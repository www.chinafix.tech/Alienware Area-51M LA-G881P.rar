# Allegro board Alienware Area-51M LA-G881P.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SUSACK#: length 33.7
  TOP w0.089: UH1.BE35 275.18,63.08 275.18,65.52 v2(275.54,65.87)
  IN2 w0.104: v2(275.49,84.1) 275.49,82.19 274.26,80.96 274.26,80 277.06,77.2 277.06,72.15 276.76,71.85 276.76,67.09 v2(275.54,65.87)
  BOTTOM w0.112: RH1016.2 280.8,84.64 v1(280.57,84.86) ; v1(280.57,84.86) 276.25,84.86 v2(275.49,84.1) ; v1(280.57,84.86) 281.72,86 RH1027.1 282.21,86.46 282.14,86.53 QH1.3
SUSCLK: length 202.4
  TOP w0.089: v2(271.07,62.51) 270.97,62.87 270.73,63.01 UH1.BE45
  IN3 w0.104: v2(333.15,42.76) 333.15,42.95 335.31,45.11 336.51,45.11 336.77,45.36 339.24,45.36 340.35,44.26 341.62,44.26 342.06,43.82 342.06,33.9 338.42,30.25 335.29,30.25 333.53,28.49 333.53,25.01 330.67,22.16 328.58,22.16 327.49,21.07 316.48,21.07 315.58,21.97 314.2,21.97 308.93,27.23 307.08,27.23 305.79,28.52 304.07,28.52 301.64,30.96 301.64,31.48 298.99,34.13 296.12,34.13 293.15,37.1 293.15,39.27 294.03,40.16 294.03,42.95 291.8,45.19 291.8,53.1 292,53.3 292,56.61 290.82,57.8 290.82,59.94 289.13,61.63 289.13,62.75 288.37,63.51 272.07,63.51 v2(271.07,62.51)
  IN4 w0.084: v2(333.15,42.76) 333.13,42.74 333.13,41.38 333.91,40.6 334.48,40.6 335.19,39.89 335.19,32.57 338.34,29.42 338.34,28.73 338.47,28.6 341.77,28.6 341.91,28.45 342.08,28.45 342.48,28.05 343.67,28.05 346.91,24.81 346.91,24.8 347.14,24.57 351.79,24.57 352.82,25.59 353.17,25.59 354.87,23.9 v2(360.64,23.9)
  BOTTOM w0.112: JSSD1.68 360.4,24.15 v2(360.64,23.9) 360.83,23.9 362.05,22.68 365.58,22.68 367.94,20.32 367.94,15.8 367.36,15.23 367.36,12.29 369.08,10.57 370.64,10.57 JSSD2.68 ; v2(333.15,42.76) 333.15,42.95 334.17,43.97 334.17,44.66 334.6,45.1 JWLAN.50
SUSP#: length 626.9
  TOP w0.112: CE205.1 267.36,83.53 UE13.4 269.13,83.26 v2(270.17,84.3) ; R174.1 337.22,21.16 337.17,21.11 R182.1 336.63,21.04 336.51,21.15 v2(336.51,21.23) ; v2(36.53,30.39) 37.97,31.84 37.97,34.26 v2(38.56,34.85) ; PR209.2 216.04,112.53 215.92,112.42 211.69,112.42 210.39,111.11 210.39,110.47 v2(210.4,110.45) 210.4,108.23 209.71,107.53 v1(207.29,107.53) 202.59,107.53 200.62,105.56 200.62,95.21 v2(200.56,95.15) ; U16.4 358.92,17.96 358.59,18.28 358.59,21.01 v2(358.42,21.18) ; UE5.116 v2(297.94,23.98)
  TOP w0.254: v2(168.86,100.55) 168.61,100.81 168.29,100.81 168.16,100.94 UZ21.3
  IN1 w0.084: v2(138.87,99.37) 138.15,99.37 133.95,95.17 133.95,88.73 131.41,86.19 129.18,86.19 127.79,84.8 126.36,84.8 125.92,85.24 123.86,85.24 123.47,85.63 123.47,85.96 123.48,85.97 123.48,89.25 121.76,90.97 111.31,90.97 110,89.67 109.81,89.47 109.81,82.87 104.01,77.07 104.01,77.06 103.95,77.01 103.95,68.05 98.22,62.31 96.79,62.31 82.23,47.76 71.69,47.76 70.59,46.65 64.92,40.99 58,40.99 57.17,41.82 57.17,42.76 54.46,45.48 v2(54.05,45.48)
  IN2 w0.104: v2(168.86,100.55) 174.69,94.73 200.14,94.73 v2(200.56,95.15) ; v2(36.53,30.39) 35.78,29.64 35.48,29.64 34.34,28.5 34.34,22.31 34.69,21.97 34.69,19.06 35.64,18.11 38.3,18.11 38.77,17.64 v2(38.77,16.19)
  IN3 w0.104: v2(28.21,55.22) 28.54,54.89 34.82,54.89 36.02,53.69 36.02,52.39 37.08,51.33 37.08,49.02 36.6,48.53 36.6,46.07 37.94,44.73 37.94,42.5 37.67,42.23 37.67,35.74 v2(38.56,34.85) ; v2(168.86,100.55) 167.97,101.45 156.67,101.45 155.93,102.19 146.64,102.19 144.02,99.57 139.06,99.57 v2(138.87,99.37) ; v2(297.94,23.98) 298.18,23.74 301.26,23.74 302.68,25.16 303.76,25.16 305.12,23.8 305.12,22.83 305.29,22.66 308.6,22.66 309.61,21.65 310.71,21.65 315.49,16.87 326.88,16.87 329.63,19.61 331.91,19.61 333.53,21.23 v2(336.51,21.23) 336.51,20.92 338.55,18.88 348.2,18.88 350.36,21.04 350.36,21.73 351.46,22.82 v2(351.69,22.82) ; v2(355.02,20.7) 357.94,20.7 v2(358.42,21.18) ; v2(277.37,34) 277.01,34.36 276.49,34.36 276.13,34 263.7,34 260.38,30.68 v2(258.17,30.68) ; v2(210.4,110.45) 211.23,109.62 216.56,109.62 217.62,108.56 219.28,108.56 219.72,109.01 236.97,109.01 238.32,110.36 259.37,110.36 262.8,106.93 269.3,106.93 274.22,102.01 274.22,97.16 274.85,96.52 274.85,89.91 270.17,85.23 v2(270.17,84.3)
  IN4 w0.084: v2(351.69,22.82) 353.27,21.24 354.47,21.24 v2(355.02,20.7) ; v2(263.19,59.54) 263.19,57.94 262.22,56.97 262.22,54.93 260.24,52.95 260.24,49.03 258.02,46.81 258.02,30.82 v2(258.17,30.68) ; v2(28.21,55.22) 28.54,54.89 43.68,54.89 48.06,54.03 50.45,51.64 50.45,48.34 52.72,46.06 53.47,46.06 v2(54.05,45.48)
  BOTTOM w0.112: v2(277.37,34) 278.92,34 281.36,31.55 283.09,31.55 288.3,26.35 288.88,26.35 292.09,23.14 294.62,23.14 295.96,24.47 297.44,24.47 v2(297.94,23.98) 297.75,23.79 Q8.3 ; JAUDIO.9 38.56,15.62 38.77,15.84 v2(38.77,16.19) ; v2(263.19,59.54) 263.19,60.93 264.66,62.39 264.66,67.41 263.55,68.52 263.55,75.59 262.76,76.39 262.76,79.2 263.52,79.96 263.52,83.07 264.74,84.3 v2(270.17,84.3) ; v2(28.21,55.22) 26.7,55.22 RT15.2
  BOTTOM w0.254: v2(168.86,100.55) 168.86,104.72 167.44,106.15 167.44,110.25 165.37,112.32 160.81,112.32 160.56,112.57 160.56,116.5 160.01,117.05 PRF01.1
SUSP#_R: length 9.8
  BOTTOM w0.102: UT1.D2 20.87,47.49 21.1,47.73 21.1,48.18 20.95,48.32 20.95,48.41
  BOTTOM w0.112: 20.95,48.41 20.93,48.44 20.93,49.35 ; RT30.2 RT15.1
  BOTTOM w0.127: 20.93,49.35 20.93,49.4 21.22,49.7 21.22,49.72 21.56,50.06 21.56,51.48 22.53,52.45 v1(23.78,52.45) 24.58,52.45 25.08,52.95 RT30.2
SW_1.2V: length 13
  IN4 w1.016: 221.87,119.26 222.48,119.26 223.29,118.45 228.44,118.45 230.22,116.67 233.77,116.67
  vias: v1(221.2,119.85) v2(220.67,119.87) v2(221.12,119.34) v2(234.78,117.05) v2(234.78,116.48)
SW_+1VALWP: length 4.7
  IN1 w1.016: 267.72,14.37 267.44,14.09 267.44,10.13 267.17,9.87
  vias: v1(265.9,20.53) v2(265.89,8.96) v2(266.37,9.27) v2(267.5,15.97) v2(267.5,15.34)
SWR_18_PG: length 1.1
  TOP w0.112: RL23.2 v1(170.21,161.95)
SWR_25_PG: length 40.6
  TOP w0.112: v2(171.73,166.34) 171.93,166.15 UL11.7 ; UL10.2 194.65,165.25 193.73,166.18 192.54,166.18 v2(192.37,166.01)
  IN2 w0.104: v2(171.73,166.34) 172.74,166.34 175.69,163.39 175.69,161.18 176.65,160.22 177.95,160.22 179.95,158.21 179.95,158.05 v2(179.36,157.45)
  IN3 w0.104: v2(192.37,166.01) 191.61,165.25 191.61,163.66 192.05,163.22 192.05,161.56 190.63,160.14 187.39,160.14 186.39,159.14 186.39,157.36 186.19,157.16 179.65,157.16 v2(179.36,157.45)
  BOTTOM w0.112: v2(192.37,166.01) 192.5,165.89 192.5,165.26 RL20.2 ; v2(179.36,157.45) v1(179.87,157.45)
SWTRAP: length 5.5
  TOP w0.112: RE685.1 RE684.2 310.43,13.67 309.43,13.67 309.22,13.46 v1(308.83,13.46) 308.15,13.46 308.14,13.48 UE5.70
SYS_PWROK: length 59.6
  TOP w0.089: UH1.AU3 291.35,59.03 291.58,58.8 292.03,58.8 292.22,58.6 292.65,58.6 292.77,58.48 293.29,58.48 293.3,58.48 v2(293.3,58.48)
  TOP w0.112: v2(299.28,19.9) 304.23,14.95 305.9,14.95 306.03,15.08 UE5.74 v3(308.96,15.08) 309.65,15.08 309.72,15.01 CE46.1
  IN4 w0.084: v2(293.3,58.48) 293.3,58.48 293.33,58.45 293.33,56.72 293.56,56.48 293.56,54.41 295,52.96 295.5,52.96 296.51,51.96 296.51,45.85 296.32,45.66 296.32,45.66 295.76,45.1 295.76,39.1 297.65,37.2 297.65,35.47 295.17,32.99 295.17,28.99 297.11,27.05 297.11,26.53 298.57,25.07 298.57,23.42 299.64,22.35 299.64,20.74 299.28,20.38 v2(299.28,19.9)
SYS_RESET#: length 13.5
  TOP w0.089: 293.8,59.29 292.41,59.29 292.14,59.02 UH1.AU2
  TOP w0.112: RH5.2 RH571.1 298.07,65.12 CH175.1 297.27,64.63 297.27,63.52 297.12,63.37 297.12,62.86 297.02,62.76 297.02,60.15 296.33,59.46 295.62,59.46 295.3,59.78 v1(294.35,59.78) 294.29,59.78 293.8,59.29
SYS_SWCLK: length 5.3
  TOP w0.127: UE1.37 v1(364.84,31.61) 365.76,31.61 v2(366.04,31.9)
  BOTTOM w0.112: v2(366.04,31.9) 366.55,31.9 366.68,31.77 JELC.4
SYS_SWDIO: length 8.1
  TOP w0.127: v2(360.84,31.96) 360.32,31.45 UE1.34
  BOTTOM w0.112: v2(360.84,31.96) v1(361.85,31.96) 365.15,31.96 365.41,31.71 JELC.2
SYSON: length 453.7
  TOP w0.112: v2(304.71,22.7) 305.84,22.7 306.08,22.93 306.08,23.2 306.35,23.48 UE5.95 308.1,23.48 308.19,23.57 309.19,23.57 CE42.2 ; v2(208.37,104.86) v1(208.37,104.38) 208.37,104.04 209,103.4 Q9.3 ; v2(77.32,20.09) 79.65,20.09 80.03,20.46 U19.4 ; v2(273.98,77.73) 273.98,79.27 v2(272.77,80.48)
  TOP w0.254: v2(218.91,109.06) 218.91,111.41 218.59,111.73 PR208.1
  IN3 w0.104: v2(218.91,109.06) 219.1,109.24 236.87,109.24 238.22,110.59 259.47,110.59 262.9,107.16 269.4,107.16 274.45,102.11 274.45,97.25 275.08,96.62 275.08,89.81 271.43,86.16 271.43,83.68 272.31,82.8 272.31,80.94 v2(272.77,80.48) ; v2(117.44,87.84) 117.69,88.1 117.69,88.97 120.56,91.83 123.29,91.83 124.24,92.79 182.79,92.79 194.45,104.44 207.95,104.44 v2(208.37,104.86)
  IN4 w0.084: v2(117.44,87.84) 117.19,88.1 117.19,98.51 108.27,107.43 v2(108.27,115.22)
  BOTTOM w0.112: v2(218.91,109.06) 218.73,109.24 215.58,109.24 211.2,104.86 v2(208.37,104.86) ; v2(77.32,20.09) 77.32,21.37 78.83,22.88 78.83,36.35 77.56,37.62 72.99,37.62 71.78,38.82 71.78,42.38 82.39,52.98 82.39,58.38 86.33,62.32 86.96,62.32 88.99,64.34 90.4,64.34 92.44,62.3 96.06,62.3 100.93,67.17 100.93,68.86 102.39,70.32 102.39,77.93 105.06,80.6 105.53,82.63 105.53,112.48 v2(108.27,115.22) ; v2(304.71,22.7) 304.69,22.7 304.02,23.37 302.16,23.37 301.36,22.57 299.72,22.57 298.63,23.65 298.63,24.34 297.79,25.18 294.81,25.18 294.13,24.5 291.4,24.5 289.08,26.83 288.49,26.83 283.29,32.03 281.6,32.03 279.6,34.03 279.6,35.69 278.96,36.33 275.58,36.33 270.08,41.83 270.08,43.81 270.15,43.89 270.15,46.99 270.06,47.09 270.06,48.32 272.29,50.56 272.29,52.88 274.39,54.98 274.39,55.61 274.67,55.89 275.01,55.89 275.39,56.27 275.73,56.27 277.14,57.68 277.14,60.42 276.74,60.82 276.49,60.82 276.24,61.07 276.24,61.49 276.57,61.82 276.57,63.02 275.11,64.49 275.11,68.4 273.39,70.11 273.39,75 273.74,75.35 273.74,77.49 v2(273.98,77.73)
TBT_A_AUX_N: length 6.1
  TOP w0.076: v2(27.46,41.25) 27.7,41.49 27.7,41.64 27.95,41.89 28.84,41.89 29.23,41.5 29.86,41.5 30.43,40.92 30.68,40.92 v1(30.95,40.66) 31.2,40.4 31.2,40.27 31.4,40.08 CT44.2
  BOTTOM w0.076: v2(27.46,41.25) 27.8,41.59 UT1.W15
TBT_A_AUX_N_C: length 24.6
  TOP w0.119: v2(36.41,50.76) 36.4,50.74 35.83,50.74 35.43,50.34 v4(35.43,48.6) 35.43,46.5 35.43,46.37 35.43,46.11 35.43,45.73 36.34,44.81 37.85,44.81 38.31,44.35 38.31,43.01 36.85,41.55 34.92,41.55 33.15,39.78 32.75,39.78 CT44.1
  BOTTOM w0.076: UT4.J2 41.72,48.57 41.47,48.82 40.77,48.82 40.46,49.12 40.46,49.7 40.08,50.08 39.75,50.08 39.24,50.58
  BOTTOM w0.119: 39.24,50.58 RT70.2 37.94,50.82 37.82,50.7 36.48,50.7 v2(36.41,50.76)
TBT_A_AUX_P: length 6
  TOP w0.076: v2(28.12,41.25) 27.96,41.42 27.96,41.53 28.06,41.63 28.73,41.63 29.12,41.23 29.75,41.23 30.06,40.92 30.32,40.66 30.55,40.66 30.94,40.27 30.94,40.17 31.29,39.81 31.56,39.81 31.87,39.5 CT43.2
  BOTTOM w0.076: v2(28.12,41.25) 28.11,41.27 28.11,41.59 28.2,41.68 28.36,41.68 UT1.Y15
TBT_A_AUX_P_C: length 24.6
  TOP w0.119: v2(36.41,50.18) 36.15,50.44 35.95,50.44 35.73,50.22 35.73,46.17 35.73,45.85 36.46,45.12 37.98,45.12 38.62,44.48 38.62,42.88 36.98,41.24 35.05,41.24 33.28,39.47 32.49,39.47 CT43.1
  BOTTOM w0.076: UT4.J1 41.36,48.51 41.36,48.4 41.28,48.32 41.11,48.32 41.01,48.42 41.01,48.47 40.92,48.56 40.66,48.56 40.2,49.01 40.2,49.59 39.97,49.82 39.44,49.82 39.24,49.62
  BOTTOM w0.119: 39.24,49.62 RT73.1 38.17,49.62 37.87,49.92 37.87,50.06 37.55,50.39 36.63,50.39 v2(36.41,50.18)
TBT_A_CC1: length 44.8
  TOP w0.112: v2(47.02,51.72) 46.77,51.72 v1(46.26,51.2)
  IN2 w0.508: v2(13.17,45.49) 14.11,45.49 14.96,46.34 14.96,49.62 17.12,51.78 24.29,51.78 26.43,53.92 29.07,53.92 29.26,53.73 29.63,53.35 42.63,53.35 43.52,52.47 43.99,52.47 44.94,51.52 46.82,51.52 v2(47.02,51.72)
  BOTTOM w0.203: UT4.L9 45.29,49.99 47.02,51.71 v2(47.02,51.72)
  BOTTOM w0.254: v2(47.02,51.72) 46.88,51.86 CT112.1
  vias: v2(6.78,44.93)
TBT_A_CC2: length 46
  TOP w0.112: v1(47.59,51.27) 47.92,51.6 v2(47.92,51.66)
  IN2 w0.508: v2(13.13,46.18) 13.89,46.18 14.33,46.61 14.33,49.88 16.86,52.41 24.02,52.41 26.17,54.56 29.33,54.56 29.9,53.99 44.55,53.99 45.52,53.02 46.76,53.02 47.65,52.12 47.65,51.93 v2(47.92,51.66)
  BOTTOM w0.203: v2(47.92,51.66) 47.92,51.56 47.34,50.97 47.34,50.92 47.21,50.79 47.21,50.74 46.56,50.09 46.1,50.09 45.79,49.78 UT4.L10
  BOTTOM w0.254: CT113.1 48.05,51.78 v2(47.92,51.66)
TBT_A_SBU1: length 58.2
  TOP w0.112: JUSBC.B8 6.42,46.48 6.63,46.68 v2(6.73,46.68) ; v1(46.96,54) 46.59,53.63 v2(46.55,53.63)
  IN2 w0.104: v2(12.03,46.56) 12.04,46.56 12.04,46.7 11.76,46.98 11.76,49.07 11.79,49.07 13.36,50.65 13.36,56.03 14.85,57.52 27.31,57.52 30.17,54.65 45.46,54.65 46.49,53.63 v2(46.55,53.63)
  BOTTOM w0.076: UT4.K8 44.79,49.18 45.04,49.43 45.04,49.67 45.02,49.7 45.02,50.06 45.96,50.99 45.96,50.99 46.48,51.51
  BOTTOM w0.112: v2(12.03,46.56) 11.98,46.51 11.86,46.51 11.72,46.37 DT13.1 10.28,46.37 9.91,46 8.94,46 8.71,46.23 7.19,46.23 v2(6.73,46.68) ; 46.48,51.51 46.48,53.56 v2(46.55,53.63)
TBT_A_SBU2: length 58.2
  TOP w0.112: JUSBC.A8 8.86,44.73 9.57,45.44 DT14.1 12.02,45.44 v2(12.6,44.85) ; v2(45.91,53.63) v1(45.38,53.63)
  IN2 w0.104: v2(45.91,53.63) 45.12,54.42 30.08,54.42 27.21,57.28 14.95,57.28 13.6,55.93 13.6,50.55 12.01,48.97 12.01,47.16 12.6,46.57 12.6,46.17 12.49,46.07 12.1,46.07 12,45.97 12,45.79 12.14,45.65 12.49,45.65 12.6,45.55 12.6,44.86 v2(12.6,44.85)
  BOTTOM w0.076: 46.18,51.51 46.18,51.44 46.07,51.33 46,51.33 44.87,50.19 44.87,49.64 UT4.L8
  BOTTOM w0.112: v2(45.91,53.63) 46.18,53.36 46.18,51.51
TBT_A_TRX_DTX_N0: length 15.7
  TOP w0.119: JUSBC.A10 8.1,43.73 arc(8.2,43.71) 8.29,43.67 8.34,43.62 arc(8.38,43.59) 8.42,43.58 8.51,43.58 arc(8.62,43.53) 8.72,43.45 9.57,42.59 arc(9.74,42.48) 9.93,42.44 10.59,42.44 arc(10.82,42.49) DT5.1 arc(11.22,42.5) 11.45,42.47 11.46,42.47 arc(11.51,42.48) 11.57,42.48 arc(11.92,42.41) 12.22,42.21 12.22,42.21 arc(12.37,41.99) 12.42,41.72 12.42,41.23 arc(12.52,40.75) 12.79,40.35 14.43,38.7 arc(14.96,38.35) 15.58,38.22 16.8,38.22 arc(16.95,38.25) v2(17.08,38.34)
  BOTTOM w0.076: 18.09,38.44 18.18,38.53 arc(18.51,38.75) 18.9,38.83 19.02,38.83 arc(19.14,38.85) 19.25,38.92 arc(19.32,38.97) 19.4,38.98 19.58,38.98 arc(19.65,38.95) 19.68,38.88 19.68,38.85 arc(19.68,38.82) 19.66,38.79 19.66,38.79 arc(19.62,38.76) 19.56,38.75 UT1.A21
  BOTTOM w0.104: 17.64,38.17 17.66,38.17 17.67,38.17 17.72,38.17 arc(17.83,38.21) 17.93,38.28 18.09,38.44
  BOTTOM w0.119: 17.64,38.17 17.36,38.17 arc(17.25,38.2) 17.16,38.26 v2(17.08,38.34)
TBT_A_TRX_DTX_N1: length 19.7
  TOP w0.119: v2(10.9,48.87) 9.27,48.87 arc(9.02,48.82) 8.82,48.68 arc(8.76,48.65) 8.7,48.63 arc(8.59,48.6) 8.46,48.59 7.26,48.59 arc(7.12,48.56) 7.01,48.48 arc(6.95,48.4) 6.91,48.3 arc(6.91,48.27) 6.91,48.25 6.91,48.22 arc(6.87,48.04) 6.77,47.9 6.53,47.65 arc(6.33,47.52) 6.11,47.48 JUSBC.B10
  BOTTOM w0.076: UT1.B15 19.79,41.36 arc(19.71,41.3) 19.61,41.28 19.34,41.28 arc(19.27,41.29) 19.21,41.33 arc(19.12,41.39) 19.02,41.41 18.95,41.41 arc(18.73,41.45) 18.55,41.57 18.47,41.65 18.31,41.81 18.16,41.96 arc(18,42.07) 17.8,42.11 17.46,42.11 17.44,42.09 17.42,42.09
  BOTTOM w0.119: v2(10.9,48.87) 10.9,48.87 arc(11.07,48.96) 11.26,48.95 arc(11.31,48.92) 11.36,48.89 arc(11.37,48.88) 11.37,48.87 12.02,48.22 12.03,48.22 arc(12.17,48.1) 12.33,48 12.34,48 arc(12.52,47.93) 12.72,47.91 arc(12.84,47.89) 12.95,47.82 DT9.1 arc(13.25,47.8) 13.46,47.84 13.77,47.84 arc(13.98,47.8) 14.16,47.68 14.21,47.62 arc(14.3,47.46) 14.33,47.29 14.33,44.85 arc(14.44,44.29) 14.76,43.81 16.18,42.39 arc(16.52,42.16) 16.92,42.09 17.42,42.09
TBT_A_TRX_DTX_P0: length 15.7
  TOP w0.119: v2(17.08,37.76) 17,37.83 arc(16.91,37.9) 16.79,37.92 15.58,37.92 arc(14.84,38.07) 14.22,38.49 12.57,40.13 arc(12.23,40.64) 12.12,41.23 12.12,41.72 arc(12.09,41.87) 12,41.99 12,42 arc(11.81,42.13) 11.57,42.17 arc(11.29,42.12) 11.05,41.96 DT4.1 arc(10.79,42.08) 10.52,42.14 9.93,42.14 arc(9.62,42.2) 9.36,42.37 8.5,43.23 arc(8.47,43.25) 8.43,43.27 8.43,43.27 arc(8.42,43.27) 8.41,43.27 8.21,43.27 arc(8.13,43.24) 8.04,43.23 JUSBC.A11
  BOTTOM w0.076: 18.3,38.24 18.3,38.24 18.3,38.26 18.3,38.26 18.37,38.33 18.37,38.35 18.37,38.35 arc(18.61,38.51) 18.9,38.57 19.28,38.57 19.35,38.54 arc(19.4,38.52) 19.45,38.52 19.61,38.52 arc(19.71,38.54) 19.79,38.6 UT1.B21
  BOTTOM w0.104: 18.3,38.24 18.13,38.07 arc(17.91,37.92) 17.64,37.87
  BOTTOM w0.119: 17.64,37.87 17.36,37.87 arc(17.21,37.84) v2(17.08,37.76)
TBT_A_TRX_DTX_P1: length 19.7
  TOP w0.119: v2(10.9,49.45) 10.83,49.38 arc(10.59,49.23) 10.32,49.17 9.27,49.17 arc(8.93,49.11) 8.64,48.93 arc(8.62,48.92) 8.6,48.92 arc(8.53,48.9) 8.46,48.89 7.26,48.89 arc(7.05,48.86) 6.86,48.76 arc(6.85,48.75) 6.84,48.74 6.74,48.64 arc(6.66,48.5) 6.61,48.35 6.61,48.22 arc(6.6,48.17) 6.58,48.13 6.49,48.05 arc(6.41,47.99) 6.32,47.98 JUSBC.B11
  BOTTOM w0.076: 17.42,42.39 17.44,42.39 17.46,42.37 17.8,42.37 arc(18.1,42.31) 18.34,42.15 18.5,41.99 18.66,41.83 18.73,41.76 arc(18.83,41.69) 18.95,41.67 19.22,41.67 arc(19.23,41.67) 19.23,41.68 arc(19.23,41.68) 19.24,41.68 19.24,41.68 arc(19.31,41.73) 19.4,41.75 19.52,41.75 arc(19.61,41.71) 19.64,41.63 19.64,41.6 arc(19.62,41.54) 19.56,41.51 UT1.A15
  BOTTOM w0.119: 17.42,42.39 16.92,42.39 arc(16.63,42.45) 16.4,42.61 14.97,44.03 arc(14.72,44.41) 14.63,44.85 14.63,47.29 arc(14.59,47.56) 14.46,47.8 arc(14.45,47.81) 14.44,47.82 14.38,47.89 arc(14.1,48.08) 13.77,48.14 13.33,48.14 arc(13.31,48.14) 13.29,48.14 arc(13.14,48.19) 13.08,48.33 DT8.1 13.06,48.35 12.88,48.24 arc(12.8,48.22) 12.72,48.21 arc(12.69,48.22) 12.66,48.22 12.59,48.23 arc(12.58,48.23) 12.57,48.23 12.56,48.24 arc(12.46,48.28) 12.38,48.33 arc(12.3,48.38) 12.24,48.44 11.59,49.09 arc(11.46,49.19) 11.32,49.25 arc(11.12,49.29) 10.94,49.4 v2(10.9,49.45)
TBT_A_TTX_C_DRX_N0: length 14.7
  TOP w0.119: JUSBC.B3 6.11,43.98 arc(6.23,43.95) 6.34,43.88 arc(6.39,43.84) 6.44,43.83 arc(6.45,43.83) 6.46,43.83 6.48,43.81 6.52,43.81 arc(6.66,43.78) 6.79,43.7 arc(6.86,43.59) 6.89,43.46 6.89,42.66 arc(6.91,42.57) 6.96,42.5 7.01,42.45 arc(7.12,42.37) 7.25,42.34 7.64,42.34 arc(7.8,42.31) 7.93,42.23 7.95,42.21 arc(8.07,42.12) 8.22,42.09 8.3,42.09 arc(8.5,42.13) 8.68,42.25 v2(8.74,42.31)
  BOTTOM w0.119: v2(8.74,42.31) arc(8.88,42.21) 9.06,42.17 9.54,42.17 arc(9.61,42.19) 9.68,42.23 arc(9.85,42.35) 10.05,42.39 10.56,42.39 arc(10.77,42.43) 10.95,42.55 DT3.1 11.1,42.55 arc(11.23,42.46) 11.39,42.43 11.71,42.43 arc(12.03,42.36) 12.3,42.18 12.67,41.81 arc(12.88,41.5) 12.95,41.12 12.95,40.36 arc(13.01,40.08) 13.17,39.84 13.55,39.46 arc(13.68,39.37) 13.83,39.34 15.22,39.34 arc(15.33,39.36) 15.41,39.42 arc(15.46,39.45) 15.5,39.47 arc(15.62,39.51) 15.75,39.52 16.76,39.52 arc(16.87,39.54) CT42.1
TBT_A_TTX_C_DRX_N1: length 17.8
  TOP w0.119: JUSBC.A3 8.11,47.23 arc(8.17,47.24) 8.22,47.27 arc(8.3,47.32) 8.4,47.34 11.22,47.34 arc(11.55,47.41) 11.84,47.6 arc(12.17,47.82) 12.57,47.9 12.6,47.9 arc(12.84,47.85) 13.05,47.72 DT7.1 arc(13.3,47.83) 13.55,47.88 13.74,47.88 arc(13.98,47.83) 14.17,47.7 14.33,47.54 arc(14.52,47.26) 14.58,46.93 14.58,44.24 arc(14.36,43.11) 13.71,42.14 13.66,42.09 arc(13.54,41.92) 13.5,41.72 13.5,41.3 arc(13.67,40.9) 14.06,40.74 14.43,40.74 arc(14.49,40.73) v2(14.55,40.69)
  BOTTOM w0.119: v2(14.55,40.69) arc(14.7,40.8) 14.88,40.83 15.64,40.83 arc(15.74,40.83) 15.84,40.81 arc(15.87,40.8) 15.9,40.79 arc(15.97,40.76) 16.04,40.72 16.18,40.63 arc(16.34,40.52) 16.53,40.48 16.65,40.48 arc(16.84,40.44) CT40.1
TBT_A_TTX_C_DRX_P0: length 14.6
  TOP w0.119: JUSBC.B2 6.11,43.48 arc(6.2,43.49) 6.28,43.55 arc(6.32,43.58) 6.38,43.59 6.52,43.59 arc(6.58,43.58) 6.63,43.54 arc(6.66,43.5) 6.67,43.46 6.67,42.66 arc(6.7,42.49) 6.8,42.34 6.85,42.29 arc(7.03,42.17) 7.25,42.12 7.64,42.12 arc(7.71,42.11) 7.77,42.07 7.79,42.05 arc(7.99,41.92) 8.22,41.87 8.3,41.87 arc(8.52,41.83) 8.71,41.7 v2(8.73,41.68)
  BOTTOM w0.119: CT41.1 16.94,39.08 arc(16.78,39.18) 16.6,39.22 15.75,39.22 arc(15.68,39.21) 15.62,39.19 arc(15.46,39.08) 15.26,39.04 13.83,39.04 arc(13.56,39.09) 13.33,39.24 12.95,39.62 arc(12.73,39.96) 12.65,40.36 12.65,41.12 arc(12.6,41.38) 12.45,41.6 12.08,41.97 arc(11.91,42.08) 11.71,42.12 11.39,42.12 arc(11.23,42.09) 11.09,42 DT2.1 arc(10.85,42.04) 10.66,42.08 10.05,42.08 arc(9.96,42.06) 9.89,42.02 arc(9.73,41.91) 9.54,41.87 9.19,41.87 arc(8.94,41.82) v2(8.73,41.68)
TBT_A_TTX_C_DRX_P1: length 17.8
  TOP w0.119: JUSBC.A2 8.16,47.73 arc(8.22,47.72) 8.27,47.7 arc(8.33,47.66) 8.39,47.65 11.22,47.65 arc(11.44,47.69) 11.62,47.82 arc(12.06,48.11) 12.57,48.21 12.67,48.21 arc(12.89,48.25) DT6.1 arc(13.3,48.23) 13.55,48.18 13.74,48.18 arc(14.09,48.11) 14.39,47.91 14.55,47.76 arc(14.8,47.38) 14.89,46.93 14.89,44.24 arc(14.64,42.99) 13.93,41.93 13.87,41.87 arc(13.83,41.8) 13.81,41.72 13.81,41.3 arc(13.88,41.12) 14.06,41.04 arc(14.29,41.09) 14.49,41.22 v2(14.55,41.28)
  BOTTOM w0.119: v2(14.55,41.28) arc(14.67,41.19) 14.82,41.14 14.82,41.14 arc(14.85,41.14) 14.88,41.14 15.64,41.14 arc(15.78,41.13) 15.92,41.1 arc(15.97,41.09) 16.01,41.07 arc(16.06,41.05) 16.12,41.02 16.12,41.02 16.37,40.87 16.4,40.84 arc(16.46,40.8) 16.53,40.79 16.7,40.79 arc(16.87,40.82) CT39.1
TBT_A_TTX_DRX_N0: length 2.6
  BOTTOM w0.076: UT1.B19 19.77,39.84 arc(19.71,39.89) 19.64,39.9 19.36,39.9 arc(19.28,39.89) 19.22,39.85 arc(19.13,39.79) 19.02,39.77 18.72,39.77 arc(18.57,39.74) 18.44,39.66 18.32,39.53 arc(18.29,39.51) 18.25,39.5 18.09,39.5
  BOTTOM w0.104: 18.09,39.5 17.8,39.5 arc(17.66,39.53) CT42.2
TBT_A_TTX_DRX_N1: length 2.5
  BOTTOM w0.076: UT1.B17 19.79,40.44 arc(19.71,40.38) 19.61,40.36 19.45,40.36 arc(19.4,40.36) 19.35,40.38 19.28,40.41 arc(19.19,40.47) 19.09,40.49 17.98,40.49 arc(17.77,40.45) CT40.2
TBT_A_TTX_DRX_P0: length 2.6
  BOTTOM w0.076: UT1.A19 19.54,39.67 arc(19.59,39.66) 19.63,39.64 arc(19.64,39.63) 19.64,39.62 19.65,39.58 arc(19.65,39.56) 19.65,39.55 19.65,39.54 arc(19.64,39.51) 19.62,39.49 19.61,39.48 arc(19.6,39.47) 19.58,39.46 19.55,39.44 arc(19.53,39.44) 19.52,39.44 19.42,39.44 arc(19.33,39.45) 19.25,39.49 19.24,39.5 arc(19.16,39.55) 19.07,39.57 18.82,39.57 arc(18.73,39.55) 18.66,39.5 18.65,39.5 18.48,39.32 18.47,39.32 18.4,39.24 18.22,39.24 18.21,39.23 18.11,39.23 18.1,39.21 18.09,39.21
  BOTTOM w0.104: 18.09,39.21 17.87,39.21 arc(17.73,39.18) 17.61,39.11 CT41.2
TBT_A_TTX_DRX_P1: length 2.5
  BOTTOM w0.076: UT1.A17 19.56,40.59 arc(19.61,40.6) 19.65,40.63 arc(19.67,40.66) 19.68,40.69 19.68,40.72 arc(19.65,40.79) 19.57,40.82 19.4,40.82 arc(19.32,40.81) 19.25,40.76 arc(19.17,40.71) 19.07,40.69 18.06,40.69 arc(17.84,40.74) 17.65,40.86 CT39.2
TBT_A_USB20_L_NB: length 19.8
  TOP w0.119: JUSBC.A7 7.84,45.23 7.94,45.32 8.27,45.32 v2(8.41,45.18)
  IN1 w0.102: v2(8.41,45.18) 8.37,45.22 7.81,45.22 7.53,45.5 7.53,47.14 8.04,47.65 9.36,47.65 10.1,48.38 10.1,51.31 12.68,53.88 12.68,55.46 12.49,55.65 11.86,55.65 v2(11.81,55.6)
  BOTTOM w0.119: v2(11.81,55.6) 12.01,55.8 12.17,55.8 12.33,55.64 DT10.4 DT10.7 13.91,55.64 14.01,55.74 14.96,55.74 15.03,55.8 15.31,55.8 15.46,55.65 LT3.3
TBT_A_USB20_L_NT: length 18.1
  TOP w0.119: JUSBC.B7 6.61,45.98 v2(6.73,46.1)
  IN1 w0.102: v2(11.81,54.1) 11.81,53.9 11.71,53.79 11.42,53.79 11.29,53.92 11.29,54.33 11.19,54.43 10.81,54.43 9.12,52.74 9.12,49.68 7.98,48.54 7.28,48.54 6.19,47.44 6.19,45.92 6.29,45.82 6.45,45.82 v2(6.73,46.1)
  BOTTOM w0.119: v2(11.81,54.1) 11.98,54.26 12.18,54.26 12.3,54.14 DT10.1 DT10.9 13.76,54.14 13.9,54.28 15.39,54.28 LT2.3
TBT_A_USB20_L_PB: length 19.8
  TOP w0.119: JUSBC.A6 7.82,45.73 7.91,45.63 8.27,45.63 v2(8.41,45.77)
  IN1 w0.102: v2(11.81,56.18) 12.04,55.95 12.61,55.95 12.98,55.59 12.98,53.76 10.41,51.18 10.41,48.26 9.49,47.34 8.17,47.34 7.84,47.01 7.84,45.63 7.94,45.53 8.17,45.53 v2(8.41,45.77)
  BOTTOM w0.119: LT3.2 15.5,56.11 14.9,56.11 14.84,56.04 14.01,56.04 13.91,56.14 DT10.6 DT10.5 12.35,56.14 12.32,56.11 11.89,56.11 v2(11.81,56.18)
TBT_A_USB20_L_PT: length 18.1
  TOP w0.119: JUSBC.B6 6.69,45.48 v2(6.73,45.51)
  IN1 w0.102: v2(6.73,45.51) 6.16,45.51 5.88,45.79 5.88,47.57 7.16,48.84 7.85,48.84 8.81,49.81 8.81,52.86 10.69,54.73 11.36,54.73 11.41,54.68 v2(11.81,54.68)
  BOTTOM w0.119: LT2.2 15.5,54.59 13.92,54.59 13.86,54.64 DT10.8 DT10.2 12.25,54.64 12.18,54.57 11.93,54.57 v2(11.81,54.68)
TBT_A_USB20_N: length 43.2
  TOP w0.119: v2(50.58,52.3) 49.75,52.3 RT112.1
  IN1 w0.102: v2(20.98,39.31) 20.98,38.43 21.26,38.15 24.23,38.15 24.97,38.89 24.97,42.06 25.32,42.41 30.4,42.41 30.58,42.23 40.94,42.23 41.11,42.06 45.15,42.06 49.91,46.82 49.91,52.08 50.13,52.3 v2(50.58,52.3)
  BOTTOM w0.076: UT1.D20 20.66,38.99 v2(20.98,39.31)
TBT_A_USB20_NB: length 37.1
  IN1 w0.102: v2(16.82,55.32) 16.73,55.32 16.58,55.47 16.58,55.61 16.74,55.78 17.03,55.78 17.13,55.88 17.6,55.88 18.19,56.46 18.19,56.87 18.79,57.48 30.48,57.48 32.87,55.09 40.26,55.09 40.54,54.81 43.66,54.81 45.23,53.24 45.23,52.48 v2(45.1,52.35)
  BOTTOM w0.076: 45.26,51.51 45.26,51.25 44.35,50.35 44.35,49.63 UT4.L7
  BOTTOM w0.119: v2(45.1,52.35) 45.26,52.19 45.26,51.51 ; v2(16.82,55.32) 16.82,55.63 16.7,55.75 16.54,55.75 16.44,55.65 LT3.4
TBT_A_USB20_NT: length 35.6
  IN1 w0.102: v2(16.71,54.05) 16.99,54.33 17.88,54.33 18.41,53.8 18.41,53.01 19.15,52.27 24.46,52.27 26.36,54.18 39.88,54.18 40.16,53.9 43.26,53.9 43.69,53.46 43.69,53.39 43.7,53.37 43.7,53.33 v2(43.66,53.29)
  BOTTOM w0.076: UT4.L6 43.85,49.63 43.85,49.75 43.91,49.81 43.91,50.69 44.32,51.1 44.32,51.37 44.3,51.39 44.3,51.48 44.28,51.5 44.28,51.51
  BOTTOM w0.119: LT2.4 16.24,54.23 16.53,54.23 v2(16.71,54.05) ; 44.28,51.51 44.28,52.24 43.94,52.58 43.94,52.75 43.83,52.86 43.29,52.86 43.15,53 43.15,53.17 43.27,53.29 v2(43.66,53.29)
TBT_A_USB20_P: length 43.2
  TOP w0.119: v2(50.58,52.88) 50.32,52.62 50.28,52.6 49.97,52.6 RT113.1
  IN1 w0.102: v2(21.62,39.32) 21.29,38.98 21.29,38.56 21.39,38.45 24.1,38.45 24.66,39.01 24.66,42.19 25.19,42.72 30.52,42.72 30.71,42.53 41.07,42.53 41.23,42.37 45.02,42.37 49.61,46.95 49.61,52.2 50,52.6 50.3,52.6 v2(50.58,52.88)
  BOTTOM w0.076: UT1.E20 21.38,38.99 21.62,39.23 v2(21.62,39.32)
TBT_A_USB20_PB: length 37.1
  IN1 w0.102: v2(45.69,52.35) 45.54,52.49 45.54,53.36 43.79,55.12 40.66,55.12 40.38,55.4 32.99,55.4 30.61,57.78 18.67,57.78 17.88,57 17.88,56.59 17.48,56.18 v2(16.87,56.18)
  BOTTOM w0.076: 45.56,51.51 45.56,51.5 45.54,51.48 45.54,51.39 45.52,51.37 45.52,51.14 44.61,50.24 44.61,49.79 44.55,49.73 44.55,49.33 44.3,49.07 UT4.K7
  BOTTOM w0.119: LT3.1 16.44,56.15 16.53,56.06 16.74,56.06 v2(16.87,56.18) ; 45.56,51.51 45.56,52.22 v2(45.69,52.35)
TBT_A_USB20_PT: length 35.6
  IN1 w0.102: v2(16.71,54.63) 18.01,54.63 18.72,53.92 18.72,53.13 19,52.86 19.28,52.58 24.33,52.58 26.24,54.48 40,54.48 40.28,54.2 43.41,54.2 44.01,53.6 44.01,53.52 v2(44.25,53.29)
  BOTTOM w0.076: UT4.K6 43.89,49.07 44.05,49.23 44.05,49.69 44.17,49.81 44.17,50.58 44.58,50.99 44.58,51.51
  BOTTOM w0.119: v2(16.71,54.63) 16.61,54.53 16.24,54.53 LT2.1 ; 44.58,51.51 44.58,52.37 44.25,52.7 v2(44.25,53.29)
TBT_CIO_PLUG_EVENT#: length 311
  TOP w0.089: v2(283.13,59.5) 283.06,59.43 UH1.AV21
  TOP w0.112: v2(53.64,34.82) v1(52.99,34.82)
  IN1 w0.084: v2(53.64,34.82) 53.87,35.05 55.52,35.05 57.09,33.48 57.09,30.16 58.03,29.22 58.78,29.22 60.31,27.69 60.31,27.33 62.44,25.2 67.95,25.2 69.2,23.95 77.24,23.95 79.15,22.04 80.04,22.04 80.93,21.16 84.02,21.16 84.45,21.58 87.86,21.58 88.15,21.87 90.1,21.87 92.61,19.35 110.3,19.35 112.78,21.83 115.88,21.83 116.05,21.66 v2(117.82,21.66)
  IN2 w0.104: v2(53.64,34.82) 53.64,34.82 52.01,34.82 45.69,41.15 42.32,41.15 41.25,42.22 40.19,42.22 38.79,43.62 38.79,44.01 37.39,45.41 36.86,45.41 36.11,46.15 36.11,47.5 33.03,50.59 30.93,50.59 30.61,50.26 28.73,50.26 27.91,49.44 v2(27.91,49.43)
  IN3 w0.104: v2(283.13,59.5) 283.66,58.97 283.66,54.3 285.19,52.77 285.19,51.5 284.72,51.03 284.72,50.66 282.67,48.61 282.67,40.73 279.76,37.82 279.76,34.98 278.32,33.55 263.57,33.55 258.73,28.71 256.54,28.71 252.47,24.64 249.22,24.64 248.77,25.09 237.39,25.09 236.94,24.64 229.86,24.64 227.24,22.02 217.4,22.02 217.16,21.79 215.67,21.79 215.67,21.78 206.27,21.78 204.98,23.07 187.92,23.07 185.96,25.02 133.54,25.02 131.44,22.92 119.08,22.92 v2(117.82,21.66)
  BOTTOM w0.076: UT1.W2 27.77,47.49 27.54,47.72 27.54,48.13 27.75,48.34 27.76,48.34 27.83,48.41
  BOTTOM w0.112: 27.83,48.41 27.91,48.49 v2(27.91,49.43)
  BOTTOM w0.127: v2(27.91,49.43) 27.91,50.08 RT29.2
TBT_DEMA0: length 3.9
  TOP w0.112: UT6.49 46.03,18.84 45.56,18.36 RT233.2 RT234.2 44.57,18.35 44.38,18.54 RT710.1
TBT_DEMA1: length 1.4
  TOP w0.112: v2(46.53,19.65) 46.53,19.5 v1(46.89,19.14)
  TOP w0.254: UT6.50 v2(46.53,19.65)
TBT_DEMB0: length 3.3
  TOP w0.112: RT239.2 RT237.2 49.55,19.08 49.24,19.39 v1(48.92,19.39) 48.64,19.39 48.03,20 UT6.53
TBT_DEMB1: length 4.2
  TOP w0.112: UT6.54 48.53,19.97 48.67,19.84 50.15,19.84 v1(50.34,19.64) 50.34,19.58 50.7,19.23 RT238.2 RT240.2
TBT_EE_CLK: length 31.5
  IN3 w0.104: v2(32.6,48.98) 32.93,48.98 33.25,48.66 35,48.66 35.16,48.5 35.16,46.79 34.88,46.51 33.81,46.51 33.3,45.99 33.3,43.99 33.81,43.48 33.81,42.57 34.16,42.22 34.16,35.78 35.55,34.39 42.78,34.39 v2(43.03,34.64)
  BOTTOM w0.112: RT52.2 32.79,48.48 32.6,48.67 v2(32.6,48.98) ; RT101.1 46.85,34.39 RT122.1 45.87,34.39 45.62,34.64 UT2.6 v2(43.03,34.64)
TBT_EE_CLK_R: length 3.4
  BOTTOM w0.094: UT1.AB4 29.37,46.79 29.81,46.79 30.18,47.16 30.36,47.16 31.5,48.31 31.77,48.31
  BOTTOM w0.112: RT52.1 31.77,48.31
TBT_EE_CS_N: length 24.4
  IN3 w0.104: v2(31.06,48.82) 31.11,48.77 31.11,47.92 30.93,47.74 30.93,47.35 31.16,47.11 31.5,47.11 32.51,46.1 32.51,43.66 32.86,43.31 32.86,42.4 33.37,41.89 33.37,34.53 33.61,34.29 34.19,34.29 35.64,32.84 v2(35.84,32.84)
  BOTTOM w0.076: UT1.AC3 29.8,47.03 30.11,47.34 30.29,47.34 31.17,48.22 31.17,48.41
  BOTTOM w0.112: RT50.2 RT100.1 ; RT50.2 UT2.1 ; RT50.2 35.72,32.73 v2(35.84,32.84) ; v2(31.06,48.82) 31.17,48.72 31.17,48.41
TBT_EE_DI: length 34.5
  IN3 w0.104: v2(30.7,48.25) 30.7,47.94 30.62,47.86 30.62,47.22 31.04,46.8 31.37,46.8 32.2,45.97 32.2,42.32 33.06,41.46 33.06,34.4 33.48,33.98 34.06,33.98 35.61,32.43 41.88,32.43 43.59,34.14 43.59,34.95 v2(43.41,35.13)
  BOTTOM w0.094: 29.78,47.26 29.38,47.26 UT1.AB3
  BOTTOM w0.102: v2(30.7,48.25) 30.66,48.22 30.66,47.99 30.19,47.52 30.04,47.52 29.78,47.26
  BOTTOM w0.112: RT98.1 v1(46,36.22) 45.7,35.91 UT2.5 43.87,35.91 43.41,35.46 v2(43.41,35.13)
TBT_EE_DO: length 24.7
  IN3 w0.104: v2(31.33,47.52) 31.52,47.52 32.81,46.23 32.81,43.79 33.32,43.28 33.32,42.37 33.68,42.02 33.68,35.51 35.28,33.91 38.28,33.91 v2(38.71,33.48)
  BOTTOM w0.102: v2(31.33,47.52) 31.08,47.26 30.72,47.26 30.39,46.93 30.21,46.93 29.85,46.57 UT1.AC4
  BOTTOM w0.112: v2(38.71,33.48) 38.61,33.37 UT2.2 RT49.2 RT99.1
TBT_EE_WP_N: length 33.4
  IN3 w0.104: v2(35.25,51.54) 34.87,51.17 34.87,49.63 35.79,48.71 35.79,45.76 34.62,44.6 34.4,44.6 34.29,44.5 34.29,42.77 35,42.07 35,40.29 36.14,39.15 v2(36.14,35.11)
  BOTTOM w0.076: UT1.V1 27.31,48.39 27.33,48.41
  BOTTOM w0.112: UT2.3 35.78,34.64 RT48.2 v2(36.14,35.11) ; v2(35.25,51.54) 35.24,51.53 34.14,51.53 33.14,52.54 28.04,52.54 27.43,51.93 27.43,51.38 27.28,51.23 27.28,49.89 27.46,49.71 27.46,49.3 27.58,49.17 27.58,48.67 27.33,48.41
TBT_ENSMB: length 4.2
  TOP w0.112: UT6.48 v1(45.53,19.3) 45.15,18.91 43.71,18.91 43.4,18.6 RT221.2 RT220.2
TBT_EQA0: length 4.7
  TOP w0.112: UT6.20 48.03,32 48.14,32.12 RT230.2 RT226.2 49.24,32.16 49.07,32.33 48.98,32.33 48.86,32.45 48.86,33.29 48.89,33.32 v1(48.89,33.87)
TBT_EQA1: length 3.6
  TOP w0.112: UT6.19 48.53,30.78 49.81,32.06 RT231.2 RT229.2 v1(51.25,32.12)
TBT_EQB0: length 4.6
  TOP w0.112: v1(41.75,20.85) 41.3,20.4 RT225.2 RT227.2 44.42,20 44.53,20.11 UT6.46
TBT_EQB1: length 5
  TOP w0.112: UT6.47 45.03,19.37 44.81,19.15 44.15,19.15 43.91,19.39 v1(43.31,19.39) 42.83,18.91 42.57,18.91 42.25,18.6 RT228.2 RT224.2
TBT_FORCE_PWR: length 292.8
  TOP w0.076: RT13.2 18.75,48.13 v2(18.63,48.25)
  TOP w0.089: UH1.Y47 269.62,50.85 269.34,50.57 v2(268.9,50.57)
  TOP w0.112: v2(53.65,35.41) 54.08,35.41 v1(54.26,35.58)
  IN1 w0.084: v2(53.65,35.41) 53.7,35.35 55.51,35.35 57.3,33.57 57.3,30.25 58.12,29.43 58.87,29.43 60.63,27.67 60.63,27.31 61.94,26 63.19,26 63.78,25.41 68.04,25.41 69.29,24.16 77.33,24.16 79.24,22.25 80.13,22.25 81.01,21.37 83.65,21.37 84.07,21.79 87.77,21.79 88.17,22.18 90.08,22.18 92.7,19.56 110.21,19.56 112.69,22.04 117.17,22.04 v2(117.2,22.06)
  IN2 w0.104: v2(53.65,35.41) 53.65,35.41 51.76,35.41 45.78,41.38 42.42,41.38 41.35,42.45 40.29,42.45 39.02,43.72 39.02,44.1 37.49,45.64 36.95,45.64 36.34,46.25 36.34,47.6 33.13,50.82 30.83,50.82 30.51,50.49 27.18,50.49 26.26,49.58 19.96,49.58 v2(18.63,48.25)
  IN3 w0.104: v2(117.2,22.06) 118.92,23.78 130.9,23.78 133.43,26.31 145.64,26.31 145.97,25.98 186.36,25.98 188.18,24.16 205.31,24.16 206.58,22.89 226.55,22.89 232.33,28.66 235.86,28.66 236.39,28.14 238.52,28.14 239.25,28.87 245.64,28.87 246.54,29.77 251.52,29.77 253.39,31.64 253.39,33.6 254.33,34.54 257.61,34.54 261.52,38.45 261.52,44.92 263.3,46.7 267.11,46.7 267.42,47.01 267.42,47.46 267.8,47.84 267.99,47.84 268.38,48.22 268.38,49.84 268.9,50.36 v2(268.9,50.57)
TBT_FORCE_PWR_R: length 4.6
  TOP w0.102: v2(22.27,46.47) 22.14,46.47 21.09,47.52 v1(20.73,47.52) 19.83,47.52 RT35.1 RT13.1 19.81,48.71 RT94.2
  BOTTOM w0.076: UT1.H4 v2(22.27,46.47)
TBT_HOLD_N: length 3.3
  BOTTOM w0.112: v1(47.34,33.36) 46.89,33.81 46.45,33.81 46.08,33.43 RT51.2 46.04,33.37 UT2.7
TBT_I2C_SCL: length 21.1
  IN1 w0.084: v2(37.49,43.82) 37.24,43.82 37.03,44.02 37.03,44.81 35.63,46.21 35.63,47.86 35.16,48.33 33.92,48.33 33.67,48.07 32.88,48.07 32.54,47.73 32.54,47.51 31.79,46.76 31.79,46.76 31.69,46.66 30.14,46.66 29.15,47.64 26.44,47.64 25.96,48.12 26,48.68 26,48.72 26.01,48.78 v2(25.99,48.82)
  BOTTOM w0.076: UT1.U2 26.85,47.57 26.63,47.78 26.63,48.09 26.44,48.28 26.3,48.28 26.17,48.41
  BOTTOM w0.112: RT721.1 38.15,43.97 38.01,43.82 v2(37.49,43.82) ; RT27.2 25.24,49.48 25.64,49.09 25.72,49.09 v2(25.99,48.82) 25.99,48.6 26.17,48.41
TBT_I2C_SCL_R: length 4
  BOTTOM w0.076: UT4.D2 41.54,45.82 40.85,45.82 40.52,45.49 40.35,45.49 40.29,45.43
  BOTTOM w0.112: 40.29,45.43 39.46,44.6 39.46,44.15 39.28,43.97 RT721.2
TBT_I2C_SDA: length 19.3
  IN1 w0.084: v2(37.49,44.4) 37.49,45 36.09,46.4 36.09,48.05 35.36,48.79 33.73,48.79 33.48,48.54 32.69,48.54 32.08,47.93 32.08,47.7 31.6,47.22 31.6,47.22 31.5,47.12 30.33,47.12 29.35,48.11 26.63,48.11 26.44,48.3 26.47,48.65 v2(26.58,48.73)
  BOTTOM w0.076: 26.82,48.41 26.85,48.38 UT1.U1
  BOTTOM w0.112: RT26.2 25.83,49.93 26.58,49.18 v2(26.58,48.73) 26.58,48.65 26.82,48.41 ; v2(37.49,44.4) 37.63,44.54 RT720.1
TBT_I2C_SDA_R: length 3.1
  BOTTOM w0.076: UT4.D1 40.55,46.07 40.29,45.81
  BOTTOM w0.112: 40.29,45.81 40.1,45.81 v1(39.91,45.62) 39.23,44.94 39.23,44.84 RT720.2
TBT_PCIE_WAKE#: length 375.7
  TOP w0.112: RT10.2 v2(28.3,51.44) ; v1(261.95,72.27) v2(261.95,71.65) RH1018.1 ; UE5.127 293.54,24.55 293.33,24.34 292.38,24.34 291.55,25.17 291.55,26.31 292.12,26.88 v2(292.12,26.89)
  IN1 w0.084: v2(53.68,36.05) 53.68,36.05 52.92,36.05 52.12,35.25 52.12,30.88 56.92,26.08 56.92,21.18 56.64,20.9 56.64,20.06 58.1,18.6 60,18.6 61.64,20.24 v2(65.28,20.24)
  IN2 w0.104: v2(28.3,51.44) 28.69,51.05 33.22,51.05 36.58,47.7 36.58,46.34 37.05,45.87 37.58,45.87 39.25,44.2 39.25,43.81 40.38,42.68 41.44,42.68 42.51,41.61 47.05,41.61 52.36,36.3 52.8,36.3 53.05,36.05 53.68,36.05 v2(53.68,36.05)
  IN3 w0.104: v2(292.12,26.89) 292.12,27.14 289.97,29.29 289.97,30.24 287.96,32.25 284.13,32.25 283.92,32.03 280.28,32.03 279.6,31.35 265.17,31.35 258.61,24.8 255.91,24.8 v2(255.58,25.13) 253.35,22.89 248.76,22.89 248.14,23.52 238.02,23.52 237.58,23.08 230.5,23.08 227.88,20.47 226.01,20.47 224.73,19.19 220.72,19.19 220.35,19.56 189.22,19.56 185.32,23.46 171.14,23.46 170.53,22.86 160.42,22.86 159.82,23.46 134.19,23.46 132.08,21.36 120.55,21.36 119.29,20.09 118.59,20.09 116.57,22.11 112.29,22.11 111.18,21 111.18,20.61 110.74,20.18 110.74,20.1 110.18,19.53 109.88,19.53 108.51,20.9 108.03,20.9 107.01,21.92 102.49,21.92 101.83,21.26 94.5,21.26 93.22,22.53 89.38,22.53 88.1,21.26 86.49,21.26 86.05,21.69 81.57,21.69 79.87,19.98 78.37,19.98 76.49,18.11 69.32,18.11 67.25,20.18 65.34,20.18 v2(65.28,20.24)
  IN4 w0.084: v2(255.58,25.13) 255.58,26.73 256.21,27.35 256.21,33.61 255.65,34.17 255.65,35.21 255.44,35.42 255.44,35.99 255.65,36.19 255.65,46.66 255.45,46.86 255.45,48.51 255.59,48.66 255.59,49.8 255.65,49.86 255.65,55.72 257.88,57.96 259.86,57.96 260.76,58.86 260.76,62.35 261.7,63.29 262.6,63.29 263.17,62.72 264.91,62.72 267.11,64.92 267.11,69.39 265.71,70.79 262.81,70.79 v2(261.95,71.65)
TBT_PCIE_WAKE_N: length 312.6
  TOP w0.076: RT10.1 RT28.2 28.89,50.3 28.89,49.47 v2(28.32,48.9)
  TOP w0.112: v2(53.65,34.24) v1(54.31,34.24)
  IN1 w0.084: v2(53.65,34.24) 56.04,34.24 56.88,33.39 56.88,30.07 57.94,29.01 58.7,29.01 60.1,27.6 60.1,27.24 62.35,24.99 67.86,24.99 69.12,23.74 77.16,23.74 79.07,21.83 79.95,21.83 80.84,20.95 84.11,20.95 84.53,21.37 87.95,21.37 88.24,21.66 90.01,21.66 92.53,19.14 110.39,19.14 112.87,21.62 115.79,21.62 116.21,21.2 v2(118.18,21.2)
  IN2 w0.104: v2(53.65,34.24) 53.64,34.24 52.27,34.24 45.61,40.89 42.25,40.89 41.15,41.99 40.1,41.99 38.56,43.53 38.56,43.91 37.29,45.18 36.76,45.18 35.86,46.08 35.86,47.4 32.9,50.35 31.03,50.35 29.57,48.9 v2(28.32,48.9)
  IN3 w0.104: v2(284.28,59.49) 283.91,59.12 283.91,54.37 285.42,52.86 285.42,51.4 284.95,50.94 284.95,50.57 283.5,49.12 283.5,46.22 282.9,45.62 282.9,40.64 279.99,37.72 279.99,34.89 278.42,33.32 263.67,33.32 258.68,28.33 256.48,28.33 252.57,24.41 249.12,24.41 248.67,24.86 237.48,24.86 237.03,24.41 229.95,24.41 227.33,21.79 218.58,21.79 217.75,20.97 216.41,20.97 215.83,21.55 206.08,21.55 204.95,22.68 187.98,22.68 185.87,24.79 170.59,24.79 169.98,24.19 160.97,24.19 160.37,24.79 133.64,24.79 131.53,22.69 119.4,22.69 118.18,21.47 v2(118.18,21.2)
  BOTTOM w0.076: UT1.W1 27.77,48.08 28.32,48.62 v2(28.32,48.9)
  BOTTOM w0.112: RT694.1 283.74,58.95 v2(284.28,59.49)
TBT_PRSNT: length 8.7
  TOP w0.112: UT6.52 47.53,19.98 47.68,19.84 RT222.2 46.7,18.63 46.41,18.34 RT223.1 46.41,17.59 46,17.19 45.71,17.19 45.42,16.91 45.42,16.75 45.3,16.63 45.3,15.83 45.05,15.58 QE65.1 44.58,15.04 v1(45.24,14.37)
TBT_RBIAS: length 4.9
  TOP w0.102: v2(22.27,45.17) 21.79,45.65 21.79,45.85 21.59,46.06 20.47,46.06 v1(19.94,45.52) 19.94,45.4 RT25.1
  BOTTOM w0.076: v2(22.27,45.17) 22.59,45.49 UT1.H6
TBT_RESET_N: length 38.6
  TOP w0.102: RT80.1 RT23.1 21.13,46.96 v2(21.62,46.47)
  TOP w0.112: v2(34.15,47.83) v1(34.15,48.39)
  IN2 w0.104: v2(21.62,46.47) 21.62,46.74 22.93,48.05 29.39,48.05 29.91,47.52 30.71,47.52 31.32,48.13 33.46,48.13 33.76,47.83 v2(34.15,47.83)
  IN4 w0.084: v2(51.21,46.82) 50.61,46.23 48.26,46.23 48.18,46.3 46.56,46.3 45.48,45.23 44.44,45.23 44.12,44.91 42.29,44.91 41.07,46.13 36.44,46.13 35.33,47.24 34.35,47.24 34.15,47.44 v2(34.15,47.83)
  BOTTOM w0.102: UT1.F4 v2(21.62,46.47)
  BOTTOM w0.112: v2(51.21,46.82) 51.17,46.78 RT102.2
TBT_RESET_N_EC: length 289.1
  TOP w0.112: v2(15.87,47.34) 16.34,47.34 16.49,47.19 RT708.1 18.99,47.19 RT23.2 ; v2(244.82,2.69) 243.54,3.97 v1(241.94,3.97) 241.8,3.97 239.7,6.07 239.7,6.7 239.95,6.96 241.17,6.96 241.76,6.37 243.59,6.37 243.91,6.69 244.51,6.69 244.72,6.91 UE10.19
  IN3 w0.104: v2(15.87,47.34) 15.83,47.34 15.26,46.77 15.26,46.52 14.83,46.09 14.83,43.38 13.96,42.5 13.96,38.93 15.14,37.75 15.14,36.09 15.64,35.59 15.64,35.03 19.47,31.2 19.47,26.91 20.36,26.02 20.36,21.45 23.35,18.46 23.35,14.73 26.03,12.06 37.45,12.06 39.27,13.89 41.16,13.89 41.79,13.26 42.17,13.26 42.42,13.51 42.78,13.51 46.59,9.69 49.79,9.69 50.61,10.51 57.02,10.51 58.26,9.27 61.46,9.27 64.69,6.05 93.5,6.05 96.5,9.05 108.5,9.05 111.5,6.04 112.08,6.04 112.08,6.05 118.82,6.05 120.95,3.92 125.05,3.92 125.27,4.15 165.45,4.15 167.45,2.15 186.39,2.15 187.06,2.82 188.63,2.82 189.31,2.15 194.44,2.15 196.44,4.15 218.5,4.15 219.57,3.08 222.03,3.08 223.1,4.15 241.19,4.15 241.74,3.6 243.19,2.15 244.27,2.15 v2(244.82,2.69)
TBT_RSENSE: length 2.4
  TOP w0.076: v2(22.92,45.17) v1(22.92,45.65)
  TOP w0.102: RT25.2 22.1,44.51 22.38,44.79 22.54,44.79 v2(22.92,45.17)
  BOTTOM w0.076: UT1.J6 v2(22.92,45.17)
TBT_RST#_R: length 407.2
  TOP w0.076: RT723.2 23.95,49.95 RT1.1 23.96,49.09 v1(23.84,48.98) 23.53,48.66 23.53,46.51 v2(23.57,46.47)
  TOP w0.112: RT733.1 280.74,78.15 280.74,79.64 281.04,79.95 281.04,80.68 281.28,80.92 UT3.4 281.28,82.13 281.05,82.36 RT693.1 279.82,82.36 v2(279.7,82.23) ; v2(42.48,16.91) 42.98,16.42 QE65.2
  IN1 w0.084: v2(36.27,22.17) 36.27,21.24 37.12,20.39 37.12,16.48 37.81,15.79 41.58,15.79 42.48,16.7 v2(42.48,16.91)
  IN2 w0.104: v2(286.92,73.68) 286.92,74.54 286.33,75.13 286.33,75.73 285.34,76.72 285.34,78.54 281.65,82.23 v2(279.7,82.23)
  IN3 w0.104: v2(292.66,26.44) 292.62,26.48 292.47,26.48 291.96,26.48 291.87,26.57 291.86,26.57 291.24,27.19 291.24,27.45 289.13,29.55 288.58,29.55 287.33,30.8 284.74,30.8 284.52,30.58 281.11,30.58 280.42,29.9 265.77,29.9 257.31,21.44 230.92,21.44 228.49,19.01 226.61,19.01 225.34,17.74 220.11,17.74 219.75,18.11 187.92,18.11 184.4,21.63 171.36,21.63 168.36,18.63 154.93,18.63 151.5,15.2 146.14,15.2 144.92,13.98 134.1,13.98 133.38,14.7 125.72,14.7 125.32,15.1 121.68,15.1 121.15,15.63 118.2,15.63 117.26,14.69 112.9,14.69 111.03,16.56 111,16.56 110.47,17.09 110.47,17.79 110.24,18.03 109.32,18.03 108.21,19.14 101.95,19.14 101.33,19.76 85.88,19.76 85.74,19.89 84.68,19.89 84.68,19.89 84.05,19.89 83.81,19.89 78.98,15.07 69.94,15.07 68.86,16.15 68.81,16.15 66.24,18.72 64.67,18.72 64.67,18.72 61.55,18.72 57.95,22.31 55.16,22.31 54.91,22.07 51.76,22.07 49.98,23.86 45.58,23.86 44.99,24.44 39.1,24.44 36.83,22.17 v2(36.27,22.17) 36.25,22.15 35.64,22.15 34.77,23.01 34.77,28 33.9,28.88 33.01,28.88 32.16,29.74 32.16,30.62 31.09,31.69 31.09,37.4 30.56,37.94 30.56,38.7 30.72,38.87 30.72,40.36 29.67,41.41 29.67,42.38 30.4,43.11 30.4,43.23 30.63,43.45 30.63,44.09 29.93,44.78 29.93,46.52 29.46,46.99 29.46,47.22 29.18,47.5 29.18,47.88 28.65,48.41 26.92,48.41 26.82,48.31 25.32,48.31 23.57,46.56 v2(23.57,46.47)
  IN4 w0.084: v2(286.92,73.68) 287.03,73.68 288.85,71.87 288.85,68.65 290.3,67.2 290.3,64.56 289.97,64.23 289.97,63.14 290.38,62.73 290.38,62.35 290.25,62.22 290.25,61.92 290.5,61.66 290.5,61.08 290.35,60.93 290.35,59.99 291.12,59.22 291.12,57.06 291.72,56.46 291.72,56.43 292.24,55.91 292.24,50.37 292.99,49.62 293.39,49.62 294.4,48.6 294.4,47.52 295.19,46.74 295.19,46.4 295,46.21 295,46.2 294.77,45.97 294.76,45.97 294.4,45.61 294.4,41.13 292.13,38.86 292.13,31.96 293.01,31.07 293.01,28.74 293.67,28.09 293.67,26.68 293.43,26.44 v2(292.66,26.44)
  BOTTOM w0.076: UT1.L4 v2(23.57,46.47)
TBT_RTD3_RST#: length 30.2
  TOP w0.089: UH1.AU24 v2(281.65,59.34)
  TOP w0.112: v2(282.04,74.33) 282.06,74.35 282.06,75.83 281.43,76.45 281.43,77.45 ; 281.43,77.45 281.43,78.12 281.15,78.4 281.15,79.47 v1(281.33,79.65) 281.39,79.7 281.84,79.7 282.02,79.88 282.02,80.41 281.91,80.53 281.91,82.17 281.93,82.19 UT3.2 ; 281.43,77.45 280.73,77.45 280.33,77.85 RT695.2
  IN1 w0.084: v2(281.65,59.34) 280.11,60.88 280.11,65.75 279.27,66.59 279.27,69.35 279.54,69.62 279.54,72.9 279.77,73.13 280.1,73.13 280.33,72.9 280.55,72.9 280.84,73.19 281.03,73.19 282.04,74.2 v2(282.04,74.33)
TBT_RXDET: length 4.4
  TOP w0.112: v1(47.72,34.44) 47.84,34.31 47.84,33.04 47.49,32.69 RT218.2 47.4,32.24 RT219.1 47.03,31.88 UT6.22
TBT_S5_OFF#: length 218.6
  TOP w0.112: v2(225.64,10.3) 220.4,10.3 219.31,11.38 188.62,11.38 179.42,2.18 167.99,2.18 164.94,5.23 127.09,5.23 126.08,4.21 120.56,4.21 116.38,8.39 95.98,8.39 93.33,5.74 73.24,5.74 v1(72.86,6.12) v2(70.45,8.53) ; v2(245.39,6.06) 245.72,6.39 UE10.21 ; v2(62.64,20.66) 60.99,20.66 60.76,20.89 59.38,20.89 CT123.1 59.34,21.69 59.34,22.38 59.21,22.5 UT8.4
  BOTTOM w0.112: v2(62.64,20.66) 61.65,19.67 61.65,14.13 63.53,12.25 63.53,7.79 64.12,7.2 69.12,7.2 v2(70.45,8.53) ; v2(245.39,6.06) 245.39,5.62 244.03,4.26 229.34,4.26 225.64,7.96 v2(225.64,10.3)
TBT_SDTH: length 51.5
  TOP w0.112: v1(17.81,49.16) 17.68,49.03 RT708.2 17.47,48.11 17.42,48.05 15.76,48.05 v2(15.74,48.08) ; v2(43.17,32.12) RT216.1 RT217.2 44.73,31.14 45.03,30.84 UT6.26
  IN2 w0.104: v2(43.17,32.12) 38.47,32.12 37.69,31.34 33.4,31.34 33.02,31.72 17.79,31.72 v2(17.77,31.75)
  IN3 w0.104: v2(17.77,31.75) 17.77,32.57 15.41,34.93 15.41,35.41 14.91,35.91 14.91,35.99 14.88,35.99 14.88,37.68 13.86,38.7 13.3,39.27 13.3,42.17 14.6,43.47 14.6,46.19 15.03,46.62 15.03,46.87 15.38,47.23 15.38,47.73 v2(15.74,48.08)
TBT_SRC_CFG1: length 4.7
  BOTTOM w0.102: 29.42,48.76 29.35,48.69 29.23,48.69 28.69,48.14 UT1.AA1
  BOTTOM w0.112: 29.75,49.35 29.75,49.09 29.42,48.76 ; v1(30.12,51.89) 30.12,50.61 29.83,50.33 RT11.1
  BOTTOM w0.127: RT11.1 29.75,49.35
TBT_SRC_HPD: length 3.1
  BOTTOM w0.076: 22.53,48.44 22.25,48.15 UT1.G1
  BOTTOM w0.112: 22.53,48.44 22.58,48.49 23.04,48.49 23.19,48.64 23.19,48.66 23.27,48.74 23.27,49.24 23.14,49.37 22.82,49.37 22.51,49.68 RT4.1
TBT_SVR_IND:
  vias: v1(22.57,55.4) v2(21.75,55.93) v2(21.75,55.34) v2(21.75,54.76) v2(21.75,54.18)
TBT_TCK: length 5.8
  TOP w0.102: RT7.2 25.62,49.46 25.62,48.58 26.19,48 26.88,48 v1(26.98,47.9) 26.98,47.61 26.75,47.39 26.75,46.53 v2(26.82,46.47)
  BOTTOM w0.102: UT1.T4 v2(26.82,46.47)
TBT_TDI: length 6.8
  TOP w0.127: RT9.2 31.62,50.13 v1(31.62,48.35) 30.97,47.69 30.53,47.69 30.26,47.42 29.72,47.42 29.22,46.91 28.57,46.91 v2(28.12,46.47)
  BOTTOM w0.076: UT1.Y4 v2(28.12,46.47)
TBT_TDO: length 5.7
  TOP w0.127: RT6.2 30.31,50.1 30.31,49.52 29.93,49.14 29.93,48.81 29.8,48.69 29.8,48.23 v1(29.42,47.85) 28.23,47.85 27.47,47.09 v2(27.47,47.08)
  BOTTOM w0.076: v2(27.47,47.08) 27.47,47.08 27.51,47.08 UT1.W4
TBT_TEST_EN: length 4.1
  TOP w0.102: v1(22,47.14) 21.34,47.81 v2(21.34,48.54) 20.67,48.54 RT17.1
  BOTTOM w0.076: UT1.E1 21.33,48.41
  BOTTOM w0.112: 21.33,48.41 21.33,48.52 21.31,48.54 v2(21.34,48.54)
TBT_TEST_PWG: length 3.3
  BOTTOM w0.076: UT1.AB5 29.37,45.89 29.87,45.89 29.93,45.95 29.93,46.13 30.37,46.57 31.63,46.57 31.77,46.43
  BOTTOM w0.112: RT18.1 31.77,46.43
TBT_TMS: length 6.2
  TOP w0.102: v2(27.47,46.47) 27.04,46.89
  TOP w0.127: 27.04,46.89 27.04,47.2 27.97,48.12 27.97,48.22 v1(28.16,48.41) 29.19,48.41 29.62,48.84 29.62,49.2 29.72,49.3 29.72,50.3 RT8.2
  BOTTOM w0.076: UT1.V4 v2(27.47,46.47)
TBT_TMU_CLK_OUT: length 3.2
  BOTTOM w0.076: 27.08,49.04 27.08,47.75 27.31,47.52 UT1.V2
  BOTTOM w0.127: RT34.1 26.5,49.94 T2.1 26.95,49.17 27.08,49.04
TBT_XTAL_25_IN: length 12.4
  IN4 w0.084: v2(25.42,29.07) 25.24,29.25 25.24,29.74 24.81,30.17 24.34,30.17 20.71,33.8 v2(20.71,36.67)
  BOTTOM w0.076: UT1.D22 20.87,38.22 21.11,37.97 21.11,37.63 20.81,37.33 20.81,37.18 20.73,37.09 20.73,36.67 v2(20.71,36.67)
  BOTTOM w0.112: RT116.1 25.55,28.92 25.42,29.04 v2(25.42,29.07)
TBT_XTAL_25_OUT: length 12.1
  IN4 w0.084: v2(24.79,29.06) 25.03,29.3 25.03,29.65 24.72,29.96 24.25,29.96 20.5,33.71 20.5,36.32 20.31,36.5 v2(20.11,36.71)
  BOTTOM w0.076: v2(20.11,36.71) 20.65,37.25 20.65,37.4 20.87,37.62 UT1.D23
  BOTTOM w0.112: v2(24.79,29.06) 24.79,28.54 RT117.1
TBTA_DEBUG1: length 2.1
  BOTTOM w0.076: UT4.L2 41.7,49.67 41.7,50.57 41.17,51.09 41.17,51.26 RT71.1
TBTA_DEBUG2: length 2.8
  BOTTOM w0.076: UT4.K2 41.54,49.32 41.54,50.5 41.02,51.03 41.02,51.14 RT72.1
TBTA_DIG_AUD_N: length 2.5
  BOTTOM w0.076: UT4.K3 42.29,49.21 42.04,49.46 42.04,51.26 RT69.1
TBTA_DIG_AUD_P: length 2.5
  BOTTOM w0.076: RT68.1 42.21,51.12 42.21,49.93 42.28,49.86 42.48,49.86 42.54,49.8 42.54,49.57 42.45,49.48 42.38,49.48 UT4.L3
TBTA_HPD: length 37.3
  TOP w0.102: RT41.1 24.54,49.63 24.27,49.35 24.27,48.77 24.46,48.58 v1(24.46,47.84) 24.22,47.6 v2(24.22,46.47)
  IN1 w0.084: v2(24.22,46.47) 23.65,47.04 23.65,49.12 24.31,49.78 25.63,49.78 26.89,51.04 33.58,51.04 33.78,51.24 34.81,51.24 34.91,51.15 35.91,51.15 36.1,51.33 36.93,51.33 37.63,50.63 39.91,50.63 40.99,49.55 42.39,49.55 42.72,49.22 45.13,49.22 47.62,46.73 47.62,45.82 47.44,45.64 v2(47.44,45.41)
  BOTTOM w0.076: UT4.C10 45.92,45.57 46.15,45.79 46.16,45.79 46.18,45.81 46.68,45.81 47.02,45.47 47.19,45.47
  BOTTOM w0.102: UT1.M4 v2(24.22,46.47)
  BOTTOM w0.127: v2(47.44,45.41) 47.4,45.41 47.34,45.47 47.19,45.47
TBTA_I2C_INT: length 36.7
  TOP w0.102: v2(22.92,46.47) 22.44,46.95 22.44,47.51 21.79,48.16 21.79,49.27 21.46,49.61 20.55,49.61 20.45,49.72 20.45,50.34 20.34,50.44
  TOP w0.112: v1(37.13,42.71) 37.49,43.07 v2(37.49,43.23) ; RT32.2 20.14,50.64 20.34,50.44
  IN3 w0.104: v2(22.92,46.47) 22.92,46.52 23.42,47.02 23.42,51.74 24.82,53.13 34.75,53.13 35.71,52.17 35.71,49.23 36.09,48.84 36.09,45.87 37.05,44.92 37.05,43.68 v2(37.49,43.23)
  BOTTOM w0.076: UT1.J4 v2(22.92,46.47)
  BOTTOM w0.112: RT722.1 38.28,43.39 38.12,43.23 v2(37.49,43.23)
TBTA_I2C_INT_R: length 3.8
  BOTTOM w0.076: 40.29,45.09 40.67,45.09 41.15,45.57 UT4.C1
  BOTTOM w0.112: 40.29,45.09 40.08,44.87 40.07,44.87 39.8,44.61 v1(39.8,43.71) 39.8,43.67 39.53,43.39 RT722.2
TBTA_I2C_SCL1_R: length 4.2
  BOTTOM w0.076: v1(43.79,42.87) 43.54,43.12 43.54,44.83 UT4.B5
  BOTTOM w0.112: v1(43.79,42.87) 43.79,42.11 RT60.2
TBTA_I2C_SDA1_R: length 3.7
  BOTTOM w0.076: UT4.A5 43.29,42.87
  BOTTOM w0.112: RT59.2 v1(42.49,42.19) 42.83,42.19 43.29,42.65 43.29,42.87
TBTA_LDO_BMC: length 5.7
  BOTTOM w0.076: UT4.E1 40.52,46.57 40.15,46.2 39.38,46.2
  BOTTOM w0.112: 38.21,45.4 37.84,45.77 37.79,45.77 37.59,45.97 36.76,45.97 v1(36.48,46.25)
  BOTTOM w0.127: CT98.1 38.21,45.4 38.58,45.77 38.95,45.77 39.38,46.2
TBTA_LSRX: length 39.1
  IN1 w0.084: v2(43.74,51.86) 43.54,51.66 43.54,51.37 43.27,51.1 42.75,51.1 41.92,51.93 40.07,51.93 38.92,53.09 26.45,53.09 25.37,52.01 25.37,51.21 25.37,51.2 25.37,51.19 24.99,50.81 23.87,50.81 23.24,51.43 21.66,51.43 20.92,50.7 18.43,50.7 17.83,50.09 17.83,46.38 18,46.21 18.14,46.21 v2(18.36,46.43)
  BOTTOM w0.076: UT4.K4 43.04,49.32 43.04,49.67 42.87,49.84 42.87,50.55 43.58,51.25 43.58,51.32 43.6,51.33
  BOTTOM w0.102: 18.09,46.46 18.33,46.46 v2(18.36,46.43) 18.47,46.53 19.45,46.53 UT1.A4
  BOTTOM w0.127: v2(43.74,51.86) 43.6,51.72 43.6,51.33 ; RT42.1 17.74,46.46 18.09,46.46
TBTA_LSTX: length 39.4
  IN1 w0.084: v2(18.24,45.69) 18.24,45.79 18.03,46 17.91,46 17.62,46.29 17.62,50.69 18.59,51.66 23.32,51.66 23.33,51.67 24.71,51.67 26.35,53.31 26.54,53.31 26.56,53.3 39,53.3 40.15,52.14 42.01,52.14 42.84,51.31 43.18,51.31 43.32,51.46 43.32,51.61 v2(43.13,51.81)
  BOTTOM w0.076: 43.34,51.5 43.34,51.23 42.71,50.6 42.71,49.78 42.8,49.68 42.8,49.58 UT4.L4
  BOTTOM w0.102: 18.09,44.88 18.17,44.96 18.17,45.37 18.19,45.4 18.19,45.65 v2(18.24,45.69) 18.43,45.69 18.85,46.11 UT1.A5
  BOTTOM w0.127: RT40.1 RT21.2 17.89,44.8 18.01,44.8 18.09,44.88 ; v2(43.13,51.81) 43.34,51.6 43.34,51.5
TBTA_MRESET: length 3.1
  BOTTOM w0.076: 47.37,46.56 46.31,46.56 UT4.E11
  BOTTOM w0.127: RT63.1 48.45,45.71 48.16,46 v1(48.1,46) 47.54,46.56 47.37,46.56

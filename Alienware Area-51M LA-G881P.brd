# Allegro board Alienware Area-51M LA-G881P.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on TOP (solid shape): 60.63,16 60.63,14.53 60.26,14.16 59.27,14.16 59.16,14.27 59.16,14.88 58.72,15.31 57.28,15.31 57.1,15.49 55.47,15.49 55.47,15.8 55.6,15.92 57.66,15.92 57.86,16.13 60.5,16.13
GND on TOP (solid shape): 142.49,129.28 142.49,125.98 142.33,125.82 141.31,125.82 141.12,125.63 141.12,125.25 140.99,125.12 137.31,125.12 137.25,125.18 137.25,129.44 137.44,129.63 142.14,129.63
GND on TOP (solid shape): 294.3,91.53 294.89,88.79 295.64,86.08 290.1,86.08 287.59,88.6 287.59,91.05 288.07,91.53
GND on TOP (solid shape): 177.01,164.72 177.01,164.27 176.72,163.98 176.72,163.28 176.65,163.21 175.78,163.21 175.42,162.84 175.15,162.84 174.96,163.04 174.15,163.04 173.96,163.23 173.96,164.04 174.13,164.21 175.81,164.21 176.37,164.77 176.96,164.77
GND on TOP (solid shape): 177.58,161.39 177.58,160.79 176.98,160.19 176.98,159.76 176.82,159.6 173,159.6 172.8,159.8 172.8,160.66 172.92,160.79 173.89,160.79 173.94,160.83 173.94,161.23 174.16,161.45 177.52,161.45
GND on TOP (solid shape): 114.01,137.82 114.01,136.36 114.71,135.66 117.88,135.66 118.26,135.28 118.26,133.88 117.18,132.8 117.18,132.4 114.58,129.79 110.67,129.79 110.29,130.17 110.29,132.71 112.99,135.41 112.99,137.88 113.05,137.95 113.88,137.95
GND on TOP (solid shape): 122,148.46 122,147.31 121.87,147.18 120.99,147.18 120.64,146.83 120.64,145.35 120.57,145.28 119.81,145.28 119.56,145.54 119.56,147.44 120,147.89 120.69,147.89 120.86,148.05 120.86,148.47 120.95,148.56 121.89,148.56
GND on TOP (solid shape): 265.77,72.15 265.77,70.95 265.7,70.89 265.12,70.89 265.04,70.89 264.87,70.71 264.87,68.05 264.75,67.94 264.13,67.94 263.69,68.38 263.69,68.83 263.6,68.92 263.6,72.09 263.86,72.35 265.56,72.35
GND on TOP (solid shape): 123.14,151.4 123.14,149.76 123,149.62 121.52,149.62 120.67,148.77 120.67,148.14 120.58,148.05 119.18,148.05 119.12,148.12 119.12,150.26 119.46,150.61 120.53,150.61 120.79,150.87 121.81,150.87 122,151.06 122,151.43 122.11,151.54 123,151.54
GND on TOP (solid shape): 240.06,121.94 240.06,119.91 239.87,119.72 236.88,119.72 236.57,120.04 236.57,120.99 236.25,121.31 234.98,121.31 234.66,120.99 224.76,120.99 224.45,121.3 224.45,122.34 224.59,122.48 239.53,122.48
GND on TOP (solid shape): 113.38,171.03 113.38,170.78 113.43,170.73 114.33,170.73 114.44,170.62 114.44,170.32 114.36,170.24 113.64,170.24 113.64,170.24 113.57,170.17 113.57,169.57 113.44,169.44 112.87,169.44 112.74,169.57 112.74,170.08 112.49,170.33 112.49,171.05 112.53,171.09 113.32,171.09
GND on TOP (solid shape): 126.9,138.83 126.9,136.74 125.82,135.66 125.82,133.52 125.63,133.33 124.34,133.33 124.18,133.5 124.18,135.74 123.78,136.14 122.09,136.14 121.69,136.54 121.69,138.55 121.72,138.58 121.72,138.93 121.85,139.06 122.17,139.06 122.2,139.09 126.64,139.09
GND on TOP (solid shape): 152.37,136.95 152.37,129.56 152.22,129.41 151.56,129.41 150.88,130.1 150.01,130.1 149.5,130.61 149.5,135.43 149.83,135.76 150.96,135.76 151.15,135.95 151.15,137.21 151.31,137.36 151.97,137.36
GND on TOP (solid shape): 19.58,44.99 19.58,44.59 19.4,44.41 19.4,44.33 19.38,44.3 19.38,43.42 19.35,43.39 18.72,43.39 18.54,43.56 18.55,43.84 18.35,44.04 18.35,44.97 18.42,45.04 19.53,45.04
GND on TOP (solid shape): 191.59,165.48 191.63,165.45 191.63,164.1 191.17,163.64 191.16,163.65 191.08,163.61 191.04,163.6 190.99,163.59 190.95,163.59 190.91,163.6 190.87,163.61 190.84,163.63 190.04,163.63 189.89,163.77 189.89,164.44 189.95,164.49 190.67,164.49 190.74,164.56 190.74,165.36 190.86,165.49 191.57,165.49
GND on TOP (solid shape): 200.85,138.65 200.85,136.81 201.09,136.57 201.09,135.95 201.43,135.61 202.39,135.61 202.79,135.2 202.79,132.89 202.45,132.55 200.83,132.55 200.71,132.43 200.71,131.04 200.28,130.6 199.59,130.6 199.45,130.74 199.45,132.27 199.35,132.37 199.35,138.84 199.56,139.05 200.45,139.05
GND on TOP (solid shape): 324.21,43.79 324.21,39.47 324.08,39.34 324.08,37.95 324.33,37.69 324.33,34.72 324.03,34.41 321.09,34.41 320.77,34.73 320.77,36.57 320.89,36.7 321.82,36.7 322.1,36.98 322.1,37.87 321.72,38.25 320.55,38.25 320.19,37.89 318.93,37.89 318.72,38.1 318.72,38.84 318.95,39.06 318.95,42.16 319.2,42.42 320.22,42.42 320.52,42.72 320.52,44.4 320.67,44.55 323.44,44.55
GND on TOP (solid shape): 270.3,41.61 270.66,41.61 270.72,41.55 270.72,41.38 270.14,40.81 270.15,40.8 270.15,40.28 270.06,40.18 269.48,40.18 267.59,38.29 267.51,38.24 267.45,38.15 267.3,38.01 267.3,36.88 267.11,36.69 266.4,36.69 266.32,36.77 266.32,38.17 266.41,38.25 266.44,38.25 268.37,40.19 268.37,40.22 268.42,40.26 268.42,41.81 268.58,41.97 268.91,41.97 269.06,42.11 269.8,42.11
GND on TOP (solid shape): 9,32.2 2.7,32.2 2.7,33.1 2.41,33.81 1.7,34.1 1,34.1 0.29,34.39 0,35.1 0,40.2 9,40.2
GND on TOP (solid shape): 10.5,51 0,51 0,53 1.5,53 2.21,53.29 2.5,54 2.5,58 2.79,58.71 3.5,59 10.5,59
GND on TOP (solid shape): 385,35.7 385.6,35 386.37,35.5 394.22,35.5 394.6,35.12 394.6,29.88 394.22,29.5 386.37,29.5 386.28,29.69 386.14,29.85 385.45,29.96 385.01,29.43 385,29.36 385,29.3 385,28.22 380.71,28.22 380.33,28.6 380.33,36.41 380.78,36.85 385,36.85
GND on TOP (solid shape): 220,198.8 221.27,198.27 221.8,197 221.8,194.3 221.27,193.03 220,192.5 219.1,192.5 218.25,192.15 217.9,191.3 217.9,185.76 214.02,185.76 213.45,186.33 213.45,187.19 213.92,187.41 214.11,187.89 214.11,198.8
GND on TOP (solid shape): 153.89,55 153.89,51.46 153.89,50.32 153.69,50.12 153.63,50.09 153.57,50.1 153.55,50.16 153.36,50.5 153.06,50.23 153.03,50.14 152.94,50.12 152.59,49.98 152.6,49.61 152.6,49.5 152.51,49.44 152.3,49.44 152.21,49.5 152.21,49.6 151.93,50.11 151.66,49.6 151.66,49.5 151.57,49.44 150.97,49.44 150.77,49.64 150.77,50.82 151.01,51.06 151.31,51.06 151.39,51.13 151.39,51.75 150.92,52.22 150.92,55.01 151.12,55.21 153.68,55.21
GND on TOP (solid shape): outline of 122 points within 343.71,19.09 349.56,23.27
GND on TOP (solid shape): outline of 126 points within 0.22,29.8 9.74,57.83
GND on TOP (solid shape): 395.5,11 395.85,10.15 396.7,9.8 397.4,9.8 397.96,9.56 398.2,9 398.2,2 397.67,0.73 396.4,0.2 391.38,0.2 391.38,3.1 389.5,3.1 389.5,8.26 389.29,8.77 388.78,8.96 388.78,9.42 389.61,9.09 389.96,8.26 389.96,3.56 391.84,3.56 391.84,0.66 396.4,0.66 397.35,1.05 397.74,2 397.74,9 397.64,9.24 397.4,9.34 396.7,9.34 395.53,9.83 395.04,11 395.04,13.7 395.5,13.7
GND on TOP (solid shape): outline of 208 points within 172.32,143.31 177.79,148.79
GND on TOP (solid shape): outline of 209 points within 172.32,128.31 177.79,133.79
GND on TOP (solid shape): outline of 237 points within 0.2,3.2 20.41,16.89
GND on TOP (solid shape): 217.9,183.3 217.66,182.74 217.1,182.5 216.7,182.5 215.85,182.15 215.5,181.3 215.5,137.41 215.12,136.31 211.88,134.17 211,131.6 211,127.8 212.23,124.83 215.2,123.6 292.7,123.6 293.97,123.07 294.5,121.8 294.5,100 315.93,61.11 360.26,58.46 361.03,58.41 361.4,57.74 361.4,57.5 361.75,56.65 362.6,56.3 369.6,56.3 370.45,56.65 370.8,57.5 370.8,58 371.04,58.56 371.6,58.8 392.7,58.8 393.97,58.27 394.5,57 394.5,50.11 394.04,50.11 394.04,57 393.65,57.95 392.7,58.34 371.6,58.34 371.36,58.24 371.26,58 371.26,57.5 370.77,56.33 369.6,55.84 362.6,55.84 361.43,56.33 360.94,57.5 360.94,57.74 360.78,58.02 360.45,58.04 315.69,60.72 294.04,100 294.04,121.8 293.65,122.75 292.7,123.14 215.2,123.14 211.91,124.5 210.54,127.8 210.54,131.6 211.52,134.45 214.03,136.11 214.76,136.59 215.04,137.41 215.04,181.3 215.53,182.47 216.7,182.96 217.1,182.96 217.34,183.06 217.44,183.3 217.44,186.51 217.9,186.51
GND on TOP (solid shape): outline of 162 points within 0.2,29.75 197.32,199.9
GND on TOP (solid shape): outline of 198 points within 0.2,0.2 367.9,15.25
GND on BOTTOM (solid shape): 6,43.6 1,43.6 1,47.6 6,47.6
GND on BOTTOM (solid shape): 34.76,21.79 34.76,19.83 34.18,19.25 31.94,19.25 31.85,19.33 31.85,22.05 31.94,22.13 34.42,22.13
GND on BOTTOM (solid shape): 129.87,141.22 129.87,139.44 129.68,139.25 128.66,139.25 128.54,139.38 128.54,141.29 128.66,141.41 129.68,141.41
GND on BOTTOM (solid shape): 141.5,128.98 141.5,125.78 140.84,125.12 137.31,125.12 137.13,125.3 137.13,128.88 137.64,129.39 141.1,129.39
GND on BOTTOM (solid shape): 159.89,104.72 159.89,102.97 159.79,102.87 157.78,102.87 157.68,102.97 157.68,104.77 157.71,104.8 159.82,104.8
GND on BOTTOM (solid shape): 126.99,138.94 126.99,136.7 126.39,136.1 123.6,136.1 121.75,137.95 121.75,138.96 121.94,139.15 126.77,139.15
GND on BOTTOM (solid shape): 131.86,148.07 131.86,147.52 131.67,147.34 129.79,147.34 129.62,147.51 129.62,148.18 129.67,148.23 131.69,148.23
GND on BOTTOM (solid shape): 131.98,135.28 131.98,132.56 131.85,132.43 129,132.43 128.91,132.52 128.91,133.64 128.72,133.83 128.72,135.32 128.82,135.42 131.83,135.42
GND on BOTTOM (solid shape): 154.25,65.38 154.25,63.1 154.1,62.95 142.71,62.95 142.46,63.21 142.46,65.3 142.84,65.68 153.95,65.68
GND on BOTTOM (solid shape): 160.07,108.91 160.07,107.9 159.84,107.67 157.91,107.67 157.73,107.85 157.73,108.84 157.94,109.04 158.83,109.04 159,109.22 159.77,109.22
GND on BOTTOM (solid shape): 46.38,37.79 46.23,37.64 44.37,37.64 44.04,37.97 44.04,38.35 44.27,38.58 44.86,38.58 45.11,38.83 45.11,42.34 45.16,42.39 46.38,42.39
GND on BOTTOM (solid shape): 153.83,59.52 153.83,57.17 153.64,56.98 151.39,56.98 150.75,56.35 146.58,56.35 146.01,56.92 143.6,56.92 143.19,57.33 143.19,59.49 143.34,59.65 153.7,59.65
GND on BOTTOM (solid shape): 360.37,53.45 360.37,50.62 360.07,50.32 357.08,50.32 357.02,50.38 357.02,51.97 357.12,52.07 358.62,52.07 358.7,52.14 358.7,53.55 358.83,53.68 360.14,53.68
GND on BOTTOM (solid shape): 108.51,78.13 108.51,75.82 108.67,75.65 108.67,73.94 108.61,73.87 108.29,73.87 108.1,74.06 107.74,74.06 107.73,74.07 107.56,74.24 107.56,74.79 106.81,75.55 106.81,78.17 106.96,78.32 108.32,78.32
GND on BOTTOM (solid shape): 159.94,116.58 159.94,115.21 159.79,115.06 159.61,115.06 159.56,115.01 159.56,114.09 159.46,113.99 158.83,113.99 158.77,114.04 158.77,114.78 158.42,115.14 158.42,116.58 158.47,116.63 159.89,116.63
GND on BOTTOM (solid shape): 294.22,91.99 294.9,88.73 295.82,85.52 287.17,85.52 286.2,86.49 286.2,90.36 287.84,91.99
GND on BOTTOM (solid shape): 145.25,19.81 145.25,19.18 145.55,18.88 149.24,18.88 149.29,18.83 149.29,17.79 149.21,17.71 148.5,17.71 148.4,17.61 148.4,16.88 148.32,16.8 142.7,16.8 142.51,16.99 142.51,19.42 142.69,19.59 143.29,19.59 143.7,20.01 145.05,20.01
GND on BOTTOM (solid shape): 239.81,21.99 239.81,18.12 240.06,17.87 240.06,15.58 239.87,15.39 237.77,15.39 237.65,15.52 237.65,18.12 237.52,18.25 235.55,18.25 235.3,18.5 235.3,18.82 234.98,19.14 234.47,19.14 234.22,19.39 234.22,21.3 235.3,22.38 239.42,22.38
GND on BOTTOM (solid shape): 153,71.55 153,70.13 153.19,69.94 154.22,69.94 154.36,69.8 154.36,67.74 154.27,67.65 153.92,67.65 153.8,67.77 153.8,68.19 153.7,68.29 143.89,68.29 143.48,68.71 143.48,71.59 143.63,71.74 152.81,71.74
GND on BOTTOM (solid shape): 115.28,79.53 117.18,79.53 117.37,79.33 117.37,74.74 116.42,73.78 114.05,73.78 113.77,73.51 113.77,69.95 113.61,69.8 112.78,69.8 112.62,69.95 112.62,70.48 112.45,70.66 111.91,70.66 111.71,70.86 111.71,74.7 111.53,74.88 111.53,79.72 111.63,79.81 111.63,80.57 111.72,80.67 114.13,80.67
GND on BOTTOM (solid shape): 18.5,53.41 18.5,49.98 19.65,48.83 19.65,48.6 19.8,48.45 19.8,48.4 20.04,48.16 20.04,47.4 20.05,47.39 20.04,47.38 20.03,47.39 19.9,47.39 19.78,47.51 19.72,47.64 19.59,47.71 19.52,47.77 19.14,47.77 19.08,47.82 19.02,47.85 19.02,48.34 18.69,48.66 18.21,48.66 18.01,48.86 17.2,48.86 16.98,49.08 16.98,53.34 17.09,53.46 17.41,53.46 17.42,53.46 17.49,53.46 17.75,53.72 18.2,53.72
GND on BOTTOM (solid shape): 156.34,118.18 156.34,115.65 156.26,115.65 155.98,115.38 155.88,115.31 155.82,115.21 155.62,115.02 155.62,114.68 155.6,114.65 155.6,113.54 155.69,113.45 155.74,113.45 156.03,113.15 156.03,112.04 155.93,111.94 155.65,111.94 155.57,111.86 155.57,110.49 155.52,110.44 155.32,110.44 155.27,110.49 155.27,111.86 155.19,111.94 154.96,111.94 154.86,112.04 154.86,113.43 154.8,113.5 154.8,115.28 154.74,115.34 154.74,116.55 154.74,116.55 154.98,116.78 154.98,117.01 154.99,117.02 154.99,117.63 154.89,117.73 154.23,117.73 154.15,117.8 154.15,118.79 154.3,118.95 155.57,118.95
GND on BOTTOM (solid shape): 385,35.7 385.6,35 386.37,35.5 394.22,35.5 394.6,35.12 394.6,29.88 394.22,29.5 386.37,29.5 386.28,29.69 386.14,29.85 385.45,29.96 385.01,29.43 385,29.36 385,29.3 385,28.22 380.71,28.22 380.33,28.6 380.33,36.41 380.78,36.85 385,36.85
GND on BOTTOM (solid shape): 111.03,140.32 112.2,137.5 111.01,134.65 108.15,133.5 106.66,133.5 103.7,133.5 103.7,141.5 108.21,141.5
GND on BOTTOM (solid shape): 220,198.8 221.27,198.27 221.8,197 221.8,194.3 221.27,193.03 220,192.5 219.1,192.5 218.25,192.15 217.9,191.3 217.9,185.76 214.02,185.76 213.45,186.33 213.45,187.19 213.92,187.41 214.11,187.89 214.11,198.8
GND on BOTTOM (solid shape): 26.93,32.22 26.93,31.71 26.87,31.64 25.2,31.64 25.2,31.65 24.75,31.65 24.66,31.56 24.66,30.78 22.41,30.78 21.98,30.6 21.81,30.18 21.81,22.58 21.98,22.15 22.41,21.98 27.01,21.98 27.43,22.15 27.61,22.58 27.61,30.18 27.43,30.6 27.01,30.78 24.73,30.78 24.73,31.38 27.01,31.38 27.86,31.02 28.21,30.18 28.21,22.58 27.86,21.73 27.01,21.38 20.36,21.38 19.58,22.16 19.58,32.43 20.04,32.89 26.25,32.89
GND on BOTTOM (solid shape): outline of 125 points within 0.22,32.34 9.74,57.83
GND on BOTTOM (solid shape): 395.5,11 395.85,10.15 396.7,9.8 397.4,9.8 397.96,9.56 398.2,9 398.2,2 397.67,0.73 396.4,0.2 391.38,0.2 391.38,3.1 389.5,3.1 389.5,8.26 389.29,8.77 388.78,8.96 388.78,9.42 389.61,9.09 389.96,8.26 389.96,3.56 391.84,3.56 391.84,0.66 396.4,0.66 397.35,1.05 397.74,2 397.74,9 397.64,9.24 397.4,9.34 396.7,9.34 395.53,9.83 395.04,11 395.04,13.7 395.5,13.7
GND on BOTTOM (solid shape): outline of 162 points within 0.2,29.75 197.31,199.9
GND on BOTTOM (solid shape): outline of 110 points within 210.54,50.63 394.5,198.8
GND on BOTTOM (solid shape): outline of 198 points within 0.2,0.2 367.9,15.25
GND on IN1 (solid shape): 385,35.7 385.6,35 386.37,35.5 394.22,35.5 394.6,35.12 394.6,29.88 394.22,29.5 386.37,29.5 386.28,29.69 386.14,29.85 385.45,29.96 385.01,29.43 385,29.36 385,29.3 385,28.22 380.71,28.22 380.33,28.6 380.33,36.41 380.78,36.85 385,36.85
GND on IN1 (solid shape): outline of 101 points within 0.22,29.87 9.74,57.83
GND on IN1 (solid shape): 395.5,11 395.85,10.15 396.7,9.8 397.4,9.8 397.96,9.56 398.2,9 398.2,2 397.67,0.73 396.4,0.2 391.38,0.2 391.38,3.1 389.5,3.1 389.5,8.26 389.29,8.77 388.78,8.96 388.78,9.42 389.61,9.09 389.96,8.26 389.96,3.56 391.84,3.56 391.84,0.66 396.4,0.66 397.35,1.05 397.74,2 397.74,9 397.64,9.24 397.4,9.34 396.7,9.34 395.53,9.83 395.04,11 395.04,13.7 395.5,13.7
GND on IN1 (solid shape): outline of 162 points within 0.2,29.75 197.33,199.9
GND on IN1 (solid shape): outline of 100 points within 210.54,50.62 394.5,198.8
GND on IN1 (solid shape): outline of 207 points within 0.2,0.2 367.9,16.82
GND on IN2 (solid shape): 385,35.7 385.6,35 386.37,35.5 394.22,35.5 394.6,35.12 394.6,29.88 394.22,29.5 386.37,29.5 386.28,29.69 386.14,29.85 385.45,29.96 385.01,29.43 385,29.36 385,29.3 385,28.22 380.71,28.22 380.33,28.6 380.33,36.41 380.78,36.85 385,36.85
GND on IN2 (solid shape): outline of 124 points within 0.22,32.34 9.74,57.83
GND on IN2 (solid shape): 395.5,11 395.85,10.15 396.7,9.8 397.4,9.8 397.96,9.56 398.2,9 398.2,2 397.67,0.73 396.4,0.2 391.38,0.2 391.38,3.1 389.5,3.1 389.5,8.26 389.29,8.77 388.78,8.96 388.78,9.42 389.61,9.09 389.96,8.26 389.96,3.56 391.84,3.56 391.84,0.66 396.4,0.66 397.35,1.05 397.74,2 397.74,9 397.64,9.24 397.4,9.34 396.7,9.34 395.53,9.83 395.04,11 395.04,13.7 395.5,13.7
GND on IN2 (solid shape): outline of 162 points within 0.2,29.75 197.33,199.9
GND on IN2 (solid shape): outline of 100 points within 210.54,50.63 394.5,198.8
GND on IN2 (solid shape): outline of 198 points within 0.2,0.2 367.9,15.25
GND on IN3 (solid shape): 385,35.7 385.6,35 386.37,35.5 394.22,35.5 394.6,35.12 394.6,29.88 394.22,29.5 386.37,29.5 386.28,29.69 386.14,29.85 385.45,29.96 385.01,29.43 385,29.36 385,29.3 385,28.22 380.71,28.22 380.33,28.6 380.33,36.41 380.78,36.85 385,36.85
GND on IN3 (solid shape): outline of 129 points within 0.22,32.34 9.74,57.83
GND on IN3 (solid shape): 395.5,11 395.85,10.15 396.7,9.8 397.4,9.8 397.96,9.56 398.2,9 398.2,2 397.67,0.73 396.4,0.2 391.38,0.2 391.38,3.1 389.5,3.1 389.5,8.26 389.29,8.77 388.78,8.96 388.78,9.42 389.61,9.09 389.96,8.26 389.96,3.56 391.84,3.56 391.84,0.66 396.4,0.66 397.35,1.05 397.74,2 397.74,9 397.64,9.24 397.4,9.34 396.7,9.34 395.53,9.83 395.04,11 395.04,13.7 395.5,13.7
GND on IN3 (solid shape): outline of 162 points within 0.2,29.75 197.31,199.9
GND on IN3 (solid shape): outline of 100 points within 210.54,50.63 394.5,198.8
GND on IN3 (solid shape): outline of 198 points within 0.2,0.2 367.9,15.25
GND on IN4 (solid shape): 385,35.7 385.6,35 386.37,35.5 394.22,35.5 394.6,35.12 394.6,29.88 394.22,29.5 386.37,29.5 386.28,29.69 386.14,29.85 385.45,29.96 385.01,29.43 385,29.36 385,29.3 385,28.22 380.71,28.22 380.33,28.6 380.33,36.41 380.78,36.85 385,36.85
GND on IN4 (solid shape): outline of 128 points within 0.22,32.34 9.74,57.83
GND on IN4 (solid shape): 395.5,11 395.85,10.15 396.7,9.8 397.4,9.8 397.96,9.56 398.2,9 398.2,2 397.67,0.73 396.4,0.2 391.38,0.2 391.38,3.1 389.5,3.1 389.5,8.26 389.29,8.77 388.78,8.96 388.78,9.42 389.61,9.09 389.96,8.26 389.96,3.56 391.84,3.56 391.84,0.66 396.4,0.66 397.35,1.05 397.74,2 397.74,9 397.64,9.24 397.4,9.34 396.7,9.34 395.53,9.83 395.04,11 395.04,13.7 395.5,13.7
GND on IN4 (solid shape): outline of 162 points within 0.2,29.75 197.33,199.9
GND on IN4 (solid shape): outline of 100 points within 210.54,50.64 394.5,198.8
GND on IN4 (solid shape): outline of 198 points within 0.2,0.2 367.9,15.25
GND on TOP: 143.03,76.86 144.04,76.86 144.23,76.67 144.23,73.11 144.11,72.98 142.39,72.98 141.82,73.56 141.82,74.32 142.01,74.51 143.09,74.51 143.34,74.76 143.34,75.27 143.15,75.46 142.65,75.46 142.52,75.59 142.52,75.97 142.96,76.41 142.96,76.79
GND on TOP: 109.56,39.08 109.56,37.3 108.29,36.03 108.29,32.28 108.26,32.25 108.26,30.79 108.1,30.63 106.77,30.63 105.94,31.46 105.94,36.09 104.55,37.49 104.16,37.49 104.04,37.62 104.04,39.33 104.16,39.46 109.18,39.46
GND on TOP: 79.46,17.3 78,17.3 77.94,17.23 77.94,13.1 78.07,12.98 78.38,12.98 78.64,13.23 79.46,13.23 79.65,13.42 79.65,17.1
GND on TOP: 173.7,135.15 176.94,135.15 177.45,134.64 177.45,133.31 178.27,132.48 178.27,127.34 178.72,126.9 178.72,125.63 177.51,124.42 172.81,124.42 169.96,127.28 169.96,131.47 171.35,132.87 171.35,134.77 171.8,135.21 173.64,135.21
GND on TOP: 155.92,73.18 156.18,73.18 156.56,72.79 157.83,72.79 157.89,72.73 157.89,72.03 157.76,71.91 155.99,71.91 155.73,72.16 155.73,72.98
GND on TOP: 134.1,165.63 139.82,165.63 140.68,164.77 140.68,155.73 140.33,155.37 139.71,155.37 139.39,155.06 139.39,154.25 139.18,154.04 138.45,154.04 137.56,154.94 132.54,154.94 132.23,155.24 132.23,163.22 132.44,163.42 132.9,163.42 133.29,163.81 133.29,164.82
GND on TOP: 114.39,79.4 119.15,79.4 119.4,79.14 119.4,78.32 119.34,78.26 117.5,78.26 117.25,78 117.25,74.7 116.48,73.94 113.44,73.94 112.29,75.08 112.29,77.3
GND on TOP: 172.11,150.01 177.45,150.01 178.08,149.38 178.08,147.34 179.48,145.95 179.48,142.96 178.34,141.82 171.61,141.82 171.1,142.33 171.1,146.45 172.18,147.53 172.18,149.12 171.92,149.38 171.92,149.82
GND on TOP: 101.75,56.73 102.77,56.73 102.89,56.6 102.89,55.01 103.02,54.89 103.02,53.87 102.7,53.55 101.75,53.55 101.56,53.74 101.56,56.54
GND on TOP: 128.67,164.06 127.64,164.06 127.54,163.96 127.54,163.67 127.69,163.53 127.69,161.89 127.83,161.74 128.58,161.74 128.71,161.87 128.71,164.02
GND on TOP: 178.95,160.3 178.93,160.31 178.63,160.31 178.23,160.72 178.23,161.47 178.27,161.52 179.15,161.52 179.16,161.51 180.03,161.51 180.21,161.69 183.25,161.69 183.26,161.69 184.1,161.69 184.38,161.97 184.38,162.36 184.43,162.41 184.94,162.41 185.04,162.3 185.04,161.49 185.48,161.05 185.48,160.53 185.4,160.44 181.81,160.44 181.36,159.99 180,159.99 179.69,160.3
GND on TOP: 140.61,15.01 141.5,15.01 141.63,14.88 141.63,13.1 142.07,12.66 145.25,12.66 145.38,12.53 145.38,11.45 145.31,11.39 142.26,11.39 140.49,13.17 140.49,14.88
GND on TOP: 224.66,104.26 224.55,104.14 222.16,104.14 221.86,104.45 221.86,104.47 219.42,106.9 219.42,108.84 220.08,109.5 227.17,109.5 228.44,108.23 228.44,104.52 228.18,104.26
GND on TOP: 152.26,59.75 151.4,59.75 151.38,59.73 146.6,59.73 146.39,59.52 146.39,59.33 146.58,59.14 146.58,56.54 146.9,56.22 152.81,56.22 153,56.41 157.7,56.41 158.08,56.03 158.46,56.03 158.58,56.16 158.58,58.95 158.39,59.14 157.82,59.14 157.63,58.95 153.06,58.95
GND on TOP: 150.83,119.52 148.73,119.52 148.51,119.29 148.51,118.21 148.61,118.1 149.22,118.1 149.29,118.04 150.81,118.04 150.88,118.12 150.88,119.47
GND on TOP: 104.8,47.9 107.4,47.9 107.59,47.71 108.1,47.71 108.29,47.9 111.09,47.9 111.47,47.52 111.47,45.93 110.83,45.3 108.48,45.3 108.1,44.92 108.1,41.49 107.91,41.3 106.83,41.3 106.7,41.17 106.7,40.28 106.58,40.16 105.94,40.16 105.85,40.25 105.85,41.77 105.69,41.93 105.69,45.43 104.67,46.44 104.67,47.78
GND on TOP: 132.74,31.52 130.77,31.52 130.52,31.27 130.52,27.58 130.77,27.33 133.25,27.33 133.37,27.46 133.37,30.88
GND on TOP: 147.66,77.49 148.36,77.49 148.55,77.3 148.55,75.72 148.61,75.65 149.38,75.65 149.63,75.4 149.63,73.81 149.82,73.62 150.9,73.62 151.15,73.87 151.15,76.1 151.35,76.29 151.35,77.11 151.03,77.43 150.84,77.43 150.71,77.56 150.71,77.75 150.84,77.87 152.11,77.87 152.36,77.62 152.36,76.41 152.55,76.22 153.82,76.22 154.01,76.03 154.01,74 153.57,73.56 151.73,73.56 151.28,73.11 149.12,73.11 148.61,72.6 147.79,72.6 147.54,72.86 147.54,74.19 146.84,74.89 146.84,75.27 147.54,75.97 147.54,77.37
GND on TOP: 198.36,154.72 198.36,153.2 198.04,152.88 194.24,152.88 194.1,153.03 194.1,154.61 194.76,155.27 194.76,157.53 194.89,157.66 200.93,157.66 201.11,157.48 201.11,156.29 200.75,155.93 199.57,155.93
GND on TOP: 106.58,56.79 113.5,56.79 113.82,56.47 113.82,52.98 110.26,49.43 108.17,49.43 107.34,50.25 107.34,55.08 106.45,55.97 106.45,56.67
GND on TOP: 84.48,43.39 86,43.39 86.13,43.27 86.13,40.79 85.94,40.6 84.61,40.6 84.42,40.79 84.42,43.33
GND on TOP: 104.42,30.19 110.58,30.19 110.71,30.06 110.71,27.2 109.18,25.68 109.18,23.84 108.42,23.07 106.58,23.07 106.13,23.52 106.13,27.14 105.69,27.58 104.48,27.58 104.04,28.03 104.04,29.8
GND on TOP: 84.54,37.62 85.94,37.62 86.07,37.49 86.07,34.95 85.81,34.69 84.35,34.69 84.29,34.76 84.29,37.36
GND on TOP: 105.84,153.21 107.85,153.21 108.1,152.96 108.1,148.92 107.92,148.74 105.54,148.74 105.38,148.89 105.38,152.75
GND on TOP: 153.19,71.46 145.05,71.46 144.61,71.9 143.4,71.9 141.76,70.25 140.36,70.25 140.3,70.19 140.3,68.03 140.55,67.78 144.61,67.78 145,67.4 157.31,67.4 157.7,67.78 157.7,70.07 157.64,70.13 154.65,70.13 154.46,70.32 154.46,71.71 154.4,71.78 153.51,71.78
GND on TOP: 100.61,38.19 101.18,38.19 101.37,38 101.37,36.15 101.18,35.96 100.67,35.96 100.48,36.15 100.48,38.06
GND on TOP: 165.9,99.71 166.69,99.71 166.78,99.79 166.78,103.94 166.5,104.22 163.6,104.22 162.29,102.91 162.29,99.62 162.48,99.43 163.02,99.43 163.18,99.59 163.18,101.58 163.41,101.81 164.3,101.81 164.88,101.23 165.62,101.23 165.86,101 165.86,99.75
GND on TOP: 391.38,0.2 391.38,3.1 389.5,3.1 389.5,8.26 389.27,8.79 388.71,8.96 388.71,13.29 387.74,14.27 387.27,14.27 387.19,14.18 384.39,14.18 383.06,15.52 380.78,15.52 380.52,15.77 380.52,16.6 380.84,16.91 385,16.91 385,15.7 385.6,15 386.37,15.5 394.22,15.5 394.6,15.12 394.6,14 395.5,14 395.5,11 395.85,10.15 396.7,9.8 397.4,9.8 397.96,9.56 398.2,9 398.2,2 397.67,0.73 396.4,0.2
GND on TOP: 371.62,12.8 371.86,13.04 371.86,13.99 371.55,14.29 367.2,14.29 366.95,14.05 366.95,13.04 367.19,12.8
GND on TOP: 123.21,52.66 123.15,52.6 120.42,52.6 120.29,52.73 120.29,55.73 120.59,56.03 122.92,56.03 123.21,55.73
GND on TOP: 271.07,16.89 271.25,17.07 272,17.07 272.62,17.69 272.62,18.24 272.8,18.41 276.1,18.41 276.11,18.4 276.58,18.87 276.58,22.45 276.81,22.68 277.85,22.68 278.1,22.43 278.1,15.77 276.68,14.35 271.96,14.35 271.07,15.24
GND on TOP: 121.88,16.47 122.9,16.47 123.02,16.34 123.02,14.12 122.77,13.87 122.77,12.34 123.02,12.09 125.06,12.09 125.31,11.83 125.31,11.07 125.06,10.82 122.2,10.82 121.56,11.45 121.56,16.15
GND on TOP: 229.96,24.36 232.6,24.36 233.11,23.85 233.11,21.08 233.52,20.67 240.4,20.67 240.81,21.08 240.81,23.26 241.47,23.92 244.29,23.92 244.67,23.54 244.67,18.69 244.31,18.34 231.54,18.34 229.76,20.11 229.76,24.15
GND on TOP: 254.35,119.53 263.93,119.53 263.99,119.59 263.99,121.94 263.42,122.51 254.22,122.51 254.03,122.32 254.03,119.85
GND on TOP: 99.53,48.22 101.18,48.22 101.37,48.03 101.37,45.24 101.24,45.11 99.59,45.11 99.34,45.36 99.34,48.03
GND on TOP: 120.42,81.94 124.99,81.94 125.37,81.56 125.37,78.51 125.06,78.19 123.98,78.19 123.28,78.89 120.42,78.89 120.23,79.08 120.23,81.75
GND on TOP: 354.13,15.44 350.67,15.44 350.34,15.11 350.34,13.92 350.95,13.31 352.17,13.31 352.86,12.62 354.2,12.62 354.28,12.7 354.28,15.29
GND on TOP: 190.03,180.34 191.53,180.34 191.61,180.26 191.61,177.16 191.43,176.98 190.11,176.98 190.05,177.05 190.05,177.91 189.96,178.01 189.96,180.26
GND on TOP: 364.66,18 364.66,16.01 364.71,15.96 364.71,11.51 364.9,11.33 366.39,11.33 366.65,11.58 366.65,14.14 367.03,14.52 371,14.52 371.52,15.04 371.52,17.93 371.08,18.37 365.03,18.37
GND on TOP: 153.12,170.25 154.09,170.25 154.2,170.14 154.2,169.1 154.1,169 153.53,169 153.43,169.1 153.43,169.65 153.3,169.78 153.14,169.78 153.02,169.9 153.02,170.16
GND on TOP: 140.61,53.93 142.84,53.93 143.09,53.68 143.09,51.08 142.96,50.95 140.49,50.95 140.3,51.14 140.3,53.62
GND on TOP: 106.59,116.12 106.42,116.29 106.42,117.73 106.57,117.88 108.2,117.88 108.32,117.77 110.5,117.77 110.63,117.63 110.63,116.25 110.5,116.12
GND on TOP: 99.72,29.49 100.93,29.49 100.93,29.49 101.12,29.49 101.25,29.36 101.25,28.54 100.87,28.16 100.87,27.14 100.99,27.01 101.31,27.01 101.43,26.88 101.43,26.31 101.24,26.12 99.53,26.12 99.34,26.31 99.34,29.11
GND on TOP: outline of 120 points within 274.64,46.47 285.62,56.98
GND on TOP: 107.24,122.98 106.85,122.98 106.66,123.17 106.66,124.2 106.42,124.43 106.42,127.27 107.1,127.95 109.21,127.95 109.56,127.6 110.54,127.6 110.61,127.53 110.61,126.62 110.45,126.45 107.38,126.45 107.11,126.19 107.11,124.54 107.38,124.28 107.38,123.12
GND on TOP, BOTTOM: 86.19,27.14 86.13,27.07 84.54,27.07 84.42,27.2 84.42,29.55 84.67,29.8 86.07,29.8 86.19,29.68
GND on TOP, BOTTOM, IN1, IN2, IN3, IN4: 380.78,48.28 380.39,48.66 380.39,49.49 384.27,53.36 384.27,58.35 384.71,58.8 392.7,58.8 393.97,58.27 394.5,57 394.5,49.78 394.22,49.5 386.37,49.5 385.6,50 385,49.3 385,48.28
GND on BOTTOM: 105.69,144.93 107.66,144.93 107.85,144.74 107.85,143.76 106.51,142.42 106.17,142.42 105.63,142.96 105.63,144.87
GND on BOTTOM: 144.41,1.17 144.03,2.24 143.16,2.97 142.72,3.12 142.25,3.17 131.54,3.17 130.23,4.48 130.23,5.72 128.85,7.1 126.68,7.1 126.22,7.56 126.22,9.75 126.36,9.88 127.25,9.88 128.13,10.76 128.13,12.01 128.46,12.33 132.08,12.33 132.19,12.23 132.19,8.25 135.27,5.17 140.27,5.17 140.9,5.8 140.9,9.4 141.4,9.9 151.22,9.9 151.25,9.93 159.57,9.93 160.53,10.9 160.53,12.73 160.82,13.02 164.56,13.02 165.02,12.56 165.02,8.14 165.45,7.7 166.43,7.7 166.72,7.41 166.72,4.41 166.3,3.99 149.26,3.99 148.01,2.75 147.4,2.05 147.14,1.17
GND on BOTTOM: 362.97,8.05 365.68,8.05 365.78,7.95 365.78,7.14 365.73,7.08 362.94,7.08 362.81,7.21 362.81,7.9
GND on BOTTOM: 136.3,162.92 136.3,156.08 136.23,156.01 131.71,156.01 131.29,155.59 131.29,154.14 131.16,154.01 127.47,154.01 127.34,154.14 127.34,154.82 127.79,155.27 127.79,163.33 127.58,163.54 127.58,164.28 128.9,165.61 140.63,165.61 140.93,165.31 140.93,163.78 140.38,163.23 136.6,163.23
GND on BOTTOM: 142.96,12.72 145.26,12.72 145.39,12.6 145.39,11.45 145.29,11.35 141.63,11.35 140.79,12.19 140.79,13.33 140.47,13.66 140.47,14.9 140.58,15.01 141.57,15.01 141.69,14.88 141.69,12.41 141.92,12.18 142.63,12.18 142.77,12.32 142.77,12.53
GND on BOTTOM: 121.69,77.3 119.79,77.3 119.34,77.75 119.34,81.81 120.04,82.51 126.2,82.51 127.91,80.8 127.91,78.13 127.85,78.06 124.23,78.06 124.1,78.19 124.1,80.35 123.66,80.8 122.07,80.8 121.75,80.48 121.75,77.37
GND on BOTTOM: 90.39,42.82 93.5,42.82 93.94,42.38 93.94,24.28 93.31,23.65 90.64,23.65 89.88,24.41 89.88,40.66 90.13,40.92 90.13,42.57
GND on BOTTOM: 368.24,54.36 368.24,53.02 368.39,52.87 370.05,52.87 370.08,52.9 370.08,54.4 369.96,54.51 368.4,54.51
GND on BOTTOM: 160.65,185.06 161.19,184.52 161.19,182.08 161.12,182.01 160.27,182.01 159.95,182.34 159.11,182.76 159.11,184.96 159.21,185.06
GND on BOTTOM: 177.26,165.69 177.32,165.69 177.77,165.25 177.77,164.93 175.61,162.77 174.53,162.77 174.21,163.09 174.21,163.85 174.4,164.04 175.61,164.04
GND on BOTTOM: 102.96,64.67 104.74,64.67 104.93,64.48 104.93,62.51 104.8,62.38 103.42,62.38 103.15,62.11 103.15,61.22 103.85,60.53 103.85,60.16 103.38,59.69 103.38,59.03 103.25,58.9 101.67,58.9 101.48,59.09 101.48,63.51 102.63,64.66 102.95,64.66
GND on BOTTOM: 141.29,21.45 141.19,21.55 141.19,24.22 141.31,24.34 144,24.34 145.21,23.14 145.21,21.58 145.08,21.45
GND on BOTTOM: 199.14,157.45 199.14,155.94 198.51,155.31 197.94,154.75 197.04,153.84 197.04,152.15 196.95,152.06 193.6,152.06 193.32,152.34 193.32,154.64 193.51,154.83 193.71,154.83 194.03,155.15 194.03,157.58 194.16,157.71 198.88,157.71
GND on BOTTOM: 135.73,122.15 137.46,122.15 137.74,121.87 137.74,120.44 137.57,120.27 135.67,120.27 135.35,120.58 135.35,121.77
GND on BOTTOM: 277.52,101.29 277.52,108.35 276.99,108.89 275.57,108.89 275.28,109.17 275.28,110.81 276.13,111.66 276.13,112 276.57,112.44 284.66,112.44 284.69,112.41 285.72,113.43 286.8,113.43 287.21,113.02 287.21,109.66 285.44,107.89 285.44,102.61 286.82,101.24 292.35,101.24 292.7,100.89 292.7,97.75 292.38,97.43 278.04,97.43 277.14,98.33 277.14,100.91 ; 1 cut-out
GND on BOTTOM: 231.72,11.69 231.72,10.72 231.41,10.72 231.34,10.66 231.34,9.91 231.68,9.58 232.78,9.58 233.13,9.92 233.13,11.71 233.05,11.79 231.81,11.79
GND on BOTTOM: 76.35,20.72 76.35,9.42 75.64,8.7 73.88,8.7 72.55,7.36 72.55,7.2 72.8,6.94 76.29,6.94 76.93,7.58 79.34,7.58 79.53,7.77 79.53,9.12 79.66,9.24 83.44,9.24 83.69,9.5 83.69,20.88 82.88,21.69 77.32,21.69
GND on BOTTOM: 100.55,38.19 101.69,38.19 101.75,38.12 101.75,35.46 101.62,35.33 100.67,35.33 100.48,35.52 100.48,38.12
GND on BOTTOM: 108.48,67.33 110.13,67.33 110.39,67.08 112.27,67.08 112.84,67.65 116.17,67.65 116.42,67.4 116.42,66.19 115.66,65.43 115.66,64.41 115.47,64.22 113.88,64.22 113.69,64.03 113.69,62.7 113.5,62.51 111.78,62.51 111.66,62.38 111.66,58.63 111.53,58.51 110.51,58.51 110.45,58.57 110.45,59.21 110.32,59.33 109.63,59.33 109.56,59.4 109.56,63.27 109.44,63.4 109.24,63.4 108.93,63.71 108.55,63.71 108.36,63.9 108.36,67.21
GND on BOTTOM: 99.47,29.42 101.31,29.42 101.43,29.3 101.43,28.53 101.38,28.47 101.12,28.47 100.87,28.22 100.87,27.2 101.06,27.01 101.31,27.01 101.43,26.88 101.43,26.44 101.37,26.38 99.53,26.38 99.34,26.57 99.34,29.3
GND on BOTTOM: 283.65,81.56 281.61,81.56 280.43,80.38 280.43,79.53 280.57,79.39 281.13,79.39 281.25,79.27 281.25,79.03 281.23,79.02 281.23,78.95 281.31,78.88 281.74,78.88 281.83,78.97 281.83,79.06 281.99,79.22 282.44,79.22 282.5,79.28 282.5,80.01 282.9,80.4 283.67,80.4 283.76,80.49 283.76,81.44
GND on BOTTOM: 248.7,103.27 252.24,103.27 252.79,103.83 252.79,109.87 252.22,110.43 250.52,110.43 250.44,110.35 250.44,109.8 250.55,109.69 250.6,109.69 251.06,109.23 251.06,106.31 250.26,105.51 249.13,105.51 248.7,105.08
GND on BOTTOM: 369.02,10.96 370.52,10.96 370.64,11.08 370.64,13.07 370.09,13.62 367.92,13.62 367.59,13.29 367.59,12.39
GND on BOTTOM: 122.36,10.88 122.1,11.14 122.1,13.93 121.82,14.22 121.82,16.72 122.21,17.12 122.21,19.78 122.47,20.04 124.98,20.04 125.92,19.1 125.92,18.77 126.15,18.54 129.73,18.54 129.83,18.44 129.83,17.5 129.73,17.4 129.02,17.4 128.97,17.35 128.97,16.61 128.87,16.51 125.39,16.51 124.9,16.99 123.76,16.99 123.66,16.89 123.66,13.55 123.53,13.42 122.96,13.42 122.74,13.2 122.74,12.37 123.02,12.09 124.99,12.09 125.18,11.9 125.18,11.07 124.99,10.88
GND on BOTTOM: 123.62,57.13 122.02,57.13 121.38,56.49 120.61,56.49 120.45,56.33 120.45,55.64 120.6,55.48 123.54,55.48 123.74,55.68 123.74,57.02
GND on BOTTOM: 179.64,129.43 171.98,129.43 171.4,128.85 171.4,124.87 173.7,122.57 183.13,122.57 184.47,123.91 184.47,128.1 181.51,131.06 180.44,131.06 180.06,130.67 180.06,129.84 ; 2 cut-outs
GND on BOTTOM: 110.32,56.73 110.39,56.79 113.37,56.79 113.5,56.67 113.5,55.14 113.12,54.76 111.34,54.76 111.21,54.63 111.21,53.87 110.96,53.62 109.82,53.62 109.63,53.43 109.63,49.68 109.56,49.62 108.48,49.62 108.36,49.74 108.36,50.32 108.17,50.51 107.59,50.51 107.53,50.57 107.53,54.38 107.28,54.63 107.09,54.63 106.77,54.95 106.77,55.4 106.51,55.65 106.51,56.67 106.58,56.73
GND on BOTTOM: 104.36,30.19 110.51,30.19 110.64,30.06 110.64,27.65 109.94,26.95 108.48,26.95 108.36,26.82 108.36,23.14 108.29,23.07 107.28,23.07 107.15,23.2 107.15,23.77 107.02,23.9 106.39,23.9 106.26,24.03 106.26,27.77 106.07,27.96 105.12,27.96 104.86,28.22 104.36,28.22 104.16,28.41 104.16,30
GND on BOTTOM: 67.08,33.93 67.21,33.81 67.21,29.55 67.35,29.41 67.35,28.39 67.27,28.31 66.59,28.31 66.43,28.47 66.43,29.29 66.3,29.42 63.55,29.42 63.22,29.09 62.66,29.09 62.41,29.34 62.41,30.02 63.02,30.63 63.02,31.02 62.76,31.27 62.76,31.87 63.02,32.13 63.02,32.98 62.67,33.32 62.67,33.75 62.85,33.93
GND on BOTTOM: 84.48,43.39 86.07,43.39 86.13,43.33 86.13,40.79 85.94,40.6 84.61,40.6 84.42,40.79 84.42,43.33
GND on BOTTOM: 179.29,173.95 185.25,173.95 185.76,174.46 187.29,174.46 187.67,174.08 187.67,172.11 187.92,171.85 187.92,168.7 187.69,168.47 187.69,167.34 187.92,167.1 187.92,165.37 188.35,164.94 188.96,164.94 189.16,164.73 189.16,163.85 189.07,163.76 188.16,163.76 187.95,163.97 187.95,163.97 186.86,165.06 186.35,165.06 185.86,165.55 184.67,165.55 184.54,165.68 183.18,165.68 183.12,165.62 183.12,164.89 182.98,164.74 181.44,164.74 181.44,164.74 179.74,164.74 179.65,164.66 179.13,164.66 179.09,164.7 179.09,166.77 179.35,167.03 179.35,168.23 179.09,168.49 179.09,173.76
GND on BOTTOM: 84.54,37.62 85.81,37.62 85.94,37.49 85.94,34.82 85.81,34.69 84.35,34.69 84.29,34.76 84.29,37.36
GND on BOTTOM: 119.02,10.95 119.21,10.75 121.82,10.75 121.94,10.88 121.94,13.36 121.56,13.74 121.56,14.88 121.31,15.14 119.28,15.14 119.02,14.88
GND on BOTTOM: 101.5,56.73 102.77,56.73 102.89,56.6 102.89,53.93 102.83,53.87 102.26,53.87 101.94,53.55 101.56,53.55 101.43,53.68 101.43,56.67
GND on BOTTOM: 45.67,46.37 45.67,46.27 45.58,46.07 45.67,45.87 45.67,45.77 45.65,45.73 45.58,45.58 45.63,45.43 45.64,45.41 45.64,45.37 45.53,45.26 45.39,45.26 45.38,45.27 45.3,45.29 45.21,45.27 45.19,45.27 45.17,45.29 44.96,45.5 44.71,45.5 44.57,45.64 44.57,46.12 44.44,46.26 44.4,46.26 44.39,46.26 44.29,46.29 44.19,46.26 44.18,46.26 43.9,46.26 43.89,46.26 43.79,46.29 43.69,46.26 43.68,46.26 43.4,46.26 43.39,46.26 43.29,46.29 43.19,46.26 43.18,46.26 43.13,46.26 43.03,46.35 43.03,47.57 43.01,47.59 43.01,47.6 42.95,47.72 42.83,47.78 42.81,47.79 42.69,47.91 42.62,47.91 42.59,47.93 42.58,47.95 42.42,48.17 42.15,48.18 42.12,48.18 42.1,48.19 42.04,48.25 42.04,48.76 42.1,48.83 43.63,48.83 43.74,48.71 43.73,48.59 43.74,48.5 43.74,48.32 43.71,48.27 43.61,47.96 43.93,47.9 44,47.93 44.07,47.9 44.27,47.69 45.48,47.69 45.53,47.67 45.57,47.63 45.58,47.49 45.66,47.38 45.67,47.37 45.67,47.27 45.58,47.07 45.67,46.87 45.67,46.77 45.58,46.57
GND on BOTTOM: 103.31,14.5 104,14.5 104.11,14.61 104.11,15.71 104.75,16.35 105.21,16.35 105.39,16.53 105.39,17.06 105.28,17.17 104.07,17.17 103.29,16.39 103.29,14.52
GND on BOTTOM: 99.85,48.03 101.12,48.03 101.24,47.9 101.24,45.17 101.18,45.11 99.72,45.11 99.4,45.43 99.4,47.58
GND on BOTTOM: outline of 448 points within 18.49,38.13 29.31,46.31
GND on BOTTOM: 365.14,27.69 362.03,27.69 361.93,27.58 361.93,25.02 362.29,24.66 365.57,24.66 365.74,24.84 365.74,27.08
GND on BOTTOM: 229.25,11.73 229.25,10.13 229.43,9.96 229.43,9.96 230.42,9.96 230.66,10.2 230.66,11.65 230.51,11.8 229.33,11.8
GND on BOTTOM: 128.14,25.07 130.33,25.07 130.61,24.79 130.61,21.66 130.38,21.44 128.04,21.44 127.86,21.61 127.86,24.79
GND on BOTTOM: 136.17,117.8 137.72,117.8 137.78,117.74 137.78,116.79 137.54,116.55 136.36,116.55 136.11,116.8 136.11,117.74
GND on BOTTOM: 2,3.2 0.73,3.73 0.2,5 0.2,9 0.44,9.56 1,9.8 1.7,9.8 2.55,10.15 2.9,11 2.9,15.25 12.31,15.25 13.08,14.75 13.68,15.45 13.68,16.55 14.02,16.88 17.05,16.88 17.4,16.52 17.4,10.63 20.41,7.62 20.41,7.06 20.13,6.94 19.89,6.75 17.48,4.34 17.22,4.16 16.92,4.1 14.44,4.1 13.98,4.01 13.59,3.75 13.28,3.44 13.02,3.26 12.72,3.2
GND on BOTTOM: 110.01,39.52 110.32,39.2 110.32,37.87 108.17,35.71 108.17,32.22 108.04,32.09 107.09,32.09 106.96,32.22 106.96,32.73 106.77,32.92 106.26,32.92 106.07,33.11 106.07,36.79 105.43,37.42 104.04,37.42 103.97,37.49 103.97,39.33 104.16,39.52
GND on BOTTOM: 274.42,14.76 271.63,14.76 271.49,14.9 271.49,17.24 271.76,17.52 274.35,17.52 274.51,17.35 274.51,14.85
GND on BOTTOM: 246.6,20.41 242.28,24.72 199.8,24.72 199.29,24.22 194.59,24.22 193.39,25.42 193.39,55.59 193.32,55.65 193.32,76.35 193.39,76.41 193.39,95.02 194.4,96.04 199.93,96.04 203.42,92.54 254.41,92.54 255.36,91.59 256,91.59 257.39,92.99 257.39,94.83 258.28,95.72 264.82,95.72 265.27,95.27 265.27,92.92 263.81,91.46 260.7,91.46 257.84,88.61 257.84,87.72 255.3,85.18 255.3,70.32 254.66,69.68 207.55,69.68 207.23,70 202.78,70 201.96,70.83 201.96,72.16 201.71,72.41 199.93,72.41 199.74,72.22 199.74,58.51 201.13,57.11 201.13,57.05 201.83,56.35 201.83,54.32 202.53,53.62 254.92,53.62 255.55,52.98 255.55,27.96 251.17,23.58 251.17,21.87 249.71,20.41 ; 3 cut-outs
GND on BOTTOM: 295.27,40.31 293.93,40.31 294.16,40.54 295.3,40.54 295.62,40.85 295.62,41.3 295.36,41.55 291.36,41.55 290.74,40.93 290.74,37.95 291.07,37.62 294.2,37.62 295.53,38.95 295.53,40.05
GND on BOTTOM: 90.45,21.11 90.45,18.12 90.58,17.99 91.4,17.99 91.59,18.18 91.59,19.33 91.66,19.39 92.35,19.39 92.67,19.71 92.67,19.9 92.73,19.96 92.74,19.96 92.83,20.05 93.73,20.05 93.96,20.28 93.96,21.34 93.88,21.42 90.77,21.42
GND on BOTTOM: 128.42,117.8 129.92,117.8 130,117.73 130,115.19 129.92,115.11 128.68,115.11 128.55,114.98 128.55,113.94 128.27,113.66 127.74,113.66 127.56,113.84 127.56,114.7 127.71,114.86 128.04,114.86 128.32,115.14 128.32,117.7
GND on BOTTOM: 143.87,117.8 143.87,120.86 144.12,121.12 144.42,121.12 144.74,120.8 144.74,120.61 145,120.36 147.01,120.36 147.07,120.3 147.07,119.48 147.25,119.3 148.94,119.3 149.17,119.07 149.17,117.75 148.95,117.52 144.14,117.52
GND on BOTTOM: 172.5,132.18 171.01,133.66 171.01,133.84 165.92,138.93 165.92,139.88 164.68,141.12 164.68,160.61 165.89,161.82 171.23,161.82 174.72,158.33 174.72,156.74 174.53,156.55 173.83,156.55 173.45,156.17 173.45,154.26 173.67,154.04 179.64,154.04 180.11,153.57 180.11,149.17 178.65,147.71 171.81,147.71 171.86,147.66 171.86,144.36 179.53,144.36 179.96,143.93 179.96,134.33 177.81,132.18 ; 1 cut-out
GND on BOTTOM: 391.38,0.2 391.38,3.1 389.5,3.1 389.5,8.26 389.27,8.79 388.71,8.96 388.71,13.29 387.72,14.29 387.24,14.29 387.14,14.18 384.39,14.18 383.06,15.52 380.78,15.52 380.52,15.77 380.52,16.6 380.84,16.91 385,16.91 385,15.7 385.6,15 386.37,15.5 394.22,15.5 394.6,15.12 394.6,14 395.5,14 395.5,11 395.85,10.15 396.7,9.8 397.4,9.8 397.96,9.56 398.2,9 398.2,2 397.67,0.73 396.4,0.2
GND on BOTTOM: 255.01,4.95 256.1,4.95 256.2,5.05 256.2,7.34 255.83,7.71 255.19,7.71 255.1,7.62 255.1,6.43 254.92,6.25 254.92,5.04
GND on BOTTOM: 111.21,47.9 111.34,47.78 111.34,46.95 109.63,45.24 108.36,45.24 108.17,45.04 108.17,41.43 108.04,41.3 107.21,41.3 107.02,41.49 107.02,41.87 106.7,42.19 106.26,42.19 106.13,42.31 106.13,45.9 105.18,46.85 104.83,46.85 104.67,47.01 104.67,47.78 104.8,47.9
GND on GND1: outline of 262 points within 0.2,0.2 398.2,199.9
GND on IN1: 391.38,0.2 391.38,3.1 389.5,3.1 389.5,8.26 389.27,8.79 388.71,8.96 388.71,13.29 387.82,14.18 387.73,14.28 387.25,14.28 387.16,14.18 384.39,14.18 383.06,15.52 380.78,15.52 380.52,15.77 380.52,16.6 380.84,16.91 385,16.91 385,15.7 385.6,15 386.37,15.5 394.22,15.5 394.6,15.12 394.6,14 395.5,14 395.5,11 395.85,10.15 396.7,9.8 397.4,9.8 397.96,9.56 398.2,9 398.2,2 397.67,0.73 396.4,0.2
GND on IN1: 2,3.2 0.73,3.73 0.2,5 0.2,9 0.44,9.56 1,9.8 1.7,9.8 2.55,10.15 2.9,11 2.9,15.25 12.31,15.25 13.08,14.75 13.68,15.45 13.68,16.73 13.82,16.87 17.29,16.87 17.87,16.28 17.87,10.63 20.41,8.09 20.41,7.06 20.13,6.94 19.89,6.75 17.48,4.34 17.22,4.16 16.92,4.1 14.44,4.1 13.98,4.01 13.59,3.75 13.28,3.44 13.02,3.26 12.72,3.2
GND on IN1, IN4: 214.02,185.76 213.45,186.33 213.45,187.19 213.92,187.41 214.11,187.89 214.11,198.8 220,198.8 221.27,198.27 221.8,197 221.8,194.3 221.27,193.03 220,192.5 219.1,192.5 218.25,192.15 217.9,191.3 217.9,185.76
GND on GND2: outline of 262 points within 0.2,0.2 398.2,199.9 ; 2 cut-outs
GND on IN2: 391.38,0.2 391.38,3.1 389.5,3.1 389.5,8.26 389.27,8.79 388.71,8.96 388.71,13.29 387.73,14.28 387.26,14.28 387.16,14.18 384.39,14.18 383.06,15.52 380.78,15.52 380.52,15.77 380.52,16.6 380.84,16.91 385,16.91 385,15.7 385.6,15 386.37,15.5 394.22,15.5 394.6,15.12 394.6,14 395.5,14 395.5,11 395.85,10.15 396.7,9.8 397.4,9.8 397.96,9.56 398.2,9 398.2,2 397.67,0.73 396.4,0.2
GND on IN2: 2,3.2 0.73,3.73 0.2,5 0.2,9 0.44,9.56 1,9.8 1.7,9.8 2.55,10.15 2.9,11 2.9,15.25 12.31,15.25 13.08,14.75 13.68,15.45 13.68,16.6 13.96,16.88 17.28,16.88 17.87,16.28 17.87,10.63 20.41,8.09 20.41,7.06 20.13,6.94 19.89,6.75 17.48,4.34 17.22,4.16 16.92,4.1 14.44,4.1 13.98,4.01 13.59,3.75 13.28,3.44 13.02,3.26 12.72,3.2
GND on IN2, IN3: 214.02,185.76 213.48,186.3 213.48,187.19 213.93,187.42 214.11,187.89 214.11,198.8 220,198.8 221.27,198.27 221.8,197 221.8,194.3 221.27,193.03 220,192.5 219.1,192.5 218.25,192.15 217.9,191.3 217.9,185.76
GND on IN3: 391.38,0.2 391.38,3.1 389.5,3.1 389.5,8.26 389.27,8.79 388.71,8.96 388.71,13.29 387.72,14.29 387.27,14.29 387.16,14.18 384.39,14.18 383.06,15.52 380.78,15.52 380.52,15.77 380.52,16.6 380.84,16.91 385,16.91 385,15.7 385.6,15 386.37,15.5 394.22,15.5 394.6,15.12 394.6,14 395.5,14 395.5,11 395.85,10.15 396.7,9.8 397.4,9.8 397.96,9.56 398.2,9 398.2,2 397.67,0.73 396.4,0.2
GND on IN3: 2,3.2 0.73,3.73 0.2,5 0.2,9 0.44,9.56 1,9.8 1.7,9.8 2.55,10.15 2.9,11 2.9,15.25 12.31,15.25 13.08,14.75 13.68,15.45 13.68,16.51 14.01,16.84 17.31,16.84 17.87,16.28 17.87,10.63 20.41,8.09 20.41,7.06 20.13,6.94 19.89,6.75 17.48,4.34 17.22,4.16 16.92,4.1 14.44,4.1 13.98,4.01 13.59,3.75 13.28,3.44 13.02,3.26 12.72,3.2
GND on GND3: outline of 262 points within 0.2,0.2 398.2,199.9 ; 1 cut-out
GND on IN4: 391.38,0.2 391.38,3.1 389.5,3.1 389.5,8.26 389.27,8.79 388.71,8.96 388.71,13.29 387.72,14.29 387.27,14.29 387.17,14.18 384.39,14.18 383.06,15.52 380.78,15.52 380.52,15.77 380.52,16.6 380.84,16.91 385,16.91 385,15.7 385.6,15 386.37,15.5 394.22,15.5 394.6,15.12 394.6,14 395.5,14 395.5,11 395.85,10.15 396.7,9.8 397.4,9.8 397.96,9.56 398.2,9 398.2,2 397.67,0.73 396.4,0.2
GND on IN4: 2,3.2 0.73,3.73 0.2,5 0.2,9 0.44,9.56 1,9.8 1.7,9.8 2.55,10.15 2.9,11 2.9,15.25 12.31,15.25 13.08,14.75 13.68,15.45 13.68,16.42 14.15,16.88 17.27,16.88 17.87,16.28 17.87,10.63 20.41,8.09 20.41,7.06 20.13,6.94 19.89,6.75 17.48,4.34 17.22,4.16 16.92,4.1 14.44,4.1 13.98,4.01 13.59,3.75 13.28,3.44 13.02,3.26 12.72,3.2
GND on IN4: 23.22,32.26 27.83,32.26 28.8,31.29 28.8,23.91 28.39,23.51 23.52,23.51 21.3,25.73 21.3,31.39 20.47,32.22 20.47,32.28 19.52,33.23 19.52,37.11 19.9,37.49 21.49,37.49 21.68,37.3 21.68,33.81
GND on GND4: outline of 262 points within 0.2,0.2 398.2,199.9 ; 1 cut-out
VCC_CORE_PH1 on BOTTOM: 108.48,35.71 108.86,35.71 111.53,38.38 113.88,38.38 114.13,38.12 114.13,36.54 113.75,36.15 112.86,36.15 112.8,36.09 112.8,35.33 112.93,35.2 114.01,35.2 114.96,34.25 114.96,32.73 112.61,30.38 107.21,30.38 106.96,30.63 106.96,31.65 107.02,31.71 108.23,31.71 108.42,31.9 108.42,35.65
VCC_CORE_PH2 on BOTTOM: 111.53,29.42 113.82,29.42 113.94,29.3 113.94,27.9 113.69,27.65 112.86,27.65 112.8,27.58 112.8,26.82 112.93,26.69 113.75,26.69 114.39,26.06 114.39,24.6 111.34,21.55 107.47,21.55 107.21,21.8 107.21,22.63 107.34,22.76 108.42,22.76 108.67,23.01 108.67,26.63 108.8,26.76 110.13,26.76 111.34,27.96 111.34,29.23
VCC_CORE_PH3 on BOTTOM: 112.1,62.25 118.96,62.25 121.37,59.84 121.37,56.86 121.2,56.69 117.48,56.69 117.18,56.98 110.64,56.98 110.45,57.17 110.45,58.19 110.51,58.25 111.59,58.25 111.91,58.57 111.91,62.06
VCC_CORE_PH4 on BOTTOM: 112.67,69.43 113.82,69.43 114.07,69.68 114.07,73.37 114.32,73.62 116.42,73.62 117.56,74.76 117.56,75.91 117.69,76.03 121.31,76.03 121.56,75.78 121.56,73.3 121.31,73.05 120.17,73.05 119.91,73.3 119.91,73.87 119.85,73.94 119.02,73.94 118.9,73.81 118.9,70.19 118.39,69.68 117.63,69.68 117.12,69.17 117.12,68.41 116.61,67.9 112.74,67.9 112.61,68.03 112.61,69.37
VCC_CORE_PH5 on BOTTOM: 108.61,45.04 109.75,45.04 110.77,46.06 113.69,46.06 113.95,45.8 113.95,40.17 113.63,39.84 107.28,39.84 107.02,40.09 107.02,40.79 107.21,40.98 108.1,40.98 108.48,41.36 108.48,44.92
VCC_CORE_PH6 on BOTTOM: 110.01,53.3 113.18,53.3 113.82,53.93 116.23,53.93 116.36,53.81 116.36,52.66 116.1,52.41 115.53,52.41 115.53,51.52 116.29,51.52 116.42,51.39 116.42,48.73 115.72,48.03 108.67,48.03 108.42,48.28 108.42,49.17 108.55,49.3 109.63,49.3 109.88,49.55 109.88,53.17
VCC_GT_PH1 on BOTTOM: 135.28,17.61 135.53,17.36 136.17,17.36 136.23,17.42 136.23,18.57 136.49,18.82 137.69,18.82 138.2,18.31 138.2,15.83 137.82,15.45 134.84,15.45 134.64,15.26 134.64,13.55 134.52,13.42 133.5,13.42 133.12,13.8 133.12,16.34 132.1,17.36 130.16,17.36 130.1,17.42 130.1,18.67 129.95,18.82 126.21,18.82 126.09,18.95 126.09,20.66 126.72,21.3 135.09,21.3 135.28,21.11
VCC_GT_PH2 on BOTTOM: 145.64,21 153.8,21 154.2,20.6 154.2,17.49 154.27,17.42 155.09,17.42 155.22,17.55 155.22,18.57 155.57,18.92 157.42,18.92 157.95,18.39 157.95,17.1 158.46,16.6 159.54,16.6 159.73,16.41 159.73,15.01 159.6,14.88 154.33,14.88 153.69,15.52 152.74,15.52 152.36,15.9 152.36,16.91 151.66,17.61 149.63,17.61 149.5,17.74 149.5,18.95 149.31,19.14 145.63,19.14 145.47,19.3 145.47,20.83
VCC_VCCIO on BOTTOM (solid shape): 158.01,109.83 158.01,109.24 157.96,109.19 157.05,109.19 157,109.24 157,109.35 155.91,110.44 155.83,110.44 155.7,110.56 155.7,111.38 155.75,111.43 156.41,111.43
VDDP_1.2V on TOP (solid shape): 222.77,117.42 222.77,113.59 222.61,113.43 221.88,113.43 221.61,113.69 221.61,113.91 221.61,113.91 221.61,114.32 221.3,114.63 221.3,115.77 220.69,116.39 219.56,116.39 219.53,116.42 219.53,116.52 219.61,116.6 219.61,116.6 220.79,116.6 221.11,116.92 221.19,116.92 221.75,117.47 222.71,117.47
VDDP_ISL95338_1 on BOTTOM: 124.71,143.63 124.84,143.63 124.89,143.58 124.89,142.85 124.84,142.8 124.76,142.8 124.74,142.82 124.51,142.82 124.41,142.72 124.03,142.72 123.77,142.47 123.77,142.14 124.03,141.88 124.26,141.88 124.33,141.81 124.33,141.27 124.28,141.22 122.91,141.22 122.86,141.27 122.86,142.47 123.05,142.66 123.46,142.66 123.98,143.18 124.26,143.18
VDDP_ISL95338_2 on BOTTOM: 147.12,141.12 147.19,141.12 147.27,141.04 147.27,140.33 146.51,139.57 146.51,138.76 146.46,138.71 145.06,138.71 145.01,138.76 144.31,138.76 144.17,138.9 144.17,139.15 144.75,139.72 145.85,139.72 147.04,140.92 147.04,141.04
VDDSPD4 on TOP (solid shape): 203.37,94.11 203.37,93.41 203.07,93.12 203.07,90.91 202.93,90.78 201.68,90.78 201.46,91 201.46,94.02 201.63,94.2 203.27,94.2
+EVDD09 on BOTTOM: 172.38,163.97 172.38,164.2 172.39,164.21 172.39,165.66 172.69,165.95 174.97,165.95 176.81,167.79 176.81,168.93 177.77,169.89 178.85,169.89 178.91,169.82 178.91,168.55 179.1,168.36 179.1,167.03 178.97,166.9 178.97,165.99 178.91,165.92 178.05,165.92 177.45,166.52 177.19,166.52 177.04,166.36 177.04,165.79 175.42,164.17 174.27,164.17 173.96,163.85 172.5,163.85
+EVDD18 on TOP: 176.04,170.85 176.17,170.71 177.25,170.71 177.38,170.58 177.38,170.08 177.19,169.89 173.98,169.89 173.73,170.14 173.73,170.77 173.81,170.85
+LCDVDD on TOP: 118.05,125.7 118.26,125.49 118.26,123.82 118.09,123.65 114.91,123.65 114.55,123.29 114.55,122.95 114.41,122.81 111.24,122.81 110.82,123.23 108.96,123.23 108.59,122.87 107.67,122.87 107.55,122.99 107.55,124.29 107.32,124.52 107.32,126.21 107.42,126.31 110.34,126.31 110.95,125.7
+LCDVDD on BOTTOM: 115.38,123.28 115.38,126.24 115.75,126.62 118.16,126.62 118.25,126.53 118.25,125.59 118.13,125.47 118.13,123.4 117.89,123.15 115.5,123.15
+PWR_SRC on TOP (solid shape): 276.19,24.74 276.19,23.32 275.83,22.96 273.57,22.96 273.21,23.32 273.21,24.53 273.82,25.14 275.78,25.14
+PWR_SRC on TOP (solid shape): 284.61,121.08 284.61,112.93 283.41,111.73 272.94,111.73 271.75,112.93 271.75,121.31 272.52,122.08 274.91,122.08 274.93,122.1 283.59,122.1
+PWR_SRC on TOP (solid shape): 134.49,122.04 134.49,121.66 133.96,121.66 133.96,121.23 134.49,121.23 134.49,120.46 134.43,120.4 132.4,120.4 132.31,120.49 132.31,122 132.4,122.1 134.43,122.1
+PWR_SRC on TOP (solid shape): 307.76,37.68 307.76,34.07 307.01,33.33 302.54,33.33 302.22,33.65 302.22,34.77 302.37,34.93 303.65,34.93 304.01,35.28 304.01,37.37 304.78,38.13 307.3,38.13
+PWR_SRC on TOP (solid shape): 224.14,122.4 224.14,120.53 224.13,120.53 223.59,120.53 223.57,120.51 223.57,120.45 223.57,120.44 223.57,120.09 223.61,120.05 224.12,120.05 224.14,120.03 224.14,119.21 224.12,119.19 222.3,119.19 221.89,119.59 221.89,122.34 222.06,122.5 224.04,122.5
+PWR_SRC on BOTTOM (solid shape): 116.84,99.13 116.84,95.3 116.28,94.74 114.6,94.74 114.25,94.38 114.25,92.68 114.07,92.5 106.86,92.5 106.35,93.01 106.35,101.22 106.88,101.75 114.22,101.75
+PWR_SRC on BOTTOM (solid shape): 55.93,22.78 55.93,22.17 55.98,22.11 56.46,22.11 56.64,21.93 56.64,20.98 56.12,20.46 56.12,20.06 55.95,19.89 53.01,19.89 52.83,20.06 52.83,22.1 53.01,22.27 53.36,22.27 53.92,22.83 55.88,22.83
+PWR_SRC on BOTTOM (solid shape): 153.95,120.83 153.95,117.7 153.92,117.68 153.09,117.68 153.06,117.7 153.06,118.21 153.03,118.23 152.65,118.23 152.6,118.18 152.6,117.68 152.6,117.68 151.71,117.68 151.69,117.7 151.69,120.7 151.87,120.88 153.9,120.88
+PWR_SRC on IN2 (solid shape): 114.61,102.07 114.61,94.56 114.35,94.29 106.72,94.29 105.43,95.58 105.43,101.72 106.78,103.06 113.62,103.06

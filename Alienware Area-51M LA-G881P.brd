# Allegro board Alienware Area-51M LA-G881P.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N29418337: length 3.3
  TOP w0.112: v1(64.55,22.76) 64.22,23.09 64.22,24.28 64.7,24.77 PCZ10.2
  TOP w0.254: PCZ10.2 64.76,24.93 PRZ25.1
N29418339: length 5.6
  TOP w0.203: PUZ01.5 64.36,28.12 64.29,28.05 64.29,27.92 64.16,27.8 64.16,27.33 64.22,27.26 v2(64.22,27.11)
  TOP w0.254: PRZ23.1 64.76,26.59 PRZ25.2 64.75,26.58 v2(64.22,27.11)
  BOTTOM w0.254: PRZ28.1 v1(64.71,25.99) 64.71,26.62 v2(64.22,27.11)
N29418355: length 1.1
  TOP w0.254: PCZ25.2 71.07,31.8 PRZ38.2
N29418359: length 4.8
  TOP w0.203: PUZ01.17 68.78,31.02 68.8,30.99 69.39,30.99 v2(69.47,30.91) 69.55,30.99 69.98,30.99 PRZ41.1
  TOP w0.254: PRZ41.1 70.08,31.11 PRZ38.1
  BOTTOM w0.112: PRZ42.2 v1(70.12,30.01)
  BOTTOM w0.254: PRZ42.2 69.63,31.07 v2(69.47,30.91)
N29418371: length 3.2
  TOP w0.112: v1(72.48,28.09) 72.15,28.43 v2(72.08,28.43)
  TOP w0.254: PRZ37.1 71.6,29.51 71.97,29.14 PRZ40.2 v2(72.08,28.43)
  BOTTOM w0.254: v2(72.08,28.43) 72.08,29.13 PHZ04.2
N29418377: length 4.4
  TOP w0.203: v2(69,29.92) 68.99,29.92 68.69,30.22 PUZ01.15
  TOP w0.254: v2(69,29.92) 69,29.9 69.39,29.51 PRZ37.2
  BOTTOM w0.254: PCZ28.2 67.86,29.5 v1(68.16,29.8) 68.28,29.92 v2(69,29.92)
N29418393: length 3.6
  TOP w0.254: v2(61.45,24.41) 61.63,24.59 61.63,24.61 PHZ01.2 62.1,25.47 PRZ15.1
  BOTTOM w0.112: PRZ14.2 v1(63.21,24.59)
  BOTTOM w0.254: v2(61.45,24.41) 61.44,24.41 61.62,24.59 PRZ14.2
N29418395: length 5
  TOP w0.203: PRZ15.2 62.38,26.94 62.38,27.21 62.56,27.39 v2(63.02,27.39) 63.5,27.87 63.5,28.07 63.56,28.13 PUZ01.3
  BOTTOM w0.254: v2(63.02,27.39) 63.21,27.58 v1(63.21,28.09) 63.97,28.85 PCZ06.2
N29418397: length 4.6
  TOP w0.203: v2(63.65,27.33) 63.83,27.51 63.83,27.93 63.96,28.06 63.96,28.19 63.96,28.19 PUZ01.4
  TOP w0.254: PCZ07.2 63.53,26.22 63.17,26.22 v1(62.88,26.51) 62.88,26.56 v2(63.65,27.33)
  BOTTOM w0.254: v2(63.65,27.33) 63.65,26.64 PRZ22.2
N29418405: length 3.1
  TOP w0.112: v2(63.14,35.51) v1(63.14,35.99)
  TOP w0.203: v2(63.14,35.51) 62.76,35.12 PUZ01.36
  BOTTOM w0.203: v2(63.14,35.51) 63.14,34.82 63.5,34.47 PRZ27.1
N29418441: length 2.2
  TOP w0.203: PRZ20.1 60.26,33.69 61.21,32.73 61.28,32.73 61.39,32.62 PUZ01.40
N29418445: length 2.6
  TOP w0.203: PRZ19.1 60.33,34.46 60.76,34.03 60.76,33.65 61.35,33.06 61.41,33.06 61.46,33.02 PUZ01.39
N29418451: length 3
  TOP w0.203: PUZ01.38 61.46,33.42 61.09,33.79 61.09,34.52 60.35,35.27 PRZ18.1
N29418455: length 3.7
  TOP w0.203: PUZ01.37 61.67,33.82 61.42,34.06 61.42,35.82 v1(61.22,36.03) PRZ17.1
N29418473: length 3.7
  TOP w0.203: PRZ43.1 70.07,30.31 69.24,30.31 v2(69.05,30.5) 68.94,30.62 PUZ01.16
  BOTTOM w0.254: PCZ29.1 67.92,30.95 v1(68.8,30.95) 68.8,30.75 v2(69.05,30.5)
N29419473: length 4.2
  TOP w0.203: PCZ05.2 61.26,26.68 61.26,27.22 v2(61.3,27.26) 61.43,27.39 v1(61.94,27.39) 62.06,27.39 62.51,27.84 62.84,27.84 63.16,28.16 PUZ01.2
  BOTTOM w0.254: v2(61.3,27.26) 61.25,27.22 PRZ11.2
N29419486: length 3.3
  TOP w0.203: PUZ01.8 65.56,28.12 65.4,27.96 65.4,27.56 v1(65.47,27.49) 65.65,27.32 66.21,27.32 PCZ14.2
  TOP w0.254: PCZ14.2 PRZ32.2
N29419576: length 3.4
  TOP w0.112: v1(63.15,23.2) 63.15,23.84 62.92,24.07 PCZ08.2
  TOP w0.254: PCZ08.2 62.92,25.58 v2(62.94,25.6)
  BOTTOM w0.254: PRZ22.1 62.92,26.46 62.92,25.62 v2(62.94,25.6)
N29419623: length 1.9
  BOTTOM w0.112: v1(141.75,19.02) PRZ29.2
  BOTTOM w0.254: PRZ29.2 140.46,18.72 PHZ02.1
N29419667: length 1.8
  BOTTOM w0.112: PHZ03.2 115.96,22.08 v1(116.11,21.93)
  BOTTOM w0.254: PRZ36.1 PHZ03.2
N29419693: length 2.5
  TOP w0.112: PCZ14.1 67.98,27.02 68.5,27.54 v1(68.86,27.54)
  TOP w0.254: PRZ31.2 PCZ14.1
N29419860: length 4.7
  TOP w0.112: v1(70.39,27.65) 70.07,27.96 PRZ39.1
  TOP w0.203: PUZ01.14 68.44,29.82 69.25,29.01 v2(69.25,28.85)
  TOP w0.254: PRZ39.1 69.35,28.75 v2(69.25,28.85)
  BOTTOM w0.203: v2(69.25,28.85) 69.35,28.75 PCZ27.2
N29419910: length 1.2
  TOP w0.254: PRZ43.2 71.7,30.32 PCZ30.2
N29419918: length 1.2
  TOP w0.254: PRZ41.2 71.84,31.1 PCZ31.1
N29419943: length 3.8
  TOP w0.203: PUZ01.20 68.65,32.22 68.84,32.41 69.34,32.41 69.38,32.45 69.38,32.43 v2(69.38,32.43)
  TOP w0.254: v2(69.38,32.43) 69.65,32.7 PCZ24.1
  BOTTOM w0.112: v2(69.38,32.43) 68.97,32.43 v1(68.8,32.6)
  BOTTOM w0.254: v2(69.38,32.43) 69.65,32.7 PRZ33.1
N29419947: length 1.1
  TOP w0.254: PRZ35.1 71.08,32.61 PCZ24.2
N29438561: length 1.8
  TOP w0.203: PUZ01.43 61.24,31.42 61.21,31.38 PRZ13.2
N29438571: length 2.1
  TOP w0.203: PRZ08.2 60.5,29.83 61.29,30.62 PUZ01.45
N29599145: length 0.8
  TOP w0.254: PRZ23.2 65.58,24.92 PCZ09.1
N37345395: length 16.3
  TOP w0.089: v2(274.8,55.37) 275.44,56.01 UH1.AL35 ; v2(261.57,53.72) 261.82,53.46 T135.1
  IN3 w0.127: v2(274.8,55.37) 274.33,54.89 269.46,54.89 268.06,53.49 267.17,53.49 266.83,53.15 264.08,53.15 263.42,53.81 261.66,53.81 v2(261.57,53.72)
N38701284:
  vias: v1(355.25,28.73)
N38704058: length 4.8
  TOP w0.112: RE6.1 357.28,26.19 v1(357.41,26.06)
  TOP w0.127: RE6.1 357.53,27.05 358.82,28.34 UE1.31
N38704074: length 2.9
  TOP w0.112: RE7.1 357.8,27.86 v1(358.32,28.39) 358.32,29.29
  TOP w0.127: UE1.30 358.32,29.29
N40259586: length 3.4
  TOP w0.112: v1(44.25,46.12) 43.91,46.12 43.39,45.6 v2(43.39,45.6)
  TOP w0.127: v2(43.39,45.6) 43.39,45.14 RT108.1 RT109.2
  BOTTOM w0.076: v2(43.39,45.6) 43.79,46 UT4.D6
N105891848: length 1.8
  TOP w0.112: RD11.2 v1(257.52,68.27)
  TOP w0.127: CD31.2 RD11.2
N171085726: length 1.7
  TOP w0.112: U17.12 341.98,21.86 342.04,21.92 342.98,21.92 C2507.1
N184712230: length 5.6
  BOTTOM w0.076: 47.37,46.82 46.19,46.82 45.94,46.57 UT4.E10
  BOTTOM w0.127: T121.1 48.88,46.25 48.31,46.82 47.37,46.82 47.37,46.82
N1710857213: length 1.7
  TOP w0.112: C2506.1 343,21 342.16,21 342.11,21.06 U17.10
N1847135623: length 2.9
  TOP w0.112: T64.1 40.76,43.15 v2(40.94,43.32)
  BOTTOM w0.076: v2(40.94,43.32) 41.13,43.51 41.13,44.03 41.54,44.45 41.54,44.82 UT4.B2
N1847135624: length 6.8
  BOTTOM w0.076: 40.15,44.68 40.25,44.78 40.63,44.78 41.16,45.32 41.54,45.32 UT4.C2
  BOTTOM w0.127: 40.15,44.68 40.09,44.62 40.09,43.32 39.43,42.66 38.61,42.66 38.61,42.66 T65.1
N1847135625: length 6.8
  BOTTOM w0.076: UT4.D10 45.94,46.07 46.18,46.32 46.41,46.32 46.42,46.3 47.27,46.3
  BOTTOM w0.127: T114.1 50.41,45.3 50.4,45.29 50.05,45.29 50.05,45.3 48.28,45.3 47.27,46.3
N1847135626: length 4.3
  BOTTOM w0.076: 47.19,47.57 UT4.G11
  BOTTOM w0.127: 47.19,47.57 48.79,49.17 T120.1
N1847135629: length 3.9
  BOTTOM w0.076: 47.42,48.16 47.08,47.82 46.04,47.82 UT4.G10
  BOTTOM w0.127: T122.1 48.66,49.4 47.42,48.16
N1847135630: length 1.5
  TOP w0.127: T70.1 44.04,45.1 v2(44.04,45.66)
  BOTTOM w0.076: v2(44.04,45.66) 44.29,45.91 UT4.D7
N1847135663: length 1.2
  TOP w0.127: v2(42.29,46.69) 42.64,46.69 42.64,46.7 T62.1
  BOTTOM w0.076: UT4.F4 42.68,47.07 42.29,46.67 v2(42.29,46.69)
N1847135664: length 1.4
  TOP w0.127: T63.1 v2(42.29,47.28)
  BOTTOM w0.076: v2(42.29,47.28) 42.57,47.57 UT4.G4

## Copper pours and planes (outline as drawn)
0.9V_FB on TOP: 161.36,163.71 161.99,163.71 162.45,164.17 163.01,164.17 163.22,164.38 163.22,165.11 163.22,165.12 163.22,165.89 163.16,165.95 161.81,165.95 161.66,165.81 161.66,164.28 161.28,163.89 161.28,163.79
1.2V_B+ on TOP (solid shape): 229.09,120.76 233.47,120.76 233.57,120.65 233.57,119.85 232.82,119.09 232.82,114.32 232.69,114.2 227.61,114.2 226.72,115.09 226.72,116.04 224.28,118.48 224.28,120.18 223.73,120.18 223.72,120.2 223.72,120.37 224.27,120.37 224.28,120.38 224.28,120.78 229.07,120.78
1.8V_FB on BOTTOM: 173.18,169.69 173.18,169.7 173.37,169.89 174.84,169.89 174.91,169.82 174.91,169.31 174.6,169.01 174.6,168.25 174.34,167.98 173.7,167.98 173.45,167.73 173.45,167.53 173.36,167.44 173.35,167.44 172.39,166.48 170.6,166.48 170.46,166.63 170.46,166.97
3/5V_B+ on TOP (solid shape): 317.3,43.48 317.3,42.8 317.63,42.47 318.01,42.47 318.19,42.29 318.19,39.08 318.48,38.78 318.48,38 318.3,37.82 317.47,37.82 317.25,37.59 317.25,36.4 316.99,36.14 314.65,36.14 313.69,35.18 312.85,35.18 312.6,34.92 309.58,34.92 309.25,34.59 308.38,34.59 308.23,34.75 308.23,37.95 308.38,38.1 308.91,38.1 309.25,38.08 309.58,38.1 312.57,38.1 313.49,39.01 313.49,43.58 313.71,43.81 316.97,43.81
3V_5V_EN on TOP: 324.61,14.3 325.92,14.3 326.17,14.04 326.17,13.71 326.25,13.64 326.86,13.64 327.06,13.83 327.06,14.71 326.87,14.9 326.87,16.38 326.73,16.52 325.54,16.52 325.41,16.39 325.41,15.08 325.26,14.93 324.61,14.93 324.54,14.86 324.54,14.38
3VS on TOP (solid shape): 341.92,25.04 341.92,24.49 341.92,24.49 342.47,24.49 342.47,24.49 342.47,25.04 342.72,25.04 342.72,25.04 342.72,24.49 342.72,24.49 343.27,24.49 343.27,24.49 343.27,25.04 343.85,25.04 343.9,24.98 343.9,23.65 343.43,23.17 343.43,22.38 343.38,22.34 342.47,22.34 342.29,22.15 341.23,22.15 341.19,22.2 341.19,24.81 341.42,25.04 341.92,25.04
5VS on TOP (solid shape): 342.79,20.19 343.39,20.19 343.41,20.17 343.41,19.56 343.9,19.07 343.9,17.74 343.74,17.58 343.2,17.58 343.19,17.59 343.19,18.12 343.18,18.13 342.64,18.13 342.64,18.13 342.64,17.59 342.63,17.58 342.4,17.58 342.39,17.58 342.39,18.13 342.39,18.13 341.85,18.13 341.84,18.12 341.84,17.58 341.84,17.58 341.47,17.58 341.17,17.87 341.17,20.7 341.23,20.76 342.21,20.76
+0.6VS on TOP (solid shape): 239.93,96.09 239.93,95.35 239.12,94.54 238.1,94.54 237.44,95.2 236.36,95.2 236.19,95.36 236.19,95.8 236.24,95.84 237.32,95.84 237.67,96.19 239.83,96.19
+0.6VS on TOP (solid shape): 253.77,93.65 253.77,93.5 253.87,93.39 254.94,93.39 255.07,93.27 255.07,92.96 254.99,92.89 254.87,92.81 254.78,92.68 254.43,92.33 251.21,92.33 251.08,92.45 251.08,93.65 251.33,93.9 253.52,93.9
+0.6VS on TOP (solid shape): 210.17,116.1 210.82,116.1 210.83,116.11 210.83,116.66 210.84,116.67 211.01,116.67 211.02,116.66 211.02,116.13 211.04,116.11 212,116.11 212.04,116.08 212.04,113.47 211.85,113.28 201.79,113.28 201.53,113.53 201.53,116.13 202.35,116.95 209.33,116.95
+0.6VS on TOP (solid shape): 191.38,99.41 191.74,99.04 192.09,99.41 197.81,99.41 198.57,98.65 198.57,95.41 197.96,94.81 190.97,94.81 190.55,95.23 190.55,98.86 191.09,99.41
+0.6VS on TOP (solid shape): 228.57,95.81 228.57,94.08 228.47,93.98 228.47,93.72 227.8,93.05 227.8,91.53 227.79,91.44 227.8,91.34 227.8,89.49 226.02,87.72 217.64,87.72 216.94,88.42 213.19,88.42 211.35,90.26 211.35,92.42 210.72,93.05 210.72,93.15 210.76,93.32 210.72,93.48 210.72,93.75 210.46,94 210.46,95.25 210.67,95.45 212.01,95.45 212.11,95.35 212.11,94.89 212.37,94.64 214.48,94.64 214.53,94.59 214.53,94.2 214.48,94.06 214.49,93.92 214.01,93.45 213.82,93.25 213.89,92.98 213.89,92.41 213.32,91.84 213.32,91.34 214.46,90.19 219.93,90.19 220.88,89.24 221.65,89.24 221.67,89.24 221.83,89.19 222,89.24 222.01,89.24 222.31,89.24 222.32,89.24 222.49,89.19 222.65,89.24 222.66,89.24 223.02,89.24 223.04,89.24 223.2,89.19 223.37,89.24 223.38,89.24 223.63,89.24 223.64,89.24 223.8,89.19 223.97,89.24 223.98,89.24 225.27,89.24 225.28,89.24 225.45,89.19 225.62,89.24 225.63,89.24 225.7,89.24 226.53,90.07 226.53,94.24 226.08,94.69 225.65,94.69 225.48,94.87 225.48,95.4 225.78,95.71 227.89,95.71 228.07,95.88 228.5,95.88
+0.6VS on BOTTOM (solid shape): 212.04,94.31 212.04,93.98 211.84,93.77 211.84,93.37 212.02,93.18 213.7,93.18 213.77,93.11 213.77,92.94 213.72,92.89 211.51,92.89 211,93.4 211,94.22 211.19,94.41 211.94,94.41
+0.6VS on BOTTOM (solid shape): 252.88,93.22 254.66,93.22 254.76,93.11 254.76,92.96 254.66,92.86 252.88,92.86 252.42,92.4 251.36,92.4 251.08,92.68 251.08,93.75 251.28,93.95 252.15,93.95
+0.6VS on BOTTOM: 240.62,92.86 238.11,92.86 237.47,93.51 237.47,95.03 237.59,95.16 238.89,95.16 238.99,95.06 238.99,94.83 238.66,94.49 238.66,93.34 238.81,93.18 240.6,93.18 240.69,93.09 240.69,92.93
+0.6VS on BOTTOM: 226.11,92.86 228.73,92.86 229.06,93.19 229.06,94.03 228.57,94.51 227.53,94.51 227.41,94.38 227.41,93.95 227.56,93.8 227.76,93.8 227.94,93.62 227.94,93.43 227.69,93.18 226.06,93.18 226.02,93.14 226.02,92.95
+0.6VS on IN3: outline of 145 points within 188.79,89.93 253.69,103.78
+0.6VSP on TOP (solid shape): 214.85,118.89 217.52,118.89 217.71,118.7 217.71,118.07 217.64,118.01 216.69,118.01 216.44,118.26 215.74,118.26 214.96,117.49 214.92,117.49 214.77,117.33 212.27,117.33 212.22,117.28 212.22,116.61 211.85,116.24 211.19,116.24 211.18,116.25 211.18,116.8 211.16,116.81 210.71,116.81 210.69,116.8 210.69,116.25 210.68,116.24 210.44,116.24 210.43,116.25 210.43,118.76 210.57,118.9 214.85,118.9
+0.9V_CIO on BOTTOM (solid shape): 25.9,44.99 26.05,44.85 26.25,44.83 26.27,44.81 26.28,44.78 26.28,44.75 26.39,44.64 26.39,44.39 26.28,44.28 26.28,44.1 26.29,44.1 26.29,43.63 26.28,43.63 26.28,43.45 26.29,43.44 26.29,43.03 26.01,42.75 25.55,42.75 25.41,42.89 25.41,42.98 25.3,43.1 25.3,43.33 25.5,43.54 25.85,43.81 25.6,44.19 25.6,44.84 25.61,44.85 25.72,44.9 25.8,44.99
+0.9V_DP on BOTTOM (solid shape): 24.33,46.05 24.46,45.92 24.51,45.92 24.71,45.73 24.71,44.76 24.66,44.71 23.82,44.71 23.77,44.76 23.77,44.9 23.9,45.17 23.77,45.43 23.77,45.55 23.87,45.68 23.9,45.84 24.12,46.06 24.33,46.06
+0.9V_DP on BOTTOM (solid shape): 26.93,44.1 27.06,43.97 27.16,43.97 27.16,43.76 27.28,43.6 27.28,43.48 27.14,43.2 27.31,42.93 27.61,42.63 27.61,42.36 27.58,42.33 27.58,42.15 27.71,42.02 27.71,41.81 27.58,41.69 27.41,41.69 27.16,41.93 27.07,42.15 26.84,42.25 26.72,42.37 26.68,42.37 26.6,42.46 26.41,42.46 26.32,42.37 26.02,42.37 25.85,42.46 25.68,42.37 25.38,42.37 25.3,42.46 25.11,42.46 25.1,42.45 24.95,42.45 24.89,42.5 24.13,42.5 24.07,42.45 24,42.45 23.99,42.46 23.81,42.46 23.72,42.37 23.65,42.37 23.44,42.58 23.44,42.78 23.46,42.8 23.46,42.98 23.34,43.1 23.34,43.33 23.46,43.45 23.46,43.46 23.52,43.52 23.62,43.52 23.63,43.53 23.7,43.53 23.78,43.61 23.81,43.63 23.84,43.67 23.95,43.67 24.05,43.57 24.05,43.5 23.9,43.17 24.14,42.9 24.33,42.7 24.43,42.7 24.46,42.67 25.29,42.67 25.32,42.7 25.42,42.7 25.5,42.63 26.06,42.63 26.42,42.98 26.42,43.49 26.41,43.5 26.41,43.58 26.41,43.9 26.48,43.97 26.59,43.97 26.74,44.13 26.93,44.13
+0.9V_DP on IN3 (solid shape): outline of 257 points within 23.22,41.63 27.82,46.23
+0.9V_LVR_OUT on TOP: 20.08,40.82 20.08,40.21 20.08,40.09 19.49,39.49 19.49,38.94 19.53,38.89 20.44,38.89 20.62,39.07 20.62,39.56 20.83,39.77 20.83,40.12 20.85,40.14 21.49,40.14 21.87,40.53 21.87,40.79 21.76,40.9 20.17,40.9
+0.9V_PCIE on TOP (solid shape): outline of 95 points within 24,38.51 26.28,42.19
+0.9V_PCIE on BOTTOM (solid shape): 24.98,42.23 24.98,42.15 25.04,42.09 25.04,41.74 24.98,41.68 24.98,41.5 25.04,41.44 25.04,41.09 25.03,41.08 24.98,40.94 25.03,40.8 25.04,40.79 25.04,40.75 25.19,40.6 25.3,40.37 25.55,40.29 25.76,40.07 25.78,40.07 25.78,39.88 25.55,39.65 25.38,39.61 25.25,39.5 24.94,39.5 24.76,39.68 24.76,39.73 24.64,39.86 24.46,39.86 24.25,39.64 24.07,39.61 23.94,39.48 23.87,39.48 23.84,39.51 23.81,39.55 23.77,39.58 23.77,39.7 23.9,39.97 23.77,40.23 23.77,40.35 23.85,40.43 23.9,40.54 24,40.65 24,40.75 24.03,40.77 24.11,40.94 24.03,41.11 24,41.13 24,41.39 24.11,41.5 24.11,41.68 24,41.79 24,42.04 24.11,42.15 24.11,42.31 24.18,42.37 24.84,42.37
+0.9V_SVR on TOP (solid shape): 21.01,56.82 21.01,53.31 20.88,53.18 18.5,53.18 18.31,53.36 18.31,56.82 18.47,56.97 20.85,56.97
+0.9V_SVR on TOP (solid shape): 20.17,44.85 20.17,43.43 20.04,43.3 19.55,43.3 19.51,43.34 19.51,44.25 19.71,44.45 19.71,44.84 19.76,44.89 20.14,44.89
+0.9V_SVR on BOTTOM (solid shape): 21.99,43.69 22.04,43.63 22.11,43.58 22.38,43.31 22.38,42.8 22.5,42.68 22.5,42.45 22.38,42.33 22.38,42.15 22.5,42.03 22.5,41.8 22.38,41.68 22.38,41.64 22.33,41.59 22.15,41.57 22,41.46 21.89,41.46 21.77,41.56 21.6,41.6 21.51,41.69 21.51,41.7 21.32,41.9 21.27,42.1 21.11,42.23 21.11,43.03 21.12,43.04 21.61,43.54 21.77,43.58 21.89,43.69
+0.9V_SVR on IN3 (solid shape): outline of 840 points within 17.93,41.4 24.45,56.82
+0.9V_SVR on BOTTOM: 18.71,54.07 18.29,54.5 18.29,57.1 18.41,57.23 20.75,57.23 20.85,57.13 20.85,53.07 20.26,52.47 20.26,50.01 19.97,49.73 19,49.73 18.71,50.02
+1.2V_DDR on TOP (solid shape): 197.31,82.22 189.31,82.22 189.31,90.22 197.31,90.22
+1.2V_DDR on TOP (solid shape): 197.72,65.37 189.72,65.37 189.72,73.37 197.72,73.37
+1.2V_DDR on TOP (solid shape): 199.29,28.49 189.29,28.49 189.29,43.49 199.29,43.49
+1.2V_DDR on BOTTOM (solid shape): 201.29,72 201.28,71.97 201.29,71.75 201.43,71.58 201.43,70.63 201.45,70.61 201.45,70.57 202.59,69.43 203.42,69.43 203.48,69.37 203.48,64.79 203.86,64.41 204.2,64.41 204.42,64.22 204.7,64.16 206.22,64.16 206.84,64.78 206.88,64.83 206.92,64.88 206.96,64.87 207,64.86 207.04,64.84 207.05,64.81 207.05,63.7 206.44,63.09 205.42,63.09 205.23,62.9 204.7,62.9 204.36,62.8 204.13,62.53 203.98,62.53 203.78,62.43 203.73,62.22 203.74,62.19 203.61,62.06 203.61,54.06 203.55,54 202.66,54 201.96,54.7 201.96,56.35 199.99,58.32 199.99,72.1 200.12,72.22 201.07,72.22
+1.2V_DDR on BOTTOM (solid shape): 234.61,66.83 234.66,66.84 234.7,66.79 234.7,66.76 236.26,65.2 236.25,65.17 236.3,64.9 236.52,64.74 236.56,64.73 236.56,63.72 237.86,62.43 237.88,62.32 237.79,62.25 236.83,62.25 236.82,62.29 236.47,62.68 235.95,62.65 235.51,62.71 235.15,62.44 234.97,62.48 234.8,62.44 234.33,62.72 233.83,62.51 233.65,62.51 233.61,62.47 233.6,62.47 233.38,62.27 233.38,61.97 233.4,61.94 233.33,61.87 232.95,61.87 232.69,62.13 232.69,62.44 232.31,62.82 231.86,62.82 231.72,62.88 231.58,62.9 230.41,62.9 229.91,63.4 229.91,64.84 229.84,64.91 229.84,65.3 229.98,65.44 230.26,65.44 230.47,65.23 230.47,64.6 230.79,64.29 231.2,64.29 231.37,64.19 231.58,64.16 232.35,64.16 232.5,64 233.56,64 234.29,64.73 234.31,64.74 234.62,65.15 234.19,65.44 233.99,65.63 233.73,65.71 233.64,65.77 233.66,65.88
+1.2V_DDR on BOTTOM (solid shape): 221.87,61.03 221.9,60.99 221.9,60.7 222.26,60.35 222.29,60.26 222.24,60.19 222.07,59.82 222.34,59.53 222.38,59.52 222.38,58.85 223.74,57.5 223.69,57.37 223.67,57.22 223.67,56.85 223.94,56.59 223.96,56.5 223.5,55.97 223.67,55.4 224.27,54.79 224.3,54.68 224.2,54.62 224.06,54.62 223.44,54 221.88,54 221.88,54.26 220.93,55.21 220.9,55.28 220.93,55.35 220.97,55.4 221.02,55.46 221.11,55.44 221.21,55.45 221.9,55.2 222.34,55.8 222.34,56.26 221.79,56.81 221.82,56.84 221.95,57.26 221.77,57.66 220.55,58.89 221.11,59.44 221.14,59.49 221.18,59.53 221.61,59.88 221.18,60.23 220.95,60.43 220.66,60.5 220.62,60.52 220.61,60.55 220.61,60.84 220.67,60.94 220.77,60.92 221.25,60.8 221.67,61.06 221.75,61.06 221.84,61.07
+1.2V_DDR on BOTTOM (solid shape): outline of 122 points within 237.8,54 255.3,69.43
+1.2V_DDR on BOTTOM (solid shape): outline of 173 points within 213.96,54 230.53,69.43
+1.2V_DDR on BOTTOM (solid shape): outline of 126 points within 206.66,58.88 214.03,68.25
+1.2V_DDR on TOP: outline of 159 points within 157.88,19.43 270.76,110.32 ; 5 cut-outs
+1.2V_DDR on TOP: 169.11,100.09 169.11,97.05 168.63,96.57 167.33,96.57 167.03,96.87 167.03,100.5 167.14,100.62 167.94,100.62 168.4,100.15 169.05,100.15
+1.2V_DDR on IN2: outline of 279 points within 162.51,26.29 256.54,87.07
+1.2V_VCCPLL_OC on TOP: 163.5,100.18 164.45,100.18 164.85,100.58 165.57,100.58 165.63,100.51 165.63,97.97 165.4,97.74 163.52,97.74 163.37,97.89 163.37,100.05
+1.2VP on TOP (solid shape): 254.09,119.15 263.85,119.15 264.74,118.27 264.74,112.46 262.79,110.51 248.19,110.51 247.68,111.02 247.68,111.65 247.67,111.66 247.67,119.08 248.7,120.1 253.14,120.1
+1.05V_VCCAMPHYPLL on TOP (solid shape): 268.85,43.38 268.85,42.55 268.87,42.53 268.87,42.17 268.83,42.13 268.4,42.13 268.25,41.97 268.25,40.24 266.39,38.38 265.92,38.38 265.75,38.21 265.75,36.86 265.55,36.66 264.62,36.66 264.52,36.77 264.52,39.41 264.57,39.46 265.97,39.46 266.91,40.4 266.91,42.96 267.11,43.16 268.28,43.16 268.55,43.42 268.81,43.42
+1.05V_VCCST on TOP (solid shape): 84.45,23.62 84.45,21.51 84.25,21.31 84.25,20.7 84.12,20.57 83.29,20.57 82.98,20.88 82.63,20.88 82.35,21.16 82.35,23.52 82.63,23.8 84.28,23.8
+1.05V_VCCST on BOTTOM: 146.76,80.49 146.56,80.69 146.28,80.69 146.27,80.66 146.08,80.48 145.83,80.53 145.8,80.56 145.44,80.2 145.44,79.76 145.74,79.43 145.44,79.1 145.44,78.18 145.13,77.88 145.13,77.46 145.37,77.22 145.63,77.22 145.97,77.56 146.21,77.56 146.4,77.75 146.4,78.09 146.19,78.3 146.19,78.33 146.18,78.34 146.13,78.52 146.18,78.69 146.19,78.71 146.27,78.79 146.27,79.16 146.14,79.37 146.19,79.62 146.2,79.64 146.76,80.2
+1.05V_VCCST on IN3: 121.64,85.91 146.77,85.91 147.92,84.75 147.92,74.69 145.63,72.4 138.8,72.4 137.26,73.94 121.98,73.94 120.47,75.45 120.47,84.74
+1.05V_VCCST on IN3: 80.8,22.87 79.91,23.76 79.91,34.84 81.03,35.96 81.03,43.69 88.05,50.7 89.91,50.7 90.55,50.06 90.55,48.56 83.66,41.67 83.66,30.87 82.22,29.43 82.22,26.78 84.26,24.75 84.26,23.28 83.85,22.87 ; 1 cut-out
+1.8V_PRIM on TOP (solid shape): outline of 435 points within 277.04,56.96 285.86,60.92
+1.8V_PRIM on BOTTOM: outline of 82 points within 282.12,53.75 288.18,66.96
+1.8VALW on BOTTOM (solid shape): 305.74,50.3 305.74,50.04 305.21,49.5 305.09,49.5 304.79,49.8 302.03,49.8 301.91,49.92 301.91,50.72 302.1,50.91 305.13,50.91
+1.8VALW on BOTTOM: 299.89,39.15 299.89,39.95 300.53,40.59 303.73,40.59 304.1,40.96 304.57,40.96 305.2,40.32 305.2,39.76 304.78,39.34 303.09,39.34 302.53,38.78 301.84,38.78 301.72,38.91 301.72,39.29 301.64,39.37 300.32,39.37 300.24,39.29 300.24,38.83 300.17,38.76 299.94,38.76 299.89,38.81 299.89,39.14
+1.8VALW on IN3: 302.65,50.91 301.84,51.71 301.34,51.71 301.08,51.46 301.08,50.77 301.34,50.51 301.34,50.45 301.84,49.95 301.84,49.62 302.48,48.98 302.73,48.98 302.86,49.11 302.86,49.43 302.65,49.64
+1.8VSP on BOTTOM (solid shape): 302.5,38.4 302.5,35.04 303.13,34.41 303.13,33.56 302.93,33.36 301.9,33.36 301.77,33.48 301.05,33.48 300.81,33.73 299.07,33.73 298.95,33.85 298.95,34.41 299.07,34.53 300.62,34.53 301.06,34.97 301.06,35.93 300.89,36.11 300.44,36.11 300.13,36.42 300.13,37.53 299.89,37.77 299.89,38.43 300.02,38.55 302.34,38.55
+1.8VSP_ADJ on BOTTOM (solid shape): 301.93,33.02 303.04,33.02 303.13,32.94 303.13,32.04 302.8,31.71 302.07,31.71 301.86,31.92 301.12,31.92 300.79,32.24 299.1,32.24 298.95,32.39 298.95,33.02 299.1,33.17 300.9,33.17 301.02,33.29 301.67,33.29
+1.8VSP_VIN on TOP: 292.39,36.62 292.39,33.78 292.69,33.48 293.78,33.48 295.45,35.15 295.45,36.51 295.44,36.53 293.19,36.53 293.01,36.71 292.48,36.71
+1.8VSP_VIN on BOTTOM: 295.58,33.67 293.71,33.67 292.87,34.51 292.66,34.51 292.42,34.74 292.42,36.71 292.51,36.79 293.42,36.79 293.7,36.51 293.7,35.09 293.95,34.84 295.56,34.84 295.75,34.64 295.75,33.84
+1V_MPHY on TOP (solid shape): 266.76,42.84 266.76,40.6 266.03,39.87 264.64,39.87 264.52,40 264.52,40.62 264.59,40.69 264.97,40.69 265.07,40.79 265.07,42.44 264.96,42.54 264.27,42.54 264.21,42.6 264.21,43.28 264.21,43.29 264.21,43.48 264.28,43.55 266.05,43.55
+1V_MPHY on TOP (solid shape): 292.3,42.45 292.56,42.45 295.41,39.6 295.9,39.6 296.27,39.22 296.27,39.2 296.48,38.99 296.5,38.99 296.61,38.89 296.61,38.76 297.23,38.14 297.23,37.61 297.17,37.56 296.61,37.56 296.3,37.88 296.3,38.54 296.19,38.65 295.1,38.65 293.77,39.98 292.93,39.98 292.57,40.34 292.57,40.5 292.58,40.51 292.58,40.9 292.58,40.91 292.54,41.15 292.36,41.3 292.34,41.31 292.28,41.45 292.28,41.46 292.12,41.69 291.84,41.67 291.66,41.67 291.5,41.72 291.33,41.67 291.16,41.67 291.11,41.69 291.07,41.73 291.07,42.02 291.17,42.12 291.57,42.12 291.74,42.29 291.74,42.62 291.85,42.73 292.02,42.73
+1V_MPHY on BOTTOM: 277.6,51.15 276.88,50.43 276.88,48.25 277.12,48.01 279.79,48.01 279.79,48.53 280.1,48.84 282.72,48.84 283.55,49.68 283.55,51.08 283.48,51.15
+1V_MPHY on IN2: 290.28,51.69 277.9,51.69 277.02,50.81 277.02,49.52 272.52,45.02 266.77,45.02 265.15,43.4 265.15,41.68 265.15,41.68 265.15,40.19 266.16,39.19 291.66,39.19 293.21,40.74 293.21,43 292.55,43.67 292.55,46.87 293.1,47.43 293.1,48.87
+1VALW on TOP (solid shape): 265.86,45.18 265.86,44.14 265.71,43.99 264.21,43.99 263.87,43.65 263.87,40.66 263.6,40.39 263.6,37.78 263.38,37.49 263.6,37.19 263.6,37.18 264.43,36.35 265.91,36.35 266.09,36.17 266.14,36 266.26,35.88 266.1,35.49 266.44,35.25 266.44,33.59 266.37,33.53 266.17,33.53 265.96,33.73 265.96,34.06 265.94,34.08 263.88,34.08 263.8,34.01 263.8,33.63 263.7,33.53 260.81,33.53 260.71,33.63 260.71,34.03 260.65,34.08 258.65,34.08 258.5,33.93 258.5,33.6 258.39,33.5 258.14,33.5 258.01,33.63 258.01,43.99 259.66,45.64 265.4,45.64
+1VALW on TOP: 80.31,21.49 80.57,21.23 80.57,20.17 80.64,20.09 82.24,20.09 82.3,20.14 82.3,22.76 81.48,23.57 78.68,23.57 78.36,23.25 78.36,21.55 78.43,21.49
+1VALW on BOTTOM: 280.39,51.92 280.55,51.56 280.54,51.47 280.5,51.39 280.48,51.35 280.69,51.15 280.72,51.17 281.01,51.21 281.25,51.06 281.31,51.03 281.37,51.06 281.62,51.22 281.91,51.16 281.94,51.14 282.18,51.38 282.16,51.42 282.29,51.9 282.77,51.78 282.86,51.73 282.95,51.78 283.16,51.94 283.43,51.9 283.53,51.9 283.58,51.99 283.58,52.54 283.46,52.66 282.85,52.66 282.84,52.65 282.78,52.71 282.38,52.71 282.02,53.06 282.02,54.79 281.8,55.01 278.34,55.01 277.52,54.2 277.52,52.01 278.22,51.31 279.49,51.31 279.74,51.57 279.74,51.59 279.81,51.81 279.99,51.96
+1VALW on IN3: 269.39,48.04 269.42,48.18 269.39,48.32 269.39,53.46 270.56,54.63 284.63,54.63 285.29,53.97 285.29,41.32 283.77,39.8 263.27,39.8 261.98,41.1 261.98,45.01 263.37,46.4 268.3,46.4 269.39,47.5 ; 3 cut-outs
+1VALW on IN4: 283.63,55.86 283.63,51.12 283.39,50.88 278.24,50.88 277.98,51.14 277.98,55.79 278.62,56.43 283.06,56.43
+1VALWP on TOP: 258.56,31.59 258.15,31.04 257.91,30.93 257.81,30.7 257.81,33.09 258.04,33.32 266.34,33.32 266.6,33.07 266.6,23.32 265.84,22.55 263.75,22.55 262.94,21.74 262.94,16.91 262.93,16.9 262.93,14.39 262.91,14.37 262.91,13.74 262.53,13.36 258.6,13.36 257.81,14.15 257.81,30.66 258.3,30.35 258.44,30.91
+1VALWP_B+ on TOP: 271.25,21.94 270,21.94 269.8,21.74 269.8,19.02 270.18,18.64 276.07,18.64 276.28,18.84 276.28,22.55 276.12,22.71 274.45,22.71 274.37,22.63 274.37,22.2 274.29,22.12 273.84,22.12 273.79,22.17 273.79,22.63 273.74,22.68 271.98,22.68
+2.5V_MEM on TOP (solid shape): 206.25,94.13 206.25,92.98 205.98,92.71 204.63,92.71 204.51,92.83 204.51,93.55 204.68,93.72 205.26,93.72 205.76,94.21 206.16,94.21
+2.5V_MEM on TOP (solid shape): 233.39,95.43 233.39,94.48 233.07,94.16 230.61,94.16 230.3,94.46 230.3,94.89 230.33,94.92 231.44,94.92 231.7,95.17 231.7,95.43 231.85,95.58 233.25,95.58
+2.5V_MEM on TOP (solid shape): 220.12,94.46 220.12,93.75 219.96,93.6 218.16,93.6 217.93,93.83 217.93,94.13 218.06,94.26 218.13,94.26 218.31,94.44 218.31,94.82 218.36,94.87 219.71,94.87
+2.5V_MEM on TOP (solid shape): 245.9,94.36 245.9,93.07 245.45,92.63 244.05,92.63 243.97,92.72 243.97,93.44 244.12,93.6 244.12,93.98 244.25,94.1 244.7,94.1 244.75,94.16 244.75,94.28 244.91,94.44 245.82,94.44
+2.5V_MEM on BOTTOM (solid shape): 231.93,20.41 231.93,18.44 231.87,18.37 231.55,18.37 231.49,18.44 231.49,18.82 231.42,18.88 230.09,18.88 230.03,18.82 230.03,18.44 229.9,18.31 229.52,18.31 229.45,18.37 229.45,20.28 229.65,20.47 231.87,20.47
+2.5V_MEM on BOTTOM (solid shape): outline of 946 points within 203.16,92.61 234.5,100.49
+2.5V_MEM on BOTTOM: 217.83,94.13 217.83,92.61 217.96,92.48 219.48,92.48 219.73,92.73 219.73,94 219.48,94.26 217.96,94.26
+2.5V_MEM on BOTTOM: 246.15,93.62 244.12,93.62 243.99,93.5 243.99,92.61 244.12,92.48 246.4,92.48 246.53,92.61 246.53,93.24
+2.5V_MEM on BOTTOM: 230.63,92.61 232.43,92.61 232.56,92.73 232.56,94.36 232.13,94.79 230.43,94.79 230.25,94.61 230.25,92.99
+2.5V_MEM on IN2: 230.24,94.26 230.24,94.84 231.31,95.91 237.33,95.91 237.79,95.45 237.79,94.33 237.15,93.7 230.8,93.7
+2.5V_MEMP on BOTTOM: 229.68,18.15 232.57,18.15 233.44,17.28 234.01,17.28 234.2,17.1 234.89,17.1 235.51,16.48 237.04,16.48 237.23,16.29 237.23,15.66 237.15,15.58 231.45,15.58 231.1,15.94 231.1,16.53 230.86,16.77 229.71,16.77 229.59,16.89 229.59,18.05
+2.5VOUT_TBT on IN1: 39.52,26.31 39.52,23.14 43.65,19.01 48.29,19.01 50.48,21.2 50.48,28 49.88,28.6 41.81,28.6
+2.5VSP_ADJ on BOTTOM: 234.79,18.87 235.11,18.56 235.11,18.18 235.35,17.93 236.97,17.93 237.14,17.77 237.14,17.09 237.01,16.96 235.45,16.96 235.01,17.41 234.3,17.41 234.09,17.62 233.55,17.62 233.03,18.14 233.03,19.26 233.26,19.5 233.79,19.5 234.05,19.24 234.05,19.03 234.21,18.87
+2.5VSP_ON on BOTTOM: 240.51,16.96 242.25,16.96 242.39,17.1 242.39,17.48 242.66,17.74 244.84,17.74 244.94,17.84 244.94,18.36 244.91,18.39 242.42,18.39 241.8,17.78 240.45,17.78 240.34,17.67 240.34,17.12
+2.5VSP_VIN on BOTTOM: 240.53,16.59 243.92,16.59 244.03,16.48 244.03,10.7 243.91,10.58 242.67,10.58 242.57,10.68 242.57,11.36 242.57,11.36 243.12,11.36 243.12,11.91 242.57,11.91 242.57,11.91 242.57,12.16 242.57,12.16 243.12,12.16 243.12,12.71 243.12,12.71 242.57,12.71 242.57,12.71 242.57,15.31 242.32,15.56 240.58,15.56 240.39,15.75 240.39,16.45
+3.3V_ELC on TOP (solid shape): 367.16,36.28 367.16,34.22 366.45,33.5 365.4,33.5 365.35,33.55 365.35,34.87 365.4,34.92 365.97,34.92 366.04,35 366.04,36.27 366.17,36.39 367.06,36.39
+3.3V_ELC on TOP (solid shape): 361.47,30.86 361.47,29.54 362.51,28.5 363.78,28.5 364.11,28.17 364.11,27.23 363.98,27.1 363.35,27.1 363.24,27.2 361.12,27.2 361.05,27.27 361.05,29 361.11,29.07 361.11,30.83 361.21,30.94 361.39,30.94
+3.3V_ELC on TOP (solid shape): 353.1,31.77 355.07,31.77 355.14,31.7 355.14,31.23 354.85,30.94 353.36,30.94 352.75,30.33 352.75,29.72 352.63,29.59 351.79,29.59 351.64,29.74 351.64,30.66 351.44,30.86 350.14,30.86 349.99,31.01 349.99,31.49 350.1,31.61 351.56,31.61 352.08,32.13 352.74,32.13
+3.3V_ELC on BOTTOM (solid shape): 369.55,43.63 369.55,42.9 366.98,40.33 363.19,40.33 362.84,40.68 362.84,41.27 364.06,42.49 366.04,42.49 366.04,42.44 366.05,42.39 366.06,42.34 366.09,42.29 366.12,42.24 366.15,42.21 366.19,42.17 366.24,42.15 366.29,42.13 366.34,42.11 366.39,42.11 366.45,42.11 366.5,42.13 366.55,42.15 366.6,42.17 366.64,42.21 366.67,42.24 366.7,42.29 366.73,42.34 366.74,42.39 366.75,42.44 366.75,42.49 366.74,42.55 366.73,42.6 366.7,42.65 366.67,42.69 366.64,42.73 366.6,42.76 366.55,42.79 366.5,42.81 366.45,42.82 366.39,42.82 366.34,42.82 366.29,42.81 366.24,42.79 366.19,42.76 366.15,42.73 366.12,42.69 366.09,42.65 366.06,42.6 366.05,42.55 366.04,42.49 364.06,42.49 366.11,44.54 368.64,44.54
+3.3V_ELC on TOP: 361.95,41.46 361.95,40.42 361.18,39.65 361.18,37.8 361.95,37.04 361.95,37.04 362.03,36.96 364.82,36.96 365,37.14 365,38.81 364.81,39 363.97,39 363.75,39.21 363.75,41.25 363.41,41.59 362.08,41.59
+3.3V_ELC on BOTTOM: 362.85,33.43 362.85,36.68 363.29,37.12 366.96,37.12 367.14,36.94 367.14,35.9 366.97,35.74 366.07,35.74 365.81,35.48 365.81,33.31 365.59,33.09 363.19,33.09
+3.3V_ELC on IN1: 365.6,44.38 365.6,35.29 364.78,34.48 364.78,29.61 366.07,28.33 369.72,28.33 370.01,28.61 370.01,34.11 369.67,34.44 369.67,36.44 368.83,37.27 368.83,44.35 368.59,44.6 365.82,44.6
+3.3V_FLASH on BOTTOM (solid shape): 46.33,32.92 46.33,32.8 46.32,32.7 46.33,32.6 46.33,31.85 46.25,31.77 43.79,31.77 43.59,31.98 43.59,32.31 43.79,32.51 45.33,32.51 45.47,32.48 45.6,32.51 45.8,32.51 45.85,32.56 45.85,32.89 45.92,32.97 46.28,32.97
+3.3V_FLASH on BOTTOM (solid shape): 39.52,48.05 39.54,48.05 39.73,47.86 40.23,47.86 40.41,47.68 40.43,47.68 40.46,47.65 41.16,47.65 41.22,47.65 41.4,47.65 41.45,47.6 41.45,47.4 41.35,47.3 41.34,47.29 41.26,47.3 41.18,47.27 39.94,47.27 39.83,47.16 38.93,47.16 38.63,47.46 38.63,48.25 38.72,48.33 39.24,48.33
+3.3V_FLASH on IN1: 33.12,35.25 33.12,32.31 34.34,31.09 44.42,31.09 44.7,31.37 44.73,31.37 44.73,34.9 43.81,35.81 33.68,35.81
+3.3V_FLASH on IN2: 40.13,51.18 39.27,50.32 39.27,44.55 40.06,43.76 50.85,43.76 51.49,44.4 51.49,50.26 50.57,51.18
+3.3V_LC on IN1: 25.91,45.44 25.91,44.63 26.19,44.35 32.28,44.35 32.46,44.52 32.46,45.44 32.21,45.69 26.16,45.69
+3.3V_LC on IN3: 26.26,51.76 26.26,50.09 26.62,49.73 29.79,49.73 32.79,46.73 33.58,46.73 33.76,46.91 33.76,48.16 33.55,48.36 33.55,49.93 31.34,52.14 26.64,52.14
+3.3V_TBT_SX on TOP: 18.44,49.64 18.03,50.05 15.62,50.05 15.39,50.29 15.39,52.71 15.51,52.83 16.19,52.83 16.67,52.35 21.72,52.35 22.41,51.66 22.41,50.3 22.28,50.16 21.84,50.16 21.82,50.19 21.82,50.34 21.77,50.39 21.27,50.39 21.22,50.44 21.22,50.78 20.98,51.02 20.42,51.02 20.45,50.98 19.54,50.98 19.46,50.9 19.46,49.8 19.3,49.64 18.86,49.64 18.67,49.7 18.48,49.64
+3.3V_TBT_SX on IN2: 21.51,50.16 21.84,49.83 24.99,49.83 26.39,51.23 33.73,51.23 37.06,47.9 38.38,47.9 38.84,48.36 38.84,51.89 37.44,53.29 25.35,53.29 25.35,52.8 24.71,52.17 22.1,52.17 21.51,51.59
+3V_PCH on TOP (solid shape): 265.89,51.59 265.89,49.48 265.77,49.36 264.82,49.36 264.63,49.55 264.63,49.97 264.26,50.34 264.26,51.76 264.31,51.81 265.66,51.81
+3V_PCH on BOTTOM (solid shape): 263.79,103.89 263.79,103 263.67,102.88 262.73,102.88 262.62,102.77 262.62,100.47 262.52,100.36 260.37,100.36 260.07,100.66 260.07,103.68 260.45,104.07 263.61,104.07
+3V_PCH on TOP: 270.09,90.15 270.9,90.96 273.4,90.96 273.52,90.83 273.52,89.62 273.33,89.43 273.33,86.42 273.74,86.01 274.96,86.01 275.05,85.92 275.05,85.33 274.93,85.21 271.97,85.21 271.43,85.75 267.81,85.75 267.78,85.78 266.89,85.78 266.09,86.57 266.09,89.69 266.56,90.15
+3V_PCH on TOP: 261.95,57.02 260.73,57.02 260.55,56.84 260.55,55.12 260.76,54.91 261.75,54.91 262.03,55.19 262.03,56.94
+3V_PCH on BOTTOM: 283.54,60.27 283.29,60.53 280.13,60.53 279.24,61.42 279.24,66.88 278.84,67.28 278.84,68.65 278.13,69.37 278.13,72.39 278.03,72.49 277.09,72.49 277.01,72.42 275.18,72.42 274.86,72.1 274.86,69.37 275.24,68.98 275.24,66.25 276.02,65.47 276.02,55.42 274.22,53.62 274.22,50.76 274.41,50.57 276.95,50.57 277.4,51.01 277.4,54.32 278.22,55.14 282.16,55.14 283.54,56.52
+3V_PCH on BOTTOM: 288.37,60.2 288.71,59.86 289.25,59.86 289.38,59.99 289.38,61.42 289.41,61.44 289.41,64.33 292.38,67.3 292.38,70.6 292.38,72.08 292.16,72.3 291.43,72.3 291.26,72.13 291.26,69.51 291.27,69.5 291.27,68.99 291.28,68.98 291.28,68.3 288.37,65.38
+3V_PCH on IN1: 283.31,59.59 271.51,59.59 270.88,58.96 270.88,54.07 275.37,49.58 280.51,49.58 280.91,49.18 283.76,49.18 285.16,50.58 285.16,53.38 284.07,54.47 284.07,58.83
+3V_PCH on IN2: 268.34,56.14 268.39,56.06 268.39,54.19 267.41,53.21 267.41,52.97 267.24,52.67 267.41,52.36 267.41,51.88 266.71,51.18 266.71,49.63 266.09,49.01 261.39,49.01 260.14,50.26 260.14,56.7 260.88,57.44 260.88,72.6 262.98,74.7 262.98,78.19 266.41,81.62 266.41,86.67 265.12,87.97 265.12,98.45 263.29,100.28 260.34,100.28 260.13,100.49 260.13,101.84 260.32,102.03 266,102.03 270.86,97.18 270.86,85.24 269.97,84.35 269.97,72.56 268.43,71.02 268.43,64.76 268.38,64.68 268.29,64.67 267.82,64.33 268.29,63.99 268.38,63.98 268.43,63.9 268.43,62.98 268.39,62.94 268.39,62.16 268.34,62.08 268.24,62.07 267.71,61.76 268.24,61.44 268.34,61.44 268.39,61.36 268.39,56.91 268.34,56.83 268.25,56.82 267.77,56.49 268.25,56.16
+3V_PCH on IN3: 262.02,70.64 285.6,70.64 286.18,70.06 291.7,70.06 292.46,70.81 292.46,74.09 291.24,75.31 277.42,75.31 277.39,75.28 276.48,75.28 275.21,74.01 275.21,73.96 274.55,73.3 269.88,73.3 269.13,74.05 261.49,74.05 261.14,73.7 261.14,71.52
+3V_PCH on IN4: 269.84,81.87 269.52,81.56 269.52,77.37 271.3,75.59 271.3,73.75 273.27,71.78 273.27,71.08 272.89,70.7 270.41,70.7 269.52,71.59 267.87,71.59 267.81,71.52 266.16,71.52 263.3,74.38 263.3,89.43 263.3,89.43 263.3,89.89 263.61,90.2 269.51,90.2 269.84,89.87
+3V_PCH on IN4: 286.88,61.24 286.12,61.24 285.3,62.06 285.3,69.02 285.87,69.59 285.87,69.82 285.9,69.85 285.9,72.66 285.91,72.68 285.91,73.39 285.95,73.43 287.1,73.43 287.39,73.13 287.39,69.89 287.78,69.5 287.78,68.46 287.01,67.7 287.01,65.68 286.76,65.43 286.76,64.92 286.95,64.73 286.95,61.3
+3V_TOUCH on BOTTOM: 91.66,18.63 91.66,17.99 91.72,17.93 92.8,17.93 93.05,18.18 94.89,18.18 95.15,18.44 95.15,18.88 95.02,19.01 92.8,19.01 92.48,18.69 91.72,18.69
+3V_WLAN on TOP (solid shape): 341.13,48.89 341.13,46.14 340.98,45.99 339.77,45.99 339.67,46.09 339.67,47.77 339.15,48.28 339.15,49.12 339.22,49.18 340.84,49.18
+3V_WLAN on BOTTOM (solid shape): 336.07,33.68 336.07,33.04 334.67,31.65 333.55,31.65 333.27,31.93 333.27,33.25 333.83,33.81 335.94,33.81
+3V_WLAN on BOTTOM (solid shape): 336.46,52.7 336.54,52.66 336.55,52.56 336.45,52.05 336.6,51.55 336.6,50.95 336.07,50.42 334.34,50.42 334.14,50.62 334.14,52.45 334.39,52.7
+3V_WLAN on TOP: 334.49,35.86 336.23,35.86 336.47,35.61 336.58,35.39 336.79,35.29 336.95,35.13 338.07,35.13 338.12,35.08 338.12,33.27 337.78,32.93 336.94,32.93 336.5,32.48 336.5,32 336.33,31.82 332.87,31.82 332.69,32.01 332.69,32.78 332.78,32.87 334.09,32.87 334.31,33.09 334.31,35.68
+3V_WLAN on IN1: 336.09,49.38 340.11,49.38 340.94,48.54 340.94,36.52 337.49,33.07 337.49,31.61 336.64,30.76 333.34,30.76 333.15,30.95 333.15,33.74 335.48,36.08 335.48,48.77
+3V_WLAN on IN3: 334.21,52.63 337.34,52.63 340.79,49.17 340.79,45.84 340.46,45.51 337.18,45.51 333.88,48.82 333.88,52.3
+3VALW on TOP (solid shape): 353.42,27.84 353.42,26.11 353.11,25.8 351.74,25.8 351.51,26.03 351.51,27.89 351.71,28.09 353.16,28.09
+3VALW on TOP (solid shape): 287.05,7.61 287.05,4.26 286.21,3.41 284.08,3.41 282.71,4.78 282.71,5.29 282.95,5.53 282.95,7 283.09,7.13 283.65,7.13 283.78,7 283.82,7 283.95,6.87 283.95,5.15 284.26,4.84 285.87,4.84 286.2,5.18 286.2,7.58 286.38,7.76 286.9,7.76
+3VALW on TOP (solid shape): 340.64,26.31 340.64,25.55 340.9,25.3 340.9,23.14 340.64,22.88 340.04,22.88 339.91,22.76 339.91,22.22 339.82,22.12 339.12,22.12 338.55,22.69 338.55,23.07 338.48,23.14 337.91,23.14 337.81,23.24 337.81,26.91 338.36,27.46 339.5,27.46
+3VALW on TOP (solid shape): 60.67,25.22 60.67,23.16 60.51,23 60.51,22.89 60.51,22.82 60.51,22.75 60.51,21.57 60.46,21.52 59.64,21.52 59.54,21.62 59.54,22.61 58.38,23.77 58.38,24.65 58.54,24.81 58.69,24.81 58.9,24.75 59.11,24.84 59.17,24.86 59.24,24.84 59.71,24.83 59.78,25.29 59.78,25.4 59.86,25.45 60.44,25.45
+3VALW on TOP (solid shape): 339,49.68 339,47.97 339.38,47.59 339.38,45.2 339.17,44.98 339.17,42.34 338.2,41.38 337.66,41.38 337.57,41.44 337.59,41.55 337.34,42.16 337.09,41.55 337.11,41.44 337.02,41.38 336.99,41.38 336.9,41.47 336.32,41.47 336.19,41.6 336.19,42.18 336.74,42.18 336.74,42.88 336.19,42.88 336.19,43.38 336.74,43.38 336.74,44.08 336.19,44.08 336.19,47.38 336.74,47.38 336.74,48.09 336.19,48.09 336.19,48.58 336.74,48.58 336.74,49.29 336.19,49.29 336.19,50.05 336.43,50.29 338.39,50.29
+3VALW on IN1 (solid shape): 353.28,28.22 353.28,27.07 353.15,26.95 352.58,26.95 352.33,27.2 352.33,28.28 352.45,28.41 353.09,28.41
+3VALW on IN3 (solid shape): 364.29,19.35 364.29,17.47 363.96,17.14 360.6,17.14 360.35,17.4 360.35,18.69 361.11,19.45 364.18,19.45
+3VALW on IN3 (solid shape): 377.29,25.09 377.29,23.77 376.91,23.39 374.09,23.39 373.58,23.9 373.58,25.02 374.04,25.47 376.91,25.47
+3VALW on IN3 (solid shape): 185.08,156.33 185.08,153.57 184.73,153.22 182.11,153.22 180.5,154.84 180.5,155.53 181.6,156.64 184.77,156.64
+3VALW on IN4 (solid shape): 186.97,154.12 186.97,153.19 186.02,152.23 185.64,152.23 182.97,154.9 182.97,155.15 182.98,155.16 182.98,156.02 183.18,156.22 184.88,156.22
+3VALW on TOP: 293.19,36.73 293.19,37.59 293.37,37.77 295.24,37.77 295.42,37.6 295.42,36.72 295.36,36.66 293.25,36.66
+3VALW on TOP: 280.19,86.3 280.29,86.21 280.29,85.16 280.19,85.06 279.09,85.06 278.89,85.27 278.05,85.27 277.88,85.44 277.88,87.4 278.08,87.6 278.08,89.54 278.29,89.75 280.32,89.75 280.83,89.24 280.83,88.1 280.19,87.46
+3VALW on TOP: 358.65,15.01 358.65,16.43 358.72,16.51 359.89,16.51 360.07,16.69 360.07,17.07 360.39,17.39 360.39,17.68 361.12,18.41 363.62,18.41 364.24,17.8 364.24,15.06 364.01,14.83 362.61,14.83 362.53,14.91 358.75,14.91
+3VALW on TOP: 286.08,79.48 286.42,79.82 286.42,81.01 285.03,82.39 283.03,82.39 282.37,81.74 282.37,81.08 283.97,79.48
+3VALW on TOP: 184.23,187.43 184.23,186.12 184.52,185.82 187.03,185.82 187.11,185.9 187.11,187.05 187.02,187.14 185.39,187.14 185.01,187.52 184.32,187.52
+3VALW on TOP: 111.2,122.51 115.12,122.51 115.27,122.36 115.27,120.88 115.24,120.85 114.16,120.85 113.91,120.6 113.91,119.99 113.75,119.84 113.75,118.93 113.67,118.85 113.66,118.85 113.52,118.72 112.77,118.72 112.04,117.99 107.38,117.99 107.23,118.13 107.23,119.71 107.5,119.97 107.5,121.25 107.62,121.37 108.73,121.37 108.91,121.2 108.91,119.86 109.13,119.64 110.49,119.64 111.04,120.19 111.04,122.35
+3VALW on TOP: 162.43,169.58 162.43,168.12 162.6,167.96 162.6,167.54 162.28,167.22 161.89,167.22 161.48,166.81 161.48,166.42 161.76,166.14 164.6,166.14 165.19,166.72 165.19,168.69 164.89,168.99 163.9,168.99 163.25,169.64 162.49,169.64
+3VALW on TOP: 52.48,38.69 53.31,37.87 53.94,37.87 54.32,38.25 54.32,39.77 52.99,41.11 41.81,41.11 40.61,39.9 40.61,37.11 40.86,36.85 41.11,36.85 41.49,36.47 41.49,35.96 41.75,35.71 42.38,35.71 42.51,35.84 42.51,38.38 42.83,38.69
+3VALW on BOTTOM: 174.36,129.31 172.17,129.31 172.07,129.21 172.07,127.88 172.22,127.73 173.92,127.73 174.47,128.27 174.47,129.21
+3VALW on GND2: 51.51,18.31 49.62,20.19 49.62,36.75 51.51,38.63 58.41,38.63 58.77,38.27 58.77,37.21 53.05,31.5 53.05,21.25 53.84,20.47 56.71,20.47 57.37,21.13 57.37,25.55 60.19,25.55 60.67,25.06 60.67,19.69 59.3,18.31 ; 1 cut-out
+3VALW on IN2: outline of 98 points within 57.53,20.41 340.9,92.99
+3VALW on IN2: 161.13,168.74 161.45,168.74 163.1,167.09 163.1,166.2 162.91,166.01 161.76,166.01 161.51,166.27 161.51,167.41 160.81,168.11 160.81,168.43
+3VALW on IN2: 199.04,109.05 215.48,109.05 215.67,108.87 228.05,108.87 228.82,108.1 228.82,106.89 227.88,105.96 222.45,105.96 221.96,106.45 198.59,106.45 198.24,106.8 197.17,106.8 196.31,107.66 196.31,107.97 196.05,108.23 195.42,108.23 193.45,110.2 193.45,114.89 194.15,115.59 195.74,115.59 196.31,115.02 196.31,111.85 196.05,111.59 196.05,110.64 196.75,109.94 198.15,109.94
+3VALW on IN3: 106.16,121.61 112.54,121.61 112.82,121.34 112.82,118.31 112.53,118.03 105.94,118.03 105.66,118.31 105.66,121.1
+3VALW on IN3: 171.73,156.17 175.73,156.17 175.99,155.92 175.99,154.01 175.67,153.69 173.07,153.69 171.1,151.72 167.48,151.72 166.84,152.36 166.84,154.01 167.61,154.77 169.13,154.77 169.19,154.71 170.27,154.71
+3VALW on IN3: 156.71,167.16 163.1,167.16 163.35,166.9 163.35,165.95 161.57,164.17 155.79,164.17 154.66,163.04 149.01,163.04 147.77,164.28 147.77,166.22 148.48,166.93 151.86,166.93 152.39,167.46 156.4,167.46
+3VALW on IN4: 337.54,50.59 350.39,50.59 357.5,43.48 375.11,43.48 378.74,39.85 378.74,24 376.88,22.15 375.54,22.15 374.98,22.71 374.98,36.95 372.41,39.52 354.43,39.52 350.39,43.56 340.41,43.56 339.11,42.26 337.59,42.26 337.03,42.82 337.03,50.09
+3VALW on IN4: 193.58,120.42 195.74,120.42 195.93,120.23 195.93,114.58 195.61,114.26 193.45,114.26 193.01,114.7 193.01,119.85
+3VALW_EC on TOP: 311.15,16.05 314.39,16.05 314.47,16.13 314.47,16.74 314.4,16.81 311.15,16.81 311.1,16.76 311.1,16.1
+3VALW_LAN on BOTTOM (solid shape): 179.95,162.86 179.95,162.48 179.95,162.42 179.95,162.37 179.95,161.91 179.89,161.85 179.36,161.85 179.24,161.74 179.2,161.74 179.16,161.69 179.16,161.68 178.27,160.79 178.27,159.21 178.07,159.01 177.8,159.01 177.23,159.59 177.23,161.02 177.59,161.39 177.61,161.39 178.93,162.71 179.14,162.92 179.9,162.92
+3VALW_LAN on TOP: 166.02,167.19 166.02,167.96 166.12,168.06 167.98,168.06 167.99,168.05 168.3,168.36 168.3,169.76 168.94,170.39 168.94,170.9 168.81,171.03 168.81,173.14 166.86,173.14 166.75,173.25 166.75,173.48 166.84,173.57 168.64,173.57 168.78,173.7 168.78,174.25 168.6,174.43 166.86,174.43 166.73,174.55 166.73,176.01 167.16,176.44 174.42,176.44 174.62,176.24 174.62,173.43 174.48,173.29 173.84,173.29 173.63,173.07 171.63,173.07 171.3,172.75 171.3,172.16 170.81,171.67 170.81,170.87 170.93,170.75 170.93,167.31 170.59,166.97 170.59,165.95 170.08,165.44 167.88,165.44 167.55,165.77 166.54,165.77 166.47,165.84 166.47,166.74
+3VALW_LAN on TOP: 178.02,160.17 177.38,160.17 177.13,159.92 177.13,158.71 177.45,158.39 178.97,158.39 179.1,158.52 179.1,159.22 178.97,159.34 178.34,159.34 178.15,159.54 178.15,160.04
+3VALW_LAN on TOP: 191.29,176.65 191.29,175.35 191.1,175.16 190.21,175.16 189.93,175.44 189.93,176.73 189.96,176.76 191.19,176.76
+3VALW_LAN on TOP: 172.5,163.87 172.31,163.87 172.21,163.78 172.21,162.51 171.97,162.27 171.97,161.61 172.26,161.32 173.68,161.32 173.8,161.43 173.8,162.07 173.65,162.22 173.65,162.65 173.7,162.71 173.7,163.15 173.64,163.22 173.26,163.22 173.19,163.15 173.19,163.09 173.13,163.03 172.67,163.03 172.56,163.14 172.56,163.82
+3VALW_LAN on TOP: 158.92,164.19 158.92,162.13 159.1,161.95 159.51,161.95 159.86,162.29 160.42,162.29 160.84,162.71 162.05,162.71 162.11,162.76 162.11,162.94 162.05,163 161.07,163 160.64,163.43 160.32,163.43 160.01,163.73 160.01,164.23 159.96,164.28 159,164.28
+3VALW_LAN on IN2: 190.2,179.03 190.4,179.03 191.23,178.2 191.23,177.38 191.22,177.37 191.22,175.83 190.85,175.45 190.85,174.97 188.18,172.3 188.18,165.44 189.26,164.36 190.85,164.36 191.1,164.62 192.24,164.62 192.56,164.3 192.56,162.47 191.53,161.44 188.75,161.44 185.07,165.12 185.07,176.05 185.45,176.43 185.45,178.39 186.51,179.45 189.78,179.45
+3VALW_LAN on IN2: 170.34,167.47 169.7,167.47 169.13,166.9 169.13,166.2 173.26,162.08 173.26,160.87 175.61,158.52 178.08,158.52 178.27,158.71 178.27,159.66 177.86,160.07 176.65,160.07 175.67,161.06 175.67,162.33 174.53,163.47 174.08,163.47 170.53,167.03 170.53,167.28
+3VALW_LAN on IN3: 166.72,167.09 168.88,167.09 169.32,167.54 170.15,167.54 170.65,167.03 170.65,166.52 170.59,166.46 170.59,165.5 170.34,165.25 167.16,165.25 166.78,164.87 165.38,164.87 165.13,165.12 165.13,165.95 165.32,166.14 166.21,166.14 166.46,166.39 166.46,166.84
+3VALW_LAN on IN3: 159.22,163.92 159.99,163.92 160.18,163.73 160.18,161.95 160.11,161.88 159.22,161.88 159.03,162.08 159.03,163.73
+3VALW_LAN on IN4: 169.96,173 172.69,173 172.88,173.19 172.88,173.7 173,173.82 173.57,173.82 173.89,173.51 173.89,171.92 173.57,171.6 169.89,171.6 169.59,171.9 169.59,172.63
+3VALW_LAN on IN4: 185.2,178.25 185.2,179.16 185.89,179.86 186.37,179.86 187.02,179.2 187.02,178.85 186.78,178.61 186.6,178.61 186.4,178.41 186.4,178.26 186.15,178 185.45,178
+3VALW_LAN on IN4: 178.78,182.2 181.96,182.2 182.4,181.76 182.4,180.81 181.77,180.17 180.56,180.17 180.18,179.79 178.78,179.79 178.27,180.3 178.27,181.7
+3VALW_SSD on TOP (solid shape): 372.09,12.17 372.09,9.21 371.7,8.82 369.47,8.82 368.78,9.5 368.78,10.04 370.69,10.04 370.69,9.98 370.7,9.91 370.72,9.85 370.74,9.79 370.77,9.74 370.81,9.69 370.85,9.64 370.9,9.6 370.95,9.56 371.01,9.54 371.07,9.52 371.14,9.5 371.2,9.5 371.26,9.5 371.33,9.52 371.39,9.54 371.45,9.56 371.5,9.6 371.55,9.64 371.59,9.69 371.63,9.74 371.66,9.79 371.68,9.85 371.7,9.91 371.71,9.98 371.71,10.04 371.7,10.11 371.68,10.17 371.66,10.23 371.63,10.28 371.59,10.33 371.55,10.38 371.5,10.42 371.45,10.46 371.39,10.48 371.33,10.5 371.26,10.52 371.2,10.52 371.14,10.52 371.07,10.5 371.01,10.48 370.95,10.46 370.9,10.42 370.85,10.38 370.81,10.33 370.77,10.28 370.74,10.23 370.72,10.17 370.7,10.11 370.69,10.04 368.78,10.04 368.78,11.56 368.78,11.56 368.78,12.53 368.89,12.64 371.62,12.64
+3VALW_SSD on TOP (solid shape): 384.03,12.58 385.9,12.58 386.14,12.52 386.36,12.62 388,12.62 388.16,12.47 388.16,8.93 387.99,8.76 387.2,8.76 387.11,8.81 387.12,8.92 387.17,9.42 386.77,9.71 386.69,9.76 386.68,9.85 386.2,10.52 385.72,9.85 385.71,9.76 385.63,9.71 385.23,9.42 385.28,8.92 385.29,8.81 385.2,8.76 383.52,8.76 383.29,8.98 383.29,9.51 383.33,9.52 383.71,10.02 383.3,10.51 383.29,10.51 382.09,11.71 382.09,12.66 382.19,12.77 383.84,12.77
+3VALW_SSD on BOTTOM (solid shape): 358.27,25.52 359.68,25.52 359.8,25.41 359.8,24.64 359.66,24.5 356.51,24.5 356.36,24.66 356.36,25.71 356.47,25.83 357.97,25.83
+3VALW_SSD on BOTTOM (solid shape): 374.96,16.44 374.96,14.86 373.51,13.41 373.51,10.05 372.27,8.81 369.51,8.81 369.33,9 369.33,9.76 369.94,10.37 370.58,10.37 370.73,10.22 370.72,10.19 371.31,9.51 371.56,10.37 371.53,10.4 371.99,10.87 371.99,14.82 371.79,15.02 371.4,15.02 371.36,15.07 371.36,16.24 371.65,16.54 374.86,16.54
+3VALW_SSD on TOP: 355.1,16.47 355.23,16.6 355.23,22.92 357.72,25.41 359.1,25.41 359.41,25.11 359.41,24.81 359.04,24.44 359.04,23.06 357.94,21.97 357.94,17.07 358.4,16.62 358.4,13.91 358.72,13.59 358.72,12.22 359.03,11.91 359.51,11.91 359.66,11.76 359.66,11.53 359.77,11.43 361.77,11.43 361.82,11.48 361.82,11.83 361.92,11.94 362.18,11.94 362.38,11.73 362.38,9.45 362.38,9.45 362.38,8.48 361.11,7.21 358.42,7.21 358.42,5.26 358.09,4.93 353.18,4.93 352.21,5.9 352.21,9.85 355.1,12.74
+3VALW_SSD on BOTTOM: 351.94,11.66 352.11,11.82 357.77,11.82 357.98,11.61 357.98,10.04 357.93,9.98 353.81,9.98 353.75,9.92 353.75,9.07 354.53,8.3 357.95,8.3 358.11,8.15 358.11,6.11 357.98,5.98 352.1,5.98 351.94,6.14
+3VALW_SSD on IN3: 385.58,9.71 385.55,9.7 385.23,9.41 385.25,8.97 385.25,8.88 385.16,8.83 383.52,8.83 383.31,9.03 383.31,9.41 383.52,9.61 383.62,10.3 382.93,10.44 382.9,10.42 382.78,10.54 382.8,10.57 382.69,11 382.25,10.99 382.18,10.97 382.12,10.99 381.72,11.03 381.53,10.69 381.51,10.61 381.43,10.58 372.61,10.58 371.87,9.84 371.87,9.81 370.91,8.84 369.52,8.84 369.04,9.32 369.04,10.63 368.39,11.27 364.95,11.27 362,8.32 358.92,8.32 358.05,7.44 358.05,6.43 357.52,5.9 353.96,5.9 353.73,6.13 353.73,8.47 353.97,8.71 355.7,8.71 356.07,9.07 356.07,9.88 358.64,12.46 361.66,12.46 363.52,14.31 380.07,14.31 380.08,14.31 380.71,14.31 381.09,13.93 383.12,13.93 384.08,12.98 384.08,12.72 385.58,11.22
+3VALW_TBT on TOP (solid shape): 40.48,39.46 40.48,39.01 39.97,38.5 39.97,37.3 39.72,37.04 38.76,37.04 38.64,37.17 38.64,39.46 38.83,39.65 40.29,39.65
+3VALW_TBT on BOTTOM (solid shape): 16.84,52.87 16.84,48.98 16.96,48.85 16.64,48.45 17.06,48.15 17.24,48.15 17.38,48.24 17.46,48.24 17.46,48.18 17.93,48.18 17.99,48.12 17.99,47.54 18.16,47.37 18.59,47.37 18.88,47.66 19.07,47.66 19.08,47.64 19.47,47.64 19.53,47.58 19.57,47.58 19.63,47.55 19.65,47.49 19.65,47.46 19.85,47.26 19.98,47.26 20.12,47.12 20.12,46.84 20.05,46.77 19.95,46.79 19.88,46.77 18.12,46.77 18.02,46.87 17.77,46.87 17.25,47.39 16.64,47.39 16.31,47.72 16.31,47.91 16.09,48.13 16.09,50.16 14.59,51.66 14.59,53.37 14.77,53.55 16.15,53.55
+3VALW_TBT on BOTTOM: 35.56,39.57 35.1,39.57 34.87,39.34 34.87,37.74 34.95,37.67 36.85,37.67 36.96,37.77 36.96,38.66 37.06,38.76 40.13,38.76 40.46,39.09 40.46,39.72 39.93,40.26 38.48,40.26 38.2,39.98 35.97,39.98
+3VALW_TBT on IN1: 39.12,39.39 39.12,38.53 39.67,37.97 40.61,37.97 40.89,38.25 40.89,39.32 40.54,39.67 39.39,39.67

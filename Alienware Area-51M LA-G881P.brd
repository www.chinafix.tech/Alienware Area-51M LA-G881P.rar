# Allegro board Alienware Area-51M LA-G881P.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
RN105  0_0201_5%  [R_0201]  346.72 35 180 bottom
RN106  0_0201_5%  [R_0201]  346.72 35.58 180 bottom
RN107  0_0201_5%  [R_0201]  346.6 50.77 180 bottom
RN108  0_0201_5%  [R_0201]  346.6 50.19 180 bottom
RN109  0_0201_5%  [R_0201]  337.68 38.69 0 top
RN111  0_0201_5%  [R_0201]  335.79 40.16 180 top
RN113  0_0201_5%  [R_0201]  340.58 50.59 90 top
RN117  0_0201_5%  [R_0201]  302.16 52.25 90 bottom
RN118  0_0201_5%  [R_0201]  342.12 42.63 0 top
RN119  0_0201_5%  [R_0201]  342.12 43.2 0 top
RN120  0_0402_5%  [R_0402]  338.62 39.36 180 top
RN122  0_0805_5%  [R_0805]  342.38 46.89 180 top
RN123  0_0201_5%  [R_0201]  346.71 46.82 180 bottom
RN124  0_0201_5%  [R_0201]  346.71 47.39 180 bottom
RN125  0_0201_5%  [R_0201]  346.65 48.73 180 bottom
RN126  0_0201_5%  [R_0201]  346.65 49.3 180 bottom
RP2  33_0201_5%  [R_0201]  289.52 69.14 270 top
RP3  10K_0804_8P4R_5%  [RP_0804_8P4R]  284.28 77.54 270 bottom
RP5  10K_0201_5%  [R_0201]  285.74 70.53 90 top
RP6  33_0201_5%  [R_0201]  288.94 69.14 270 top
RP7  33_0201_5%  [R_0201]  288.13 68.92 270 top
RP8  10K_0201_5%  [R_0201]  285.17 71.13 90 top
RP9  10K_0201_5%  [R_0201]  284.6 71.32 90 top
RP10  10K_0201_5%  [R_0201]  284.03 71.33 90 top
RPC7  10K_0804_8P4R_5%  [RP_0804_8P4R]  264.66 47.02 180 top
RPH5  33_0804_8P4R_5%  [RP_0804_8P4R]  262.88 60.02 180 top
RPH6  10K_8P4R_5%  [RP_0804_8P4R]  262.75 55.33 180 top
RS1  100K_0201_5%  [R_0201]  256.86 7.26 180 top
RS2  10K_0201_5%  [R_0201]  256.23 15.38 90 top
RS9  100K_0201_5%  [R_0201]  114.74 173.19 0 top
RS10  10K_0201_5%  [R_0201]  111.38 173.63 180 top
RS11  10K_0201_5%  [R_0201]  109.72 171.09 0 top
RS12  10K_0201_5%  [R_0201]  115.66 172.4 270 top
RS15  100K_0201_5%  [R_0201]  275.45 79.63 0 top
RS16  10K_0201_5%  [R_0201]  276.03 79.07 180 top
RS17  0_0201_5%  [R0201_0OHM]  257.81 7.17 270 top
RS18  1K_0402_5%  [R_0402]  115.52 173.95 0 top
RS19  1K_0402_5%  [R_0402]  115.52 174.78 0 top
RT1  0_0201_5%  [R_0201]  23.96 49.96 90 top
RT2  0_0201_5%  [R_0201]  31.87 47.06 0 bottom
RT3  3.01K_0201_1%  [R_0201]  26.8 38.4 270 top
RT4  1M_0201_1%  [R_0201]  22.51 49.83 90 bottom
RT5  14K_0402_1%  [R_0402]  23.82 50.17 90 bottom
RT6  10K_0201_5%  [R_0201]  30.54 50.91 270 top
RT7  10K_0201_5%  [R_0201]  26.5 50.92 270 top
RT8  10K_0201_5%  [R_0201]  29.75 50.91 270 top
RT9  10K_0201_5%  [R_0201]  31.43 50.91 270 top
RT10  0_0201_5%  [R_0201]  28.3 50.33 90 top
RT11  1M_0201_1%  [R_0201]  29.75 50.33 90 bottom
RT12  0_0201_5%  [R_0201]  17.48 46.45 180 top
RT13  0_0201_5%  [R_0201]  19.81 48.13 180 top
RT14  0_0201_5%  [R_0201]  22.76 49.82 90 top
RT15  0_0201_5%  [R_0201]  25.66 53.59 90 bottom
RT16  0_0201_5%  [R_0201]  20.86 50.05 90 top
RT17  100_0201_5%  [R_0201]  19.83 49.37 180 top
RT18  100_0201_5%  [R_0201]  31.87 46.43 0 bottom
RT19  14K_0402_1%  [R_0402]  29.41 40.62 270 top
RT20  10K_0201_5%  [R_0201]  32.45 47.62 180 bottom
RT21  10K_0201_5%  [R_0201]  17.1 44.6 0 bottom
RT22  0_0201_5%  [R_0201]  44.49 42.61 270 top
RT23  0_0201_5%  [R_0201]  19.81 46.96 180 top
RT25  4.75K_0402_0.5%  [R_0402]  20.83 44.51 0 top
RT26  3.3K_0201_5%  [R_0201]  25.83 50.53 270 bottom
RT27  3.3K_0201_5%  [R_0201]  25.24 50.53 270 bottom
RT28  10K_0201_5%  [R_0201]  28.86 50.91 270 top
RT29  10K_0201_5%  [R_0201]  27.67 50.91 270 bottom
RT30  10K_0201_5%  [R_0201]  25.66 52.37 90 bottom
RT31  10K_0201_5%  [R_0201]  22.13 50.4 270 top
RT32  10K_0201_5%  [R_0201]  19.25 50.64 0 top
RT33  10K_0201_5%  [R_0201]  19.25 50.01 0 top
RT34  100K_0201_5%  [R_0201]  26.5 50.33 90 bottom
RT35  100K_0201_5%  [R_0201]  19.81 47.54 180 top
RT36  10K_0201_5%  [R_0201]  21.49 50.63 270 top
RT37  100K_0201_5%  [R_0201]  17.35 45.77 180 top
RT38  100K_0201_5%  [R_0201]  30.51 50.3 90 bottom
RT39  100K_0201_5%  [R_0201]  31.9 46.43 0 top
RT40  1M_0201_1%  [R_0201]  17.68 44.04 180 bottom
RT41  100K_0201_5%  [R_0201]  24.54 49.96 90 top
RT42  1M_0201_1%  [R_0201]  17.68 46.53 180 bottom
RT43  499_0201_1%  [R_0201]  22.97 38.41 270 top
RT44  499_0201_1%  [R_0201]  21.77 38.41 270 top
RT45  100K_0201_5%  [R_0201]  17.68 45.17 180 bottom
RT46  100K_0201_5%  [R_0201]  17.68 43.1 180 bottom
RT47  100K_0201_5%  [R_0201]  23.11 49.83 90 bottom
RT48  3.3K_0201_5%  [R_0201]  35.14 34.69 0 bottom
RT49  2.2K_0201_5%  [R_0201]  35.14 33.37 0 bottom
RT50  2.2K_0201_5%  [R_0201]  35.14 32.1 0 bottom
RT51  3.3K_0201_5%  [R_0201]  46.08 32.75 90 bottom
RT52  15_0402_5%  [R_0402]  31.87 48.31 0 bottom
RT53  0_0402_5%  [R_0402]  38.17 47.36 0 top
RT59  0_0201_5%  [R_0201]  42.49 40.78 90 bottom
RT60  0_0201_5%  [R_0201]  43.05 40.78 90 bottom
RT61  0_0201_5%  [R_0201]  36.34 48.38 0 bottom
RT62  100K_0201_5%  [R_0201]  38.72 46.22 180 bottom
RT63  100K_0201_5%  [R_0201]  48.99 45.71 0 bottom
RT64  10K_0201_5%  [R_0201]  47.47 52.37 90 bottom
RT65  10K_0201_5%  [R_0201]  48.86 52.37 90 bottom
RT66  10K_0201_5%  [R_0201]  41.01 44.31 90 top
RT67  10K_0201_5%  [R_0201]  41.6 44.31 90 top
RT68  100K_0201_5%  [R_0201]  42.49 51.4 90 bottom
RT69  100K_0201_5%  [R_0201]  41.9 51.4 90 bottom
RT70  100K_0201_5%  [R_0201]  39.01 51.4 270 bottom
RT71  100K_0201_5%  [R_0201]  41.32 51.4 90 bottom
RT72  100K_0201_5%  [R_0201]  40.76 51.4 90 bottom
RT73  100K_0201_5%  [R_0201]  39.01 49.62 90 bottom
RT75  15K_0201_1%  [R_0201]  43.66 47.82 270 top
RT76  100K_0201_5%  [R_0201]  33.03 43.78 90 top
RT77  100K_0201_5%  [R_0201]  32.44 41.35 270 top
RT78  100K_0201_5%  [R_0201]  33.03 43.12 270 top
RT79  100K_0201_5%  [R_0201]  32.44 41.96 90 top
RT80  100K_0201_5%  [R_0201]  19.81 46.38 180 top
RT83  0_0201_5%  [R_0201]  38.13 46.8 0 bottom
RT86  10K_0201_5%  [R_0201]  17.1 45.96 0 bottom
RT88  470K_0402_5%~D  [R_0402]  79.88 7.34 0 top
RT89  39_0402_5%~D  [R_0402]  83.41 13.92 180 top
RT90  8.2_0402_5%~D  [R_0402]  79.88 8.13 0 top
RT94  10K_0201_5%  [R_0201]  19.25 48.74 0 top
RT95  0_0805_5%  [R_0805]  13.58 52.27 0 bottom
RT97  0_0402_5%  [R_0402]  14.88 52.33 0 top
RT98  0_0201_5%  [R_0201]  46 37.04 0 bottom
RT99  0_0201_5%  [R_0201]  35.72 33.96 180 bottom
RT100  0_0201_5%  [R_0201]  35.72 31.52 180 bottom
RT101  0_0201_5%  [R_0201]  46.9 34.44 0 bottom
RT102  0_0201_5%  [R_0201]  48.99 46.78 0 bottom
RT107  10K_0201_5%  [R_0201]  44.16 40.78 90 bottom
RT108  0_0402_5%  [R_0402]  43.07 44.82 270 top
RT109  0_0402_5%  [R_0402]  42.28 43.91 90 top
RT110  0_0603_5%  [R_0603]  87.12 17.1 90 bottom
RT111  0_0603_5%  [R_0603]  88.39 17.05 90 bottom
RT112  0_0402_5%  [R_0402]  49.57 52.11 180 top
RT113  0_0402_5%  [R_0402]  49.57 53 180 top
RT114  0_0402_5%  [R_0402]  41.44 51.21 315 top
RT115  0_0402_5%  [R_0402]  42.07 51.84 315 top
RT116  0_0402_5%  [R_0402]  25.55 28.48 270 bottom
RT117  0_0402_5%  [R_0402]  24.73 28.48 270 bottom
RT122  33_0402_5%  [R_0402]  46.18 34.39 90 bottom
RT124  10K_0201_5%  [R_0201]  40.58 49.17 270 top
RT125  10K_0201_5%  [R_0201]  42.55 49.49 180 top
RT126  100K_0201_5%  [R_0201]  32.36 50.96 0 bottom
RT127  100K_0201_5%  [R_0201]  32.36 50.38 0 bottom
RT128  100K_0201_5%  [R_0201]  34 50.24 180 top
RT129  100K_0201_5%  [R_0201]  34 49.68 180 top
RT130  0_0201_5%  [R_0201]  49.57 47.98 180 bottom
RT131  0_0201_5%  [R_0201]  49.57 47.37 180 bottom
RT132  10K_0402_5%  [R_0402]  57.04 21.36 0 top
RT200  10K_0201_5%  [R_0201]  21.92 39.9 0 top
RT216  1K_0201_1%  [R_0201]  44.16 32.12 90 top
RT217  1K_0201_1%  [R_0201]  44.73 32.7 270 top
RT218  1K_0201_1%  [R_0201]  47.4 33.27 270 top
RT219  1K_0201_1%  [R_0201]  47.24 32.09 180 top
RT220  1K_0201_1%  [R_0201]  42.82 17.96 90 top
RT221  1K_0201_1%  [R_0201]  43.4 17.96 90 top
RT222  1K_0201_1%  [R_0201]  48.26 18.63 180 top
RT223  1K_0201_1%  [R_0201]  46.41 17.93 0 top
RT224  1K_0201_1%  [R_0201]  41.68 17.96 90 top
RT225  1K_0201_1%  [R_0201]  41.3 19.42 90 top
RT226  1K_0201_1%  [R_0201]  49.24 32.7 270 top
RT227  20K_0201_5%  [R_0201]  41.94 19.42 90 top
RT228  1K_0201_1%  [R_0201]  42.25 17.96 90 top
RT229  1K_0201_1%  [R_0201]  50.38 32.7 270 top
RT230  20K_0201_5%  [R_0201]  48.48 32.7 270 top
RT231  1K_0201_1%  [R_0201]  49.81 32.7 270 top
RT233  1K_0201_1%  [R_0201]  45.56 17.77 90 top
RT234  1K_0201_1%  [R_0201]  44.92 17.77 90 top
RT235  20K_0201_5%  [R_0201]  46.13 21.37 270 bottom
RT236  1K_0201_1%  [R_0201]  44.82 20.09 0 bottom
RT237  1K_0201_1%  [R_0201]  49.55 18.13 90 top
RT238  20K_0201_5%  [R_0201]  50.7 18.13 90 top
RT239  1K_0201_1%  [R_0201]  50.13 18.13 90 top
RT240  1K_0201_1%  [R_0201]  51.4 18.13 90 top
RT241  1K_0201_1%  [R_0201]  46.06 32.12 90 top
RT242  4.7K_0402_5%  [R_0402]  47.83 16.6 0 top
RT243  1K_0402_1%  [R_0402]  47.83 17.42 0 top
RT244  1K_0402_1%  [R_0402]  46.14 12.67 90 top
RT245  33_0201_1%  [R_0201]  59.77 11.81 180 top
RT246  33_0201_1%  [R_0201]  59.77 12.42 180 top
RT247  49.9_0402_1%  [R_0402]  60.48 12.46 90 top
RT248  475_0402_1%  [R_0402]  59.54 14.5 180 top
RT249  49.9_0402_1%  [R_0402]  60.48 11.72 270 top
RT250  2.2_0402_1%  [R_0402]  60.81 16.66 180 top
RT260  0_0603_5%  [R_0603]  42.07 36.22 0 top
RT693  100K_0402_5%  [R_0402]  280.35 82.36 90 top
RT694  0_0201_5%  [R_0201]  283.74 58.81 270 bottom
RT695  10K_0201_5%  [R_0201]  279.29 77.85 0 top
RT702  0_0201_5%  [R_0201]  58.53 13.74 0 top
RT705  0_0201_5%  [R_0201]  47.47 15.21 180 top
RT706  0_0201_5%  [R_0201]  47.47 14.64 180 top
RT707  33_0402_5%  [R_0402]  291.51 67.27 180 top
RT708  0_0402_5%  [R_0402]  17.68 47.19 90 top
RT709  0_0201_5%  [R_0201]  45.4 20.66 180 bottom
RT710  0_0201_5%  [R_0201]  43.97 18.54 270 top
RT711  604_0402_1%  [R_0402]  63.08 11.72 270 top
RT712  604_0402_1%  [R_0402]  63.08 12.52 90 top
RT713  4.7K_0402_5%  [R_0402]  63.91 10.81 90 top
RT714  4.7K_0402_5%  [R_0402]  63.91 13.43 270 top
RT716  0_0201_5%  [R_0201]  48.1 15.23 90 top
RT717  0_0201_5%  [R_0201]  48.1 14.64 270 top
RT718  0_0201_5%  [R_0201]  58.59 12.56 90 top
RT719  0_0201_5%  [R_0201]  58.59 11.95 270 top
RT720  0_0201_5%  [R_0201]  38.35 44.54 0 bottom
RT721  0_0201_5%  [R_0201]  38.35 43.97 0 bottom
RT722  0_0201_5%  [R_0201]  38.35 43.39 0 bottom
RT723  10K_0201_5%  [R_0201]  23.37 50.54 270 top
RT724  100K_0201_5%  [R_0201]  28.57 50.3 90 bottom
RT725  100K_0201_5%  [R_0201]  29.15 50.32 90 bottom
RT726  100K_0201_5%  [R_0201]  21.94 49.83 90 bottom
RT727  0_0201_5%  [R_0201]  50.17 13.61 180 bottom
RT728  0_0201_5%  [R_0201]  50.17 14.25 180 bottom
RT729  0_0402_5%  [R_0402]  26.57 53.03 90 bottom
RT730  0_0805_5%  [R_0805]  39.31 37.81 0 top
RT731  0_0402_5%  [R_0402]  35.7 56.47 0 top
RT732  10K_0201_5%  [R_0201]  44.73 40.78 90 bottom
RT733  0_0402_5%  [R_0402]  280.79 78.1 315 top
RU1  10K_0402_5%  [R_0402]  39.34 16.84 180 top
RU2  19.1K_0402_1%  [R_0402]  35.56 12.01 90 top
RU3  19.1K_0402_1%  [R_0402]  36.35 12.01 90 top
RU4  100K_0402_5%  [R_0402]  13.99 32.61 270 top
RU5  220K_0402_5%  [R_0402]  18.47 34.54 180 top
RU6  1M_0402_5%  [R_0402]  11.33 37.23 270 top
RU7  10K_0402_5%  [R_0402]  34.39 19.89 270 top
RU123  0_0201_5%  [R_0201-NPM]  372.04 38.89 0 bottom
RU124  0_0201_5%  [R_0201-NPM]  372.04 39.52 0 bottom
RU125  0_0201_5%  [R_0201-NPM]  372.67 22.06 0 bottom
RU126  0_0201_5%  [R_0201-NPM]  372.67 22.69 0 bottom
RV1  10.5K_0402_1%  [R_0402]  106.71 118.31 270 top
RV2  100_0402_5%  [R_0402]  105.74 117.4 90 top
RV4  100K_0402_1%  [R_0402]  105.91 124.96 90 top
SW2  EVQPLHA15_4P  [SW_EVQPLHA15_4P]  290.38 90.88 0 top
SW3  EVQPLHA15_4P  [SW_EVQPLHA15_4P]  290.4 90.9 180 bottom
T2  PAD~D  [TPC12]  26.95 49.49 0 bottom
T49  PAD~D  [TPC12]  298.23 51.65 180 top
T50  PAD~D  [TPC12]  296.89 51.65 180 top
T62  PAD~D  [TPC12]  42.83 46.7 90 top
T63  PAD~D  [TPC12]  41.49 47.28 90 top
T64  PAD~D  [TPC12]  40.2 43.15 90 top
T65  PAD~D  [TPC12]  36.92 42.66 270 bottom
T70  PAD~D  [TPC12]  44.35 44.79 90 top
T114  PAD~D  [TPC12]  52.1 45.3 270 bottom
T120  PAD~D  [TPC12]  49.94 49.17 270 bottom
T121  PAD~D  [TPC12]  51.02 46.25 270 bottom
T122  PAD~D  [TPC12]  48.66 49.65 270 bottom
T135  PAD~D  [TPC12]  262.15 53.46 90 top
T360  PAD~D  [TPC12]  182.59 163.09 0 top
T361  PAD~D  [TPC12]  177.38 172.55 90 top
T362  PAD~D  [TPC12]  182.59 176.11 0 top
T364  PAD~D  [TPC12]  183.99 177.89 0 top
T365  PAD~D  [TPC12]  183.8 176.62 0 top
T366  PAD~D  [TPC12]  181.45 176.78 0 top
T367  PAD~D  [TPC12]  181.19 178.04 0 top
T368  PAD~D  [TPC12]  185.7 175.73 0 top
T369  PAD~D  [TPC12]  185.32 175.32 180 bottom
T370  PAD~D  [TPC12]  182.53 177.95 0 top
T371  PAD~D  [TPC12]  181.19 175.54 0 top
T372  PAD~D  [TPC12]  297.64 67.08 0 top
TC2  PAD  [TPC12]  153.32 50.25 0 top
TC7  PAD  [TPC12]  161.01 23.8 180 bottom
TC12  PAD~D  [TPC12]  140.05 75.08 0 top
TC13  PAD~D  [TPC12]  139.98 77.43 0 top
TC14  PAD~D  [TPC12]  139.54 73.49 0 top
TC15  PAD~D  [TPC12]  139.48 76.22 0 top
TC16  PAD~D  [TPC12]  139.41 72.03 0 top
TC17  PAD~D  [TPC12]  174.73 86.64 0 top
TC18  PAD~D  [TPC12]  174.78 85.24 0 top
TC19  PAD~D  [TPC12]  140.94 73.05 0 top
TC20  PAD  [TPC12]  285.65 19.9 0 top
TC21  PAD  [TPC12]  287.43 25.11 0 top
TC22  PAD  [TPC12]  286.16 25.11 0 top
TC23  PAD  [TPC12]  283.37 22.38 0 top
TC24  PAD  [TPC12]  286.22 21.04 0 top
TC25  PAD  [TPC12]  284.76 22.12 0 top
TC26  PAD  [TPC12]  289.4 22.88 0 top
TC28  PAD  [TPC12]  288.37 69.94 0 top
TC29  PAD  [TPC12]  283.43 66.19 0 top
TC30  PAD  [TPC12]  284.45 67.02 0 top
TD1  PAD  [TPC12]  254.54 69.11 0 top
TD2  PAD  [TPC12]  249.86 68.76 0 top
TD3  PAD  [TPC12]  238.58 68.58 0 top
TD4  PAD  [TPC12]  228.69 69.81 0 top
TD5  PAD  [TPC12]  223.49 69.56 0 top
TD6  PAD  [TPC12]  222.09 69.62 0 top
TD7  PAD  [TPC12]  214.93 67.82 0 top
TD8  PAD  [TPC12]  201.57 72.51 0 top
U16  -  [AOZ1334DI-02_DFN8-7_3X3]  360.87 17 180 top
U17  AOZ1331_SON14_2X3  [TPS22966DPUR_SON14_2X3]  339.54 22.66 270 top
U18  -  [SY6288C20AAC_SOT23-5]  276 86.57 270 top
U19  -  [AOZ1334DI-01_DFN8-7_3X3]  80.11 22.41 270 top
U2407  -  [F75305M_MSOP10]  222.8 107.2 270 bottom
U2408  -  [F75397M_MSOP8]  115.4 7.28 90 bottom
UC1  CFL_S62_IP_CRB_CFLS_LGA  [LOTES_AZIF0049-P001C_1151P-T]  130.46 82.63 270 bottom
UC2  -  [74AUP1G07GW_TSSOP5]  175.68 32.49 180 top
UE1  -  [STM32F070CBT6TR_LQFP48_7X7]  361.32 38.69 270 top
UE2  GD25Q80CSIGR SOP8  [EN25F80-75HCP_SO8]  367.16 32.59 0 top
UE3  -  [TLC59116FIRHBR_VQFN32_5X5]  152.85 179.01 270 top
UE5  -  [KB9542Q-B_LQFP128_14X14]  291.51 23.88 0 top
UE6  KC3810_QFN24_4X4  [KC3810NF-A0_QFN24_4X4]  283.96 7.43 180 top
UE9  -  [SY6288C20AAC_SOT23-5]  352 30.03 180 top
UE10  KC3810_QFN24_4X4  [KC3810NF-A0_QFN24_4X4]  248.02 8.12 180 top
UE12  -  [SY6288D20AAC_SOT23-5]  300.45 43.12 90 bottom
UE13  -  [SY6288C20AAC_SOT23-5]  270.04 81.36 90 top
UH1  CNP-H_BGA874  [CNP-H_BGA_874P-T]  292.35 41.44 180 top
UH3  -  [TC7SH08FU_SSOP5]  282.18 75.88 180 bottom
UH4  -  [W25Q128JVSIQ_SO8]  255.63 103.72 90 bottom
UL1  E3000-CG QFN 88P E-LAN CTRL  [RTL8125-CG_QFN88_10X10]  188.84 165.11 180 top
UL2  BOTH_QVP2014R  [BOTH_QVP2014R_24P]  198.21 164.34 0 top
UL4  -  [AT93C46D-TH-T_TSSOP8]  161.77 174.65 270 top
UL10  -  [SY8003EDFC_DFN8_2X2]  195.15 164.83 180 top
UL11  -  [SY8003EDFC_DFN8_2X2]  171.43 163.45 0 top
UL13  -  [SY8003EDFC_DFN8_2X2]  161.68 163.84 270 top
UL14  -  [SY6288D20AAC_SOT23-5]  166.43 167.75 90 top
UM3  -  [TC7SH08FU_SSOP5]  169.28 196.55 0 bottom
UM4  PI6CEQ20200LIEX  [PI6CEQ20200LIEX_TSSOP20]  164.67 169.95 180 bottom
UM7  TC7SH08FU_SSOP5~D  [TC7SH08FU_SSOP5]  184.58 188.93 180 top
UM8  -  [DS80PCI402SQNOPB_WQFN54_10X5P5]  175.06 178 180 bottom
US1  KXCNL-1010_LGA16_3X3  [LNG3DMTR_LGA16_3X3]  224.42 16.53 180 bottom
US2  -  [LSM6DSLUSTR_LGA14_2P5X3]  111.5 172.5 0 top
US3  -  [LIS2DH12TR_LGA12_2X2]  276.78 80.15 0 top
UT1  ALPINE-RIDGE_BGA337  [ALPINE-RIDGE_BGA_337P]  19.49 47.95 270 bottom
UT2  -  [W25Q80DVSSIG_SO8]  37.27 32.1 90 bottom
UT3  -  [NL17SZ08DFT2G_SC70-5]  282.58 83.16 180 top
UT4  SN1703018ZQZR BGA96P  [TPS65982_BGA_96P]  41.29 44.57 0 bottom
UT5  -  [AOZ1336_DFN8_2X2]  89.88 18.09 90 bottom
UT6  -  [DS80PCI402SQNOPB_WQFN54_10X5P5]  49.33 21.22 90 top
UT7  PI6CEQ20200LIEX  [PI6CEQ20200LIEX_TSSOP20]  50.46 16.28 270 top
UT8  -  [SY6288D20AAC_SOT23-5]  56.49 24.4 270 top
UT10  -  [AP2330W-7_SC59-3]  14.23 50.21 90 top
UU1  -  [TPS2546RTER_QFN16_3X3]  36.98 15 90 top
UU3  -  [SY6288C20AAC_SOT23-5]  376.32 39.1 90 top
UU5  TC7SZ14FU_SSOP5~D  [TC7SZ14FU_SSOP5]  16.2 33.74 90 top
UU6  -  [PS8713BTQFN24GTR2-A_TQFN24_4X4]  31.42 26.13 270 top
UV64  -  [AOZ1334DI-02_DFN8-7_3X3]  113.08 120.43 0 top
UV65  -  [G517AH1TP1U_TSOT23-6]  107.96 123.58 180 top
UZ21  -  [AOZ1336DI_DFN8_2X2]  167.44 99.94 90 top
YE1  12MHZ 12PF +-10PPM X3S012000DC1H-X  [Y_X3G024000DC1H_4P]  361.26 44.19 180 bottom
YH1  32.768KHZ_X1A000141000300  [Y_CM31532768DZFT_2P]  261.98 64.02 90 top
YH2  24MHZ 12PF +-10PPM 7M24090001  [Y_X3G024000DC1H_4P]  298.63 47.79 90 bottom
YL1  25MHZ_20PF_7M25000153  [Y_7M25000153_4P]  184.83 157.99 180 bottom
YT1  25MHZ_20PF_XRCGB25M000F2P18R0  [Y_XRCGB25M000F2P18R0_4P]  25.84 24.98 180 bottom

## Library data of the parts
C1-C3 C6 C11 C29 C256 C258 C260 C263 C265 C266 C268 C270 C617 C618 C620-C625 C627 C628 C635-C638 C2498 C2500 C2502 C2506 C2507 C2509-C2511 C2516 C2518 C2519 C2521-C2525 C2531-C2533 C5360 C5361 CC1-CC4 CC6-CC21 CD18 CD19 CD22 CD23 CD29-CD31 CD51 CD52 CD54 CD55 CD81 CD82 CD85 CD86 CD113 CD114 CD116 CD117 CD125 CD130-CD134 CE1 CE2 CE5 CE6 CE8 CE19 CE24 CE28-CE32 CE34 CE35 CE38 CE40-CE46 CE51 CE59-CE65 CE79 CE81 CE82 CE86 CE87 CE169 CE171-CE176 CE201 CE202 CE205 CH36 CH45-CH49 CH173-CH175 CH186 CH190 CH192 CH197 CH226 CH231 CH232 CH234-CH246 CH264 CI38 CI39 CL1 CL2 CL5-CL9 CL21-CL23 CL25-CL29 CL31 CL45 CL46 CL52 CL59-CL62 CL64 CL71-CL79 CL90 CL98 CL100-CL102 CL104 CL107-CL117 CL119 CM9 CM16-CM18 CM20 CM23 CM32 CM34-CM36 CM70 CM98 CM99 CN1 CN4-CN7 CN9 CS5-CS7 CS16-CS20 CT50-CT53 CT81 CT82 CT88 CT94-CT98 CT101 CT103 CT104 CT114 CT115 CT117 CT118 CT121 CT123 CT156 CT200-CT204 CT209-CT212 CT214 CT215 CT5361 CU7 CU12 CU16 CU17 CU26 CU28 CU29 CU45-CU50 CU101 CU102 CU106-CU114 CU242-CU245 CV19 CV23 CV24 CV64 CV805 CV903 CV956 CV957 CV1071 CV1073 CV1074 CV1076 CV1078 CV1083 CV1084 CV1086-CV1103 CV1108 CV1109 PC1-PC13 PC15-PC17 PC19-PC25 PC101-PC103 PC106 PC108 PC112 PC200 PC201 PC208 PC210-PC214 PC216-PC218 PC301 PC302 PC305-PC307 PC310 PC311 PC318 PC319 PC705 PC708 PC711 PC721 PC747-PC749 PC751-PC753 PC765 PC768 PC769 PC777 PC779-PC781 PC791-PC794 PC1202-PC1204 PC1206 PC1207 PC1801 PC1805 PC1807 PC2501 PC2507 PCA01 PCA02 PCA03 PCA07 PCA08 PCA09 PCA11 PCA13 PCA14 PCA26 PCF01 PCF02 PCF04 PCF05 PCF11-PCF13 PCF15 PCG01 PCG02 PCG07 PCG08 PCG09 PCG10 PCG12 PCG13 PCG17-PCG19 PCG22 PCI06 PCI07 PCI09 PCI10 PCI15 PCI16 PCI18 PCI19 PCI25-PCI28 PCI35 PCI36 PCI41-PCI44 PCI46 PCI48 PCI52-PCI55 PCI62 PCI63 PCI68-PCI71 PCI73 PCI74 PCI79-PCI82 PCI201-PCI215 PCS19-PCS28 PCS48-PCS57 PCS67 PCS68 PCS84 PCS85 PCS2508-PCS2511 PCZ01 PCZ02 PCZ03 PCZ05 PCZ06 PCZ07 PCZ08 PCZ09-PCZ31 = C_0402
C4 C5 C2501 C2508 CC31 CC46 CC56-CC63 CD9-CD16 CD21 CD27 CD28 CD40-CD47 CD50 CD58 CD59 CD72-CD79 CD84 CD89 CD90 CD102-CD109 CD112 CD119 CD120 CE7 CE9 CE170 CE177 CH80-CH83 CH176 CH177 CH180 CH183-CH185 CH187 CH188 CH201-CH217 CH227-CH230 CH247-CH262 CL3 CL4 CL91-CL97 CL99 CL121-CL127 CL129 CM21 CM22 CM30 CM33 CM37 CM38 CM62-CM69 CT1-CT16 CT18 CT21 CT23-CT49 CT54-CT72 CT77-CT80 CT83-CT86 CT102 CT108-CT113 CT153 CT205 CT208 CT213 CT217-CT219 CU104 CU105 = C_0201
C8 CC32 CC49-CC52 CE80 CE204 CF5-CF7 CH56 CH263 CL118 CN2 CT122 CU2 CU10 CV21 CV806 PC303 PC304 PC308 PC309 PC1205 PC1208 PCA15-PCA18 PCG27-PCG37 PCI96-PCI133 = C_0805
C257 C261 C262 C264 C267 C269 C2512-C2515 CC22-CC30 CC33-CC38 CC47 CC48 CD1-CD8 CD20 CD24 CD25 CD32-CD39 CD49 CD53 CD56 CD64-CD71 CD83 CD87 CD88 CD94-CD101 CD111 CD115 CD118 CE22 CE203 CF4 CH52 CH53 CH181 CH182 CH189 CH233 CL20 CL24 CL40-CL44 CL47-CL51 CL53-CL58 CL63 CL65-CL70 CL80-CL82 CL103 CL120 CM19 CM29 CM31 CN3 CN8 CS1 CS2 CT73-CT75 CT90-CT93 CT99 CT100 CT106 CT116 CT124 CT154 CT155 CT157 CT206 CT207 CT216 CU3 CU11 CU27 CV902 CV1079-CV1082 CV1085 CV1104-CV1107 PC14 PC18 PC104 PC105 PC107 PC109 PC202-PC207 PC219 PC220 PC316 PC317 PC750 PC757 PC760-PC764 PC766 PC767 PC775 PC776 PC778 PC795 PC796 PC1201 PC1802-PC1804 PC1806 PC2502-PC2506 PCA04 PCA05 PCA06 PCA10 PCA12 PCA19-PCA25 PCF03 PCF06 PCF07 PCF08 PCF09 PCF10 PCF14 PCG03 PCG04 PCG05 PCG06 PCG11 PCG14-PCG16 PCG20 PCG21 PCG38 PCG39 PCI08 PCI12-PCI14 PCI17 PCI20 PCI29 PCI37-PCI40 PCI45 PCI47 PCI49-PCI51 PCI56 PCI64-PCI67 PCI72 PCI75-PCI78 PCI83 PCI134-PCI139 PCI141-PCI148 PCS01 PCS02 PCS04 PCS05 PCS29-PCS32 PCS42 PCS58 PCS69-PCS79 PCS81-PCS83 PCZ04 = C_0603
C631 C641 CU6 PCS03 PCS06 PCS61 PCS62 = C_B2
CD17 CD48 CD80 CD110 PC110 PC111 PC209 PC215 PC312-PC315 PCG23-PCG26 PCI86-PCI95 = C_D2
CL10 = C_1808
CLIP1 = CLIP_10P2X7P2_SHIELDING_CASE1
CLIP2 = EMIST_SQ-42G-2_1P
CLRP1 = SHORTPADS: User Part Number: PART#
DE1 DF1 DF2 DU6 DU8 PDS01 PDS02 PDS705 = SDMK0340L-7-F_SOD323-2
DE2 DE3 DH1 = RB751V-40_SOD323-2
DK1-DK3 PD3 PD4 = TVNST52302AB0_SOT523-3
DN1 DN2 = RB751S40T1G_SOD523-2
DS1 DT1 = RB520SM-30T2R_EMD2-2
DT2-DT9 DT11-DT14 = PESD5V0H1BSF_SOD962-2-2
DT10 DU2 DU12 DU13 = TVWDF1004AD0_DFN9
DT15 = PESD24VS2UT_SOT23-3
DU9-DU11 = PESD5V0U2BT_SOT23-3
FD1 FD2 FD10 FD11 = FIDUCIAL_C40M80
H1-H5 H8 H65 = H_3P8-G
H42 H63 = H_3P8
H43-H55 = H_3P0-G
H56 H58 H60 H70 = H_3P2
H57 H59 = H_3P3
H72 = H_3P0N
H73 = H_4P0X3P0N
J4-J6 PJP1801 PJP1802 PJP2501 PJP2502 = JUMP_43X79
JAUDIO = ACES_50473-0300M-P01_30P
JCDRA = TE_2260531-1_46P
JDBG = CVILU_CH31052VA00-NH_5P
JDG = ACES_50293-0107N-P02_10P
JDGFF1 JDGFF2 = UNIMI_FBGCAX011_68P-T
JDIMM1 = LOTES_ADDR0205-P001A02_260P
JDIMM2 = LOTES_ADDR0070-P025A_260P
JDIMM3 = LOTES_ADDR0069-P009A_260P-T
JDIMM4 = LOTES_ADDR0206-P001A02_260P
JELC = CVILU_CH51102M100-0P_10P-T
JFAN1 JFAN2 = ACES_50273-0050N-001_5P
JFC = CVILU_CI1110M2VR0-NH_10P
JHDD = ACES_50406-02071-001_20P
JLAN = SANTA_130456-931_13P-T
JP3 JP6 PJP102 PJP103 PJP200 PJP201 PJP301-PJP304 PJPF02 = JUMP_43X118
JPCMC = INTEL_CMC_PRIMARY_36P-T
JPK = ACES_51519-02001-P01_20P
JPWR = ACES_50611-0060B-P01_6P
JRTC = ACES_50271-0020N-001_2P
JSSD1 = LOTES_APCI0096-P002A_75P
JSSD2 = LOTES_APCI0181-P001A_75P
JTOBII = ACES_50228-0067N-001_6P
JTP = ACES_51625-01601-001_16P
JTRON = ACES_50238-02471-002_24P
JUSB1 = TAIWI_USB050-10B7CRL-TWD_10P-T
JUSB2 JUSB3 = ACON_TCRAY-9U1U91_9P-T
JUSBC = JAE_DX07S024JJ5R1200_24P
JWDB = ACES_50207-00471-P01_4P-T
JWLAN = LOTES_APCI0128-P005A_75P
LE1 LE2 = KC_FBMA-L11-160808-800LMT_2P
LE3 LE7 LM1 LT2 LT3 LU3-LU5 = MURAT_DLM0NSN900HY2D_4P
LE4 = MURAT_BLM15AG121SN1D_L0402_2P
LH1 LH2 = TDK_MLF1608A2R2KT_2P
LL1 LL2 LL4 = TAI-T_AHP252010HF-1R0M_2P
LT1 = MAG_MND-04ABIR60M-XGL_2P
LT4 = MURAT_LQM18PN1R0MFHD_2P
PBATT1 = ACES_51481-01371-P01_13P
PC797 PC798 PC800 = C_T521D107M025ATE060
PCI11 PCI21 PCI140 = C_ECST250ADA101MF611
PCI149 PCI150 = C_D1
PD1 PD2 = TP0610K-T1-E3_SOT23-3
PD5 PD301 = BAS40CW_SOT323-3
PD200 = D_SOD323-2
PD704 PD706 = BAT54CW_SOT323-3
PD705 = SS5P10-M3-86A_TO277A3
PD1201 = SX34_SMA2
PDS03 PDS04 PDS706 = SMF4L22A_SOD123FL2
PH1 PHZ01 PHZ02 PHZ03 PHZ04 PR1-PR19 PR21-PR26 PR28 PR34-PR38 PR40 PR41 PR101 PR103 PR104 PR106-PR108 PR201 PR205-PR207 PR209 PR210 PR212-PR217 PR301-PR307 PR314 PR317 PR727 PR729 PR731 PR732 PR740-PR742 PR745 PR749 PR751-PR757 PR760 PR764 PR772 PR774 PR1201 PR1203-PR1206 PR1801-PR1806 PR2502-PR2506 PRA01 PRA02 PRA05 PRA06 PRA07 PRA08 PRA09-PRA18 PRA20 PRA22 PRF02 PRF05 PRF06 PRF07 PRF09-PRF11 PRG02 PRG03 PRG04 PRG09-PRG13 PRG15 PRG16 PRG21-PRG23 PRI11 PRI12 PRI14 PRI19 PRI20 PRI22 PRI23 PRI27 PRI29 PRI30 PRI34 PRI36-PRI38 PRI52 PRI54 PRI55 PRI60-PRI63 PRI67 PRI69 PRI70 PRI75-PRI78 PRI92 PRI94 PRI95 PRI100-PRI103 PRI107 PRI109 PRI110 PRI115-PRI118 PRI201-PRI204 PRI207 PRI208 PRI210 PRI211 PRI214-PRI218 PRI220 PRI221 PRI223 PRI226-PRI230 PRS02 PRS03 PRS09 PRS14 PRS15 PRS18 PRS20 PRS22 PRS23 PRS29 PRS34 PRS35 PRS38 PRS40 PRS53-PRS70 PRS75-PRS80 PRS86 PRS87 PRS89 PRS90 PRS92-PRS95 PRS98 PRS99 PRZ01 PRZ03 PRZ05 PRZ06 PRZ08 PRZ11 PRZ13-PRZ20 PRZ22 PRZ23 PRZ25 PRZ27-PRZ43 PRZ45 R174 R179-R182 R307 R325 R367 R369-R379 R393-R400 R402-R411 RC1-RC5 RC9-RC14 RC16 RC17 RC19 RC21 RC25 RC26 RC35 RC36 RC62 RC63 RC197 RC348 RC353-RC356 RC684-RC688 RC690-RC693 RD1-RD18 RD26-RD32 RD38-RD44 RD51 RD52 RD54-RD57 RD62 RE1-RE17 RE20 RE21 RE23 RE25 RE28 RE31 RE40 RE42-RE44 RE63 RE64 RE66 RE70 RE71 RE74-RE76 RE83-RE85 RE100 RE101 RE154-RE158 RE160 RE161 RE201 RE530 RE642 RE643 RE645 RE650-RE657 RE659 RE660 RE662 RE684 RE685 RE688-RE693 RE695 RE696 RE698-RE700 RE704-RE707 RF1-RF6 RH1 RH2 RH4-RH7 RH9 RH11 RH14-RH16 RH31 RH32 RH38 RH39 RH63 RH70-RH72 RH79 RH83-RH85 RH88 RH89 RH95 RH99 RH100 RH103 RH104 RH109 RH111 RH130 RH135 RH180-RH182 RH184-RH188 RH193 RH199 RH213-RH216 RH218-RH220 RH453 RH460-RH463 RH495 RH501 RH502 RH506 RH512 RH515-RH518 RH520 RH521 RH524 RH525 RH531 RH533 RH545 RH571 RH580 RH581 RH588-RH591 RH594 RH598-RH607 RH617-RH623 RH627 RH628 RH631-RH637 RH706 RH707 RH1015-RH1018 RH1023-RH1027 RL1-RL6 RL8-RL11 RL14-RL18 RL20-RL25 RL41-RL43 RL51-RL54 RL58 RL60 RL66-RL69 RL71 RM5 RM6 RM17 RM18 RM20 RM21 RM25 RM27-RM29 RM38 RM41 RM42 RM61 RM91-RM94 RM96 RN1 RN6 RN8 RN30 RN120 RS18 RS19 RT5 RT19 RT25 RT52 RT53 RT88-RT90 RT97 RT108 RT109 RT112-RT117 RT122 RT132 RT242-RT244 RT247-RT250 RT693 RT707 RT708 RT711-RT714 RT729 RT731 RT733 RU1-RU7 RV1 RV2 RV4 = R_0402
PJP101 PJP202 PJP203 PJP1201 PJP1202 PJPA01 PJPF01 = JUMP_43X39
PJPDC1 PJPDC2 = ACES_50493-01301-P01_13P
PJPS01 PJPS02 PJPS03 PJPS04 = JUMP_43X118-NPM
PL1-PL5 PL7-PL11 PL311 PL312 = 5A_Z120_0805_2P
PL6 PL12 = MURAT_BLM15HG601SN1D_2P
PL13 PL14 = 9A_Z80_1812_2P
PL101 = L_7X7X3_M_2P
PL201 PLS01 PLS10 = MAG_MMD-10CZN1R0M-R1L_2P
PL301 PL302 = MAG_MMD-10CZ-2R2M-X2L_2P
PL700 = L_10X10X4_M_2P
PL711 = CYNTE_PCMB063T-1R0MS_2P
PL1201 = MAG_MMD-05CZ-3R3M-M7L_2P
PLA01 = MAG_MMD05CZR47M_4P
PLF01 = CYNTE_PCMB042T-1R0MS_2P
PLG01 PLG02 PLI01 PLI02 PLI03 PLI04 PLI05 PLI06 = L_7X7X4_M
PLI11 PLI12 = KC_FBMA-L11-453215800LMA90T_2P
PLS02 PLS04 = MAGIC_SRPG1005-1R0M-AD_2P
PQ1 PQ3 = FDV301N_NL_SOT23-3
PQ2 PQ4 = RHU002N06_SOT323-3
PQ6 PQ10 PQS13 PQS17 Q7-Q9 = DMN65D8LDW-7_SOT363-6
PQ7 PQ9 PQ11 PQ12 PQS18 PQS19 PQS23 PQS28 Q2410 = SSM3K7002FU_SC70-3
PQ8 = SI3457CDV-T1-GE3_TSOP6
PQ101 = AON7408L_DFN8-5
PQ102 = AON7752_DFN3X3EP8-5
PQ200 PQS01 PQS02 PQS03 PQS06 PQS07 PQS09 = AON6380_DFN5X6-8-5
PQ201 = AON6414AL_DFN8-5
PQ202 PQS29 PQS30 = 2N7002DW-7-F_SOT363-6
PQ301 PQ303 = AON7534_DFN3X3-8-5
PQ302 PQ304 = AON7508_DFN8-5
PQ704 PQ708 = PK5N2EA_PDFN5X6P8-5
PQ709 PQS31 = LMUN5113T1G_SOT323-3
PQ710 PQS32 = LTC015EUBFS8TL_UMT3F
PQ717 = EMB04N03H_EDFN5X6-8-5
PQA01 = AON6992_DFN5X6D-8-7
PQS04 PQS08 = AON7380_DFN3X3-8-5
PQS05 PQS11 = Q_N_DFN56-8-5
PQS10 PQS15 = AON6403_DFN5X6-8-5
PQS12 PQS16 = NTR4502PT1G_SOT23-3
PQS22 PQS24 PQS26 PQS27 = AO3409_SOT23-3
PR20 PR27 PR42 PR44 PR45 PR208 PR211 PR312 PR313 PR315 PR750 PR769 PR770 PR775-PR777 PR779 PR792 PR2501 PRA19 PRA21 PRA23 PRF01 PRF08 PRG01 PRG05 PRG14 PRG17 PRI13 PRI15 PRI28 PRI31 PRI53 PRI56 PRI68 PRI71 PRI93 PRI96 PRI108 PRI111 PRI205 PRI206 PRI209 PRI212 PRI213 PRI219 PRI222 PRI224 PRI225 PRS10 PRS12 PRS13 PRS19 PRS30 PRS32 PRS33 PRS39 PRS73 PRS74 PRZ02 PRZ04 PRZ07 PRZ09 PRZ10 PRZ12 PRZ21 PRZ24 PRZ26 PRZ44 R185 R412 RE77 RH613 RH614 RL57 = R0402_0OHM
PR102 PR200 PR203 PR204 PR308 PR309 PR771 PR773 PR793 PRA03 PRB66 PRF03 PRG06 PRG08 PRG18 PRG20 PRI16 PRI18 PRI32 PRI33 PRI57 PRI59 PRI72 PRI74 PRI97 PRI99 PRI112 PRI114 PRS04 PRS11 PRS24 PRS31 PRS96 PRS97 RD58-RD61 RE24 RE50 RE78 RE79 RL30 RL38-RL40 RL44-RL50 RL70 RT110 RT111 RT260 = R_0603
PR105 PR202 PR310 PR311 PR743 PR766 PR1202 PRA04 PRF04 PRG07 PRG19 PRI17 PRI35 PRI58 PRI73 PRI98 PRI113 PRS08 PRS41 PRS83 PRS85 = R_1206
PR703 PR765 PRS01 PRS21 = R_2512_4P
PR761 = R0603_0OHM
PRS06 PRS26 RH12 RN20 RN122 RT95 RT730 = R_0805
PU101 = TPS51212DSCR_SON10_3X3
PU201 = RT8207PGQW_WQFN20_3X3
PU301 = TPS51225CRUKR_QFN20_3X3
PU703 = ISL95520HRZ-T_QFN32_4X4
PU1201 = RT9297GQW_WDFN10_3X3
PU1801 PU2501 = RT9059GSP_SO8
PUA01 = ISL95870BHRZ-T_QFN20_3X4
PUF01 = SY8286RAC_QFN20_3X3
PUG01 PUG02 PUI01 PUI02 PUI03 PUI04 PUI05 PUI06 = SIC632CDT1GE3_POWERPAK31_5X5
PUI07 PUI08 PUI09 = ISL6617CRZ-T_DFN10_3X3
PUS1 PUS2 = ISL95338HRTZ-T_TQFN32_4X4
PUZ01 = ISL95829CHRTZ-T_TQFN48_6X6
Q2407 Q2411 Q2412 = MMBT3904WH_SOT323-3
Q2409 = AO6424A_TSOP6
QE1 QE3-QE5 QE13 QE21 QE22 QE64 QH5 QM2 QT2 = DMN66D0LDW-7_SOT363-6
QE2 QE58 QE59 QE65 = 2N7002W-T-R7_SOT323-3
QE8 QM1 QM3 = SI2301CDS-T1-GE3_SOT23-3
QH1 = MESS138W-G_SOT323-3
QN8 QN9 = L2N7002DW1T1G_SC88-6
QS3 = L2N7002WT1G_SC-70-3
R363 R365 RE18 RE19 RE33 RE300 RE646 RE661 RE663 RE668 RE669 RE678-RE681 RE694 RE701-RE703 RG555 RG556 RH21 RH25-RH30 RH91 RH92 RH200 RH537 RH558 RH722-RH725 RH1021 RL12 RL13 RM1 RM2 RM14 RM23 RM26 RM62 RM64 RM66 RM70 RM72 RM75 RM76 RM79 RM81 RM82 RM84-RM87 RN7 RN9 RN101-RN109 RN111 RN113 RN117-RN119 RN123-RN126 RP2 RP5-RP10 RS1 RS2 RS9-RS12 RS15 RS16 RT1-RT4 RT6-RT18 RT20-RT23 RT26-RT51 RT59-RT73 RT75-RT80 RT83 RT86 RT94 RT98-RT102 RT107 RT124-RT131 RT200 RT216-RT231 RT233-RT241 RT245 RT246 RT694 RT695 RT702 RT705 RT706 RT709 RT710 RT716-RT728 RT732 = R_0201
RE90 RP3 RPC7 RPH5 RPH6 = RP_0804_8P4R
RE200 RE202 RU123-RU126 = R_0201-NPM
RE647 RE648 = R_0402-NPM
RS17 = R0201_0OHM
SW2 SW3 = SW_EVQPLHA15_4P
T2 T49 T50 T62-T65 T70 T114 T120-T122 T135 T360-T362 T364-T372 TC2 TC7 TC12-TC26 TC28-TC30 TD1-TD8 = TPC12
U16 UV64 = AOZ1334DI-02_DFN8-7_3X3
U17 = TPS22966DPUR_SON14_2X3
U18 UE9 UE13 UU3 = SY6288C20AAC_SOT23-5
U19 = AOZ1334DI-01_DFN8-7_3X3
U2407 = F75305M_MSOP10
U2408 = F75397M_MSOP8
UC1 = LOTES_AZIF0049-P001C_1151P-T
UC2 = 74AUP1G07GW_TSSOP5
UE1 = STM32F070CBT6TR_LQFP48_7X7
UE2 = EN25F80-75HCP_SO8
UE3 = TLC59116FIRHBR_VQFN32_5X5
UE5 = KB9542Q-B_LQFP128_14X14
UE6 UE10 = KC3810NF-A0_QFN24_4X4
UE12 UL14 UT8 = SY6288D20AAC_SOT23-5
UH1 = CNP-H_BGA_874P-T
UH3 UM3 UM7 = TC7SH08FU_SSOP5
UH4 = W25Q128JVSIQ_SO8
UL1 = RTL8125-CG_QFN88_10X10
UL2 = BOTH_QVP2014R_24P
UL4 = AT93C46D-TH-T_TSSOP8
UL10 UL11 UL13 = SY8003EDFC_DFN8_2X2
UM4 UT7 = PI6CEQ20200LIEX_TSSOP20
UM8 UT6 = DS80PCI402SQNOPB_WQFN54_10X5P5
US1 = LNG3DMTR_LGA16_3X3
US2 = LSM6DSLUSTR_LGA14_2P5X3
US3 = LIS2DH12TR_LGA12_2X2
UT1 = ALPINE-RIDGE_BGA_337P
UT2 = W25Q80DVSSIG_SO8
UT3 = NL17SZ08DFT2G_SC70-5
UT4 = TPS65982_BGA_96P
UT5 = AOZ1336_DFN8_2X2
UT10 = AP2330W-7_SC59-3
UU1 = TPS2546RTER_QFN16_3X3
UU5 = TC7SZ14FU_SSOP5
UU6 = PS8713BTQFN24GTR2-A_TQFN24_4X4
UV65 = G517AH1TP1U_TSOT23-6
UZ21 = AOZ1336DI_DFN8_2X2
YE1 YH2 = Y_X3G024000DC1H_4P
YH1 = Y_CM31532768DZFT_2P
YL1 = Y_7M25000153_4P
YT1 = Y_XRCGB25M000F2P18R0_4P

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
2N7002DW-7-F_SOT363-6
  oval 0.432x0.61 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0.65,1.9) 6(0,1.9)
2N7002W-T-R7_SOT323-3
  oval 0.813x0.914 smd: 1(0,0) 2(0.65,1.6) 3(-0.65,1.6)
5A_Z120_0805_2P
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
9A_Z80_1812_2P
  rect 1.803x3.404 smd: 1(0,0) 2(3.8,0)
74AUP1G07GW_TSSOP5
  oval 0.381x1.346 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.79) 5(0,1.79)
ACES_50207-00471-P01_4P-T
  oval 0.508x0.991 smd: 1(0,0) 2(-0.8,0) 3(-1.6,0) 4(-2.4,0)
  rect 1.194x1.702 smd: 5(-3.7,1.45) 6(1.3,1.45)
ACES_50228-0067N-001_6P
  oval 0.61x1.549 smd: 1(0,0) 2(-1,0) 3(-2,0) 4(-3,0) 5(-4,0) 6(-5,0)
  rect 1.194x1.803 smd: 7(1.3,2.525) 8(-6.3,2.525)
ACES_50238-02471-002_24P
  oval 0.61x1.6 smd: 1(0,0) 2(0,5.6) 3(1,0) 4(1,5.6) 5(2,0) 6(2,5.6) 7(3,0) 8(3,5.6) 9(4,0) 10(4,5.6) 11(5,0) 12(5,5.6) 13(6,0) 14(6,5.6) 15(7,0) 16(7,5.6) 17(8,0) 18(8,5.6) 19(9,0) 20(9,5.6) 21(10,0) 22(10,5.6) 23(11,0) 24(11,5.6)
  rect 0.838x1.803 smd: 25(-1.325,3.2) 26(12.325,3.2)
ACES_50271-0020N-001_2P
  oval 0.787x1.6 smd: 1(0,0) 2(1.25,0)
  rect 2.108x2.997 smd: 3(3.8,-2.9) 4(-2.55,-2.9)
ACES_50273-0050N-001_5P
  oval 0.787x1.6 smd: 1(0,0) 2(1.25,0) 3(2.5,0) 4(3.75,0) 5(5,0)
  rect 2.108x2.997 smd: 6(7.55,-2.9) 7(-2.55,-2.9)
ACES_50293-0107N-P02_10P
  rect 0.838x7.01 smd: 1(0,0) 2(1.5,0) 3(3,0) 4(4.5,0) 5(6,0) 6(7.5,0) 7(9,0) 8(10.5,0) 9(12,0) 10(13.5,0)
ACES_50406-02071-001_20P
  oval 0.254x1.295 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0) 19(9,0) 20(9.5,0)
  rect 1.194x2.692 smd: 21(-2.4,1.95) 22(11.9,1.95)
  rect 2.311x1.295 smd: 23(0.85,3.9) 24(8.65,3.9)
ACES_50473-0300M-P01_30P
  oval 0.254x1.092 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0) 19(9,0) 20(9.5,0) 21(10,0) 22(10.5,0) 23(11,0) 24(11.5,0) 25(12,0) 26(12.5,0) 27(13,0) 28(13.5,0) 29(14,0) 30(14.5,0)
  rect 0.559x1.092 smd: 31(-0.9,0) 32(15.4,0)
  rect 1.397x1.905 smd: 33(-3.1,-2.92) 34(17.6,-2.92)
ACES_50493-01301-P01_13P
  rect 0.838x7.01 smd: 1(0,0) 2(-1.5,0) 3(-3,0) 4(-4.5,0) 5(-6,0) 6(-7.5,0) 7(-9,0) 8(-10.5,0) 9(-12,0) 10(-13.5,0) 11(-15,0) 12(-16.5,0) 13(-18,0)
ACES_50611-0060B-P01_6P
  oval 0.61x1.651 smd: 1(0,0) 3(1,0) 5(2,0) 7(3,0) 9(4,0) 11(5,0)
  oval 0.61x1.854 smd: 2(0,3.75) 4(1,3.75) 6(2,3.75) 8(3,3.75) 10(4,3.75) 12(5,3.75)
ACES_51481-01371-P01_13P
  rect 0.838x7.01 smd: 1(0,0) 2(1.5,0) 3(3,0) 4(4.5,0) 5(6,0) 6(7.5,0) 7(9,0) 8(10.5,0) 9(12,0) 10(13.5,0) 11(15,0) 12(16.5,0) 13(18,0)
ACES_51519-02001-P01_20P
  oval 0.305x0.991 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0) 19(9,0) 20(9.5,0)
  rect 1.803x2.21 smd: 21(11.65,-5.5) 22(-2.15,-5.5)
ACES_51625-01601-001_16P
  oval 0.305x1.092 smd: 1(0,0) 2(-0.5,0) 3(-1,0) 4(-1.5,0) 5(-2,0) 6(-2.5,0) 7(-3,0) 8(-3.5,0) 9(-4,0) 10(-4.5,0) 11(-5,0) 12(-5.5,0) 13(-6,0) 14(-6.5,0) 15(-7,0) 16(-7.5,0)
  rect 0.991x2.489 smd: 17(1.8,-3.6) 18(-9.3,-3.6)
ACON_TCRAY-9U1U91_9P-T
  round 1.295 hole 0.711: 1(0,0) 2(-2.5,0) 3(-4.5,0) 4(-7,0) 5(-7.5,-1.5) 6(-5.5,-1.5) 7(-3.5,-1.5) 8(-1.5,-1.5) 9(0.5,-1.5)
  oval 1.295x2.311 hole 0.711x1.702: 10(-9.9,0.3) 12(2.9,0.3)
  oval 1.295x2.007 hole 0.711x1.397: 11(-11.2,-8.95) 13(4.2,-8.95)
ALPINE-RIDGE_BGA_337P
  round 0.254 smd: A1(0,0) A23(10.12,0) AA2(0.46,-9.2) AA22(9.66,-9.2) AB2(0.46,-9.66) AB3(0.92,-9.66) AB4(1.38,-9.66) AB5(1.84,-9.66) AB6(2.3,-9.66) AB7(2.76,-9.66) AB8(3.22,-9.66) AB9(3.68,-9.66) AB10(4.14,-9.66) AB11(4.6,-9.66) AB12(5.06,-9.66) AB13(5.52,-9.66) AB14(5.98,-9.66) AB15(6.44,-9.66) AB16(6.9,-9.66) AB17(7.36,-9.66) AB18(7.82,-9.66) AB19(8.28,-9.66) AB20(8.74,-9.66) AB21(9.2,-9.66) AB22(9.66,-9.66) AC1(0,-10.12) AC23(10.12,-10.12) B2(0.46,-0.46) B3(0.92,-0.46) B4(1.38,-0.46) B5(1.84,-0.46) B6(2.3,-0.46) B7(2.76,-0.46) B8(3.22,-0.46) B9(3.68,-0.46) B10(4.14,-0.46) B11(4.6,-0.46) B12(5.06,-0.46) B13(5.52,-0.46) B14(5.98,-0.46) B15(6.44,-0.46) B16(6.9,-0.46) B17(7.36,-0.46) B18(7.82,-0.46) B19(8.28,-0.46) B20(8.74,-0.46) B21(9.2,-0.46) B22(9.66,-0.46) C2(0.46,-0.92) C22(9.66,-0.92) D2(0.46,-1.38) D4(1.16,-1.16) D5(1.81,-1.16) D6(2.46,-1.16) D8(3.11,-1.16) D9(3.76,-1.16) D11(4.41,-1.16) D12(5.06,-1.16) D13(5.71,-1.16) D15(6.36,-1.16) D16(7.01,-1.16) D18(7.66,-1.16) D19(8.31,-1.16) D20(8.96,-1.16) D22(9.66,-1.38) E2(0.46,-1.84) E4(1.16,-1.81) E5(1.81,-1.81) E6(2.46,-1.81) E8(3.11,-1.81) E9(3.76,-1.81) E11(4.41,-1.81) E12(5.06,-1.81) E13(5.71,-1.81) E15(6.36,-1.81) E16(7.01,-1.81) E18(7.66,-1.81) E19(8.31,-1.81) E20(8.96,-1.81) E22(9.66,-1.84) F2(0.46,-2.3) F4(1.16,-2.46) F5(1.81,-2.46) F6(2.46,-2.46) F8(3.11,-2.46) F9(3.76,-2.46) F11(4.41,-2.46) F12(5.06,-2.46) F13(5.71,-2.46) F15(6.36,-2.46) F16(7.01,-2.46) F18(7.66,-2.46) F19(8.31,-2.46) F20(8.96,-2.46) F22(9.66,-2.3) G2(0.46,-2.76) G22(9.66,-2.76) H2(0.46,-3.22) H4(1.16,-3.11) H5(1.81,-3.11) H6(2.46,-3.11) H8(3.11,-3.11) H9(3.76,-3.11) H11(4.41,-3.11) H12(5.06,-3.11) H13(5.71,-3.11) H15(6.36,-3.11) H16(7.01,-3.11) H18(7.66,-3.11) H19(8.31,-3.11) H20(8.96,-3.11) H22(9.66,-3.22) J2(0.46,-3.68) J4(1.16,-3.76) J5(1.81,-3.76) J6(2.46,-3.76) J8(3.11,-3.76) J9(3.76,-3.76) J11(4.41,-3.76) J12(5.06,-3.76) J13(5.71,-3.76) J15(6.36,-3.76) J16(7.01,-3.76) J18(7.66,-3.76) J19(8.31,-3.76) J20(8.96,-3.76) J22(9.66,-3.68) K2(0.46,-4.14) K22(9.66,-4.14) L2(0.46,-4.6) L4(1.16,-4.41) L5(1.81,-4.41) L6(2.46,-4.41) L8(3.11,-4.41) L9(3.76,-4.41) L11(4.41,-4.41) L12(5.06,-4.41) L13(5.71,-4.41) L15(6.36,-4.41) L16(7.01,-4.41) L18(7.66,-4.41) L19(8.31,-4.41) L20(8.96,-4.41) L22(9.66,-4.6) M2(0.46,-5.06) M4(1.16,-5.06) M5(1.81,-5.06) M6(2.46,-5.06) M8(3.11,-5.06) M9(3.76,-5.06) M11(4.41,-5.06) M12(5.06,-5.06) M13(5.71,-5.06) M15(6.36,-5.06) M16(7.01,-5.06) M18(7.66,-5.06) M19(8.31,-5.06) M20(8.96,-5.06) M22(9.66,-5.06) N2(0.46,-5.52) N4(1.16,-5.71) N5(1.81,-5.71) N6(2.46,-5.71) N8(3.11,-5.71) N9(3.76,-5.71) N11(4.41,-5.71) N12(5.06,-5.71) N13(5.71,-5.71) N15(6.36,-5.71) N16(7.01,-5.71) N18(7.66,-5.71) N19(8.31,-5.71) N20(8.96,-5.71) N22(9.66,-5.52) P2(0.46,-5.98) P22(9.66,-5.98) R2(0.46,-6.44) R4(1.16,-6.36) R5(1.81,-6.36) R6(2.46,-6.36) R8(3.11,-6.36) R9(3.76,-6.36) R11(4.41,-6.36) R12(5.06,-6.36) R13(5.71,-6.36) R15(6.36,-6.36) R16(7.01,-6.36) R18(7.66,-6.36) R19(8.31,-6.36) R20(8.96,-6.36) R22(9.66,-6.44) T2(0.46,-6.9) T4(1.16,-7.01) T5(1.81,-7.01) T6(2.46,-7.01) T8(3.11,-7.01) T9(3.76,-7.01) T11(4.41,-7.01) T12(5.06,-7.01) T13(5.71,-7.01) T15(6.36,-7.01) T16(7.01,-7.01) T18(7.66,-7.01) T19(8.31,-7.01) T20(8.96,-7.01) T22(9.66,-6.9) U2(0.46,-7.36) U22(9.66,-7.36) V2(0.46,-7.82) V4(1.16,-7.66) V5(1.81,-7.66) V6(2.46,-7.66) V8(3.11,-7.66) V9(3.76,-7.66) V11(4.41,-7.66) V12(5.06,-7.66) V13(5.71,-7.66) V15(6.36,-7.66) V16(7.01,-7.66) V18(7.66,-7.66) V19(8.31,-7.66) V20(8.96,-7.66) V22(9.66,-7.82) W2(0.46,-8.28) W4(1.16,-8.31) W5(1.81,-8.31) W6(2.46,-8.31) W8(3.11,-8.31) W9(3.76,-8.31) W11(4.41,-8.31) W12(5.06,-8.31) W13(5.71,-8.31) W15(6.36,-8.31) W16(7.01,-8.31) W18(7.66,-8.31) W19(8.31,-8.31) W20(8.96,-8.31) W22(9.66,-8.28) Y2(0.46,-8.74) Y4(1.16,-8.96) Y5(1.81,-8.96) Y6(2.46,-8.96) Y8(3.11,-8.96) Y9(3.76,-8.96) Y11(4.41,-8.96) Y12(5.06,-8.96) Y13(5.71,-8.96) Y15(6.36,-8.96) Y16(7.01,-8.96) Y18(7.66,-8.96) Y19(8.31,-8.96) Y20(8.96,-8.96) Y22(9.66,-8.74)
  oval 0.178x0.33 smd: A2(0.46,0) A3(0.92,0) A4(1.38,0) A5(1.84,0) A6(2.3,0) A7(2.76,0) A8(3.22,0) A9(3.68,0) A10(4.14,0) A11(4.6,0) A12(5.06,0) A13(5.52,0) A14(5.98,0) A15(6.44,0) A16(6.9,0) A17(7.36,0) A18(7.82,0) A19(8.28,0) A20(8.74,0) A21(9.2,0) A22(9.66,0) AC2(0.46,-10.12) AC3(0.92,-10.12) AC4(1.38,-10.12) AC5(1.84,-10.12) AC6(2.3,-10.12) AC7(2.76,-10.12) AC8(3.22,-10.12) AC9(3.68,-10.12) AC10(4.14,-10.12) AC11(4.6,-10.12) AC12(5.06,-10.12) AC13(5.52,-10.12) AC14(5.98,-10.12) AC15(6.44,-10.12) AC16(6.9,-10.12) AC17(7.36,-10.12) AC18(7.82,-10.12) AC19(8.28,-10.12) AC20(8.74,-10.12) AC21(9.2,-10.12) AC22(9.66,-10.12)
  oval 0.33x0.178 smd: AA1(0,-9.2) AA23(10.12,-9.2) AB1(0,-9.66) AB23(10.12,-9.66) B1(0,-0.46) B23(10.12,-0.46) C1(0,-0.92) C23(10.12,-0.92) D1(0,-1.38) D23(10.12,-1.38) E1(0,-1.84) E23(10.12,-1.84) F1(0,-2.3) F23(10.12,-2.3) G1(0,-2.76) G23(10.12,-2.76) H1(0,-3.22) H23(10.12,-3.22) J1(0,-3.68) J23(10.12,-3.68) K1(0,-4.14) K23(10.12,-4.14) L1(0,-4.6) L23(10.12,-4.6) M1(0,-5.06) M23(10.12,-5.06) N1(0,-5.52) N23(10.12,-5.52) P1(0,-5.98) P23(10.12,-5.98) R1(0,-6.44) R23(10.12,-6.44) T1(0,-6.9) T23(10.12,-6.9) U1(0,-7.36) U23(10.12,-7.36) V1(0,-7.82) V23(10.12,-7.82) W1(0,-8.28) W23(10.12,-8.28) Y1(0,-8.74) Y23(10.12,-8.74)
AO3409_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
AO6424A_TSOP6
  oval 1.473x0.508 smd: 1(0,0) 2(0,-0.95) 3(0,-1.9) 4(2.35,-1.9) 5(2.35,-0.95) 6(2.35,0)
AON6380_DFN5X6-8-5
  oval 0.508x0.838 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0)
  custom 1.15x1.15 smd: 5(1.905,3.69)
AON6403_DFN5X6-8-5
  oval 0.508x0.66 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0)
  custom 1.15x1.15 smd: 5(1.905,2.755)
AON6414AL_DFN8-5
  oval 0.61x1.27 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0)
  custom 1.105x1.105 smd: 5(1.905,3.36)
AON6992_DFN5X6D-8-7
  oval 0.66x0.635 smd: 1(0,0) 3(3.81,5.67) 4(2.54,5.67) 5(1.27,5.67) 6(0,5.67)
  custom 0.485x0.485 smd: 2(1.905,0.655)
  rect 3.988x2.667 smd: 7(1.905,3.62)
AON7380_DFN3X3-8-5
  oval 0.406x0.991 smd: 1(0,0) 2(0.66,0) 3(1.32,0) 4(1.98,0)
  custom 0.559x0.559 smd: 5(0.99,2.247)
AON7408L_DFN8-5
  oval 0.406x0.991 smd: 1(0,0) 2(0.66,0) 3(1.32,0) 4(1.98,0)
  custom 0.559x0.559 smd: 5(0.99,2.247)
AON7508_DFN8-5
  oval 0.406x0.991 smd: 1(0,0) 2(0.66,0) 3(1.32,0) 4(1.98,0)
  custom 0.559x0.559 smd: 5(0.99,2.247)
AON7534_DFN3X3-8-5
  oval 0.406x0.991 smd: 1(0,0) 2(0.66,0) 3(1.32,0) 4(1.98,0)
  custom 0.559x0.559 smd: 5(0.99,2.247)
AON7752_DFN3X3EP8-5
  oval 0.406x0.991 smd: 1(0,0) 2(0.66,0) 3(1.32,0) 4(1.98,0)
  custom 0.559x0.559 smd: 5(0.99,2.247)
AOZ1334DI-01_DFN8-7_3X3
  oval 0.305x0.406 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(1.95,2.6)
  oval 1.6x0.406 smd: 6(0.65,2.6)
  rect 2.388x1.6 smd: 7(0.975,1.3)
AOZ1334DI-02_DFN8-7_3X3
  oval 0.305x0.406 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(1.95,2.6)
  oval 1.6x0.406 smd: 6(0.65,2.6)
  rect 2.388x1.6 smd: 7(0.975,1.3)
AOZ1336_DFN8_2X2
  oval 0.254x0.787 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(1.5,2.2) 6(1,2.2) 7(0.5,2.2) 8(0,2.2)
  rect 1.499x0.889 smd: 9(0.75,1.1)
AOZ1336DI_DFN8_2X2
  oval 0.254x0.787 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(1.5,2.2) 6(1,2.2) 7(0.5,2.2) 8(0,2.2)
  rect 1.499x0.889 smd: 9(0.75,1.1)
AP2330W-7_SC59-3
  oval 0.787x0.991 smd: 1(0,0) 2(-0.95,-2.4) 3(0.95,-2.4)
AT93C46D-TH-T_TSSOP8
  oval 0.381x1.626 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(1.95,5.8) 6(1.3,5.8) 7(0.65,5.8) 8(0,5.8)
BAS40CW_SOT323-3
  oval 0.61x0.787 smd: 1(0,0) 2(0.65,1.6) 3(-0.65,1.6)
BAT54CW_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
BOTH_QVP2014R_24P
  oval 0.762x2.54 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(5.08,0) 6(6.35,0) 7(7.62,0) 8(8.89,0) 9(10.16,0) 10(11.43,0) 11(12.7,0) 12(13.97,0) 13(13.97,14.46) 14(12.7,14.46) 15(11.43,14.46) 16(10.16,14.46) 17(8.89,14.46) 18(7.62,14.46) 19(6.35,14.46) 20(5.08,14.46) 21(3.81,14.46) 22(2.54,14.46) 23(1.27,14.46) 24(0,14.46)
C_0201
  rect 0.381x0.356 smd: 1(0,0) 2(0.584,0)
C_0402
  rect 0.508x0.584 smd: 1(0,0) 2(0.914,0)
C_0603
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
C_0805
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
C_1808
  rect 1.041x2.311 smd: 1(0,0) 2(4.35,0)
C_B2
  rect 1.346x2.692 smd: 1(0,0) 2(-2.75,0)
C_D1
  rect 1.803x2.794 smd: 1(0,0) 2(6.5,0)
C_D2
  rect 2.388x2.794 smd: 1(0,0) 2(6.4,0)
C_ECST250ADA101MF611
  oval 3.505x1.6 smd: 1(0,0) 2(-5.4,0)
C_T521D107M025ATE060
  rect 2.362x2.438 smd: 1(0,0) 2(6.24,0)
CLIP_10P2X7P2_SHIELDING_CASE1
  custom 1.8x1.8 smd: 1(0,0)
CNP-H_BGA_874P-T
  round 0.305 smd: A2(0.354,0) A3(0.855,0) A4(1.355,0) A46(22.273,0) A47(22.773,0) A48(23.274,0) AA19(8.715,-9.765) AA20(9.49,-9.765) AA22(10.265,-9.765) AA23(11.039,-9.765) AA25(11.814,-9.765) AA27(12.589,-9.765) AA28(13.363,-9.765) AA30(14.138,-9.765) AA31(14.913,-9.765) AB19(8.715,-10.539) AB20(9.49,-10.539) AB22(10.265,-10.539) AB23(11.039,-10.539) AB25(11.814,-10.539) AB27(12.589,-10.539) AB28(13.363,-10.539) AB30(14.138,-10.539) AB31(14.913,-10.539) AC6(2.44,-10.735) AC7(3.202,-10.735) AC9(3.964,-10.735) AC11(4.726,-10.735) AC12(5.488,-10.735) AC14(6.25,-10.735) AC15(7.012,-10.735) AC17(7.774,-10.735) AC33(15.854,-10.735) AC35(16.616,-10.735) AC36(17.378,-10.735) AC38(18.14,-10.735) AC39(18.902,-10.735) AC41(19.664,-10.735) AC43(20.426,-10.735) AC44(21.188,-10.735) AD19(8.715,-11.314) AD20(9.49,-11.314) AD22(10.265,-11.314) AD23(11.039,-11.314) AD25(11.814,-11.314) AD27(12.589,-11.314) AD28(13.363,-11.314) AD30(14.138,-11.314) AD31(14.913,-11.314) AE6(2.44,-11.893) AE7(3.202,-11.893) AE9(3.964,-11.893) AE11(4.726,-11.893) AE12(5.488,-11.893) AE14(6.25,-11.893) AE15(7.012,-11.893) AE17(7.774,-11.893) AE33(15.854,-11.893) AE35(16.616,-11.893) AE36(17.378,-11.893) AE38(18.14,-11.893) AE39(18.902,-11.893) AE41(19.664,-11.893) AE43(20.426,-11.893) AE44(21.188,-11.893) AF19(8.715,-12.089) AF20(9.49,-12.089) AF22(10.265,-12.089) AF23(11.039,-12.089) AF25(11.814,-12.089) AF27(12.589,-12.089) AF28(13.363,-12.089) AF30(14.138,-12.089) AF31(14.913,-12.089) AG19(8.715,-12.863) AG20(9.49,-12.863) AG22(10.265,-12.863) AG23(11.039,-12.863) AG25(11.814,-12.863) AG27(12.589,-12.863) AG28(13.363,-12.863) AG30(14.138,-12.863) AG31(14.913,-12.863) AH9(3.895,-13.519) AH10(4.634,-13.328) AH12(5.412,-13.328) AH14(6.25,-13.328) AH15(7.025,-13.328) AH17(7.787,-13.328) AH33(15.841,-13.328) AH35(16.603,-13.328) AH36(17.378,-13.328) AH38(18.216,-13.328) AH40(18.994,-13.328) AH41(19.733,-13.519) AJ6(2.417,-13.9) AJ7(3.156,-13.709) AJ19(8.715,-13.638) AJ20(9.49,-13.638) AJ22(10.265,-13.638) AJ23(11.039,-13.638) AJ25(11.814,-13.638) AJ27(12.589,-13.638) AJ28(13.363,-13.638) AJ30(14.138,-13.638) AJ31(14.913,-13.638) AJ43(20.472,-13.709) AJ44(21.211,-13.9) AK19(8.715,-14.413) AK20(9.49,-14.413) AK22(10.265,-14.413) AK23(11.039,-14.413) AK25(11.814,-14.413) AK27(12.589,-14.413) AK28(13.363,-14.413) AK30(14.138,-14.413) AK31(14.913,-14.413) AL9(3.9,-14.809) AL10(4.633,-14.573) AL12(5.395,-14.573) AL13(6.157,-14.573) AL15(6.919,-14.573) AL17(7.681,-14.573) AL21(9.8,-14.892) AL24(11.235,-14.905) AL26(12.393,-14.905) AL29(13.828,-14.892) AL33(15.947,-14.573) AL35(16.709,-14.573) AL37(17.471,-14.573) AL38(18.233,-14.573) AL40(18.995,-14.573) AL41(19.728,-14.809) AM7(3.179,-15.157) AM18(8.555,-14.997) AM32(15.073,-14.997) AM43(20.449,-15.157) AN6(2.519,-15.538) AN10(4.633,-15.97) AN12(5.37,-15.665) AN13(6.132,-15.665) AN15(6.894,-15.665) AN16(7.463,-15.708) AN18(8.555,-15.708) AN21(9.8,-15.603) AN24(11.235,-15.616) AN26(12.393,-15.616) AN29(13.828,-15.603) AN32(15.073,-15.708) AN34(16.165,-15.708) AN35(16.734,-15.665) AN37(17.496,-15.665) AN38(18.258,-15.665) AN40(18.995,-15.97) AN44(21.109,-15.538) AP9(3.9,-16.282) AP21(9.8,-16.378) AP24(11.235,-16.378) AP26(12.393,-16.378) AP29(13.828,-16.378) AP41(19.728,-16.282) AR8(3.306,-16.783) AR12(5.37,-16.757) AR13(6.132,-16.757) AR15(6.894,-16.757) AR16(7.463,-16.496) AR18(8.555,-16.47) AR32(15.073,-16.47) AR34(16.165,-16.496) AR35(16.734,-16.757) AR37(17.496,-16.757) AR38(18.258,-16.757) AR42(20.322,-16.783) AT6(2.519,-16.973) AT10(4.633,-17.087) AT16(7.463,-17.258) AT18(8.555,-17.232) AT21(9.8,-17.216) AT24(11.235,-17.14) AT26(12.393,-17.14) AT29(13.828,-17.216) AT32(15.073,-17.232) AT34(16.165,-17.258) AT40(18.995,-17.087) AT44(21.109,-16.973) AU9(3.9,-17.73) AU24(11.235,-17.902) AU26(12.393,-17.902) AU41(19.728,-17.73) AV6(2.519,-18.408) AV7(3.217,-18.078) AV11(4.735,-18.289) AV13(6.066,-18.071) AV16(7.158,-18.032) AV18(8.555,-17.994) AV21(9.8,-17.993) AV29(13.828,-17.993) AV32(15.073,-17.994) AV34(16.47,-18.032) AV37(17.562,-18.071) AV39(18.893,-18.289) AV43(20.411,-18.078) AV44(21.109,-18.408) AW9(3.99,-18.891) AW10(4.552,-18.823) AW13(5.804,-18.804) AW15(6.922,-18.766) AW18(8.319,-18.727) AW21(9.609,-18.733) AW24(11.235,-18.664) AW26(12.393,-18.664) AW29(14.019,-18.733) AW32(15.309,-18.727) AW35(16.706,-18.766) AW37(17.824,-18.804) AW40(19.076,-18.823) AW41(19.638,-18.891) AY8(3.281,-19.212) AY42(20.347,-19.212) B1(0,-0.354) B2(0.484,-0.484) B3(1.105,-0.436) B47(22.523,-0.436) B48(23.144,-0.484) B49(23.628,-0.354) BA6(2.684,-19.517) BA12(5.329,-19.449) BA14(6.574,-19.449) BA17(7.971,-19.449) BA20(9.419,-19.472) BA24(11.235,-19.426) BA26(12.393,-19.426) BA30(14.209,-19.472) BA33(15.657,-19.449) BA36(17.054,-19.449) BA38(18.299,-19.449) BA44(20.944,-19.517) BB6(2.726,-20.02) BB7(3.225,-20.314) BB9(3.79,-20.088) BB11(4.948,-20.109) BB14(6.193,-20.109) BB16(7.59,-20.109) BB20(9.228,-20.211) BB24(11.235,-20.188) BB26(12.393,-20.188) BB30(14.4,-20.211) BB34(16.038,-20.109) BB36(17.435,-20.109) BB39(18.68,-20.109) BB41(19.838,-20.088) BB43(20.403,-20.314) BB44(20.902,-20.02) BC5(2.18,-20.568) BC45(21.448,-20.568) BD1(0,-21.273) BD4(1.34,-21.297) BD46(22.288,-21.297) BD49(23.628,-21.273) BE1(0,-21.773) BE2(0.441,-21.51) BE3(0.954,-21.625) BE4(1.423,-21.801) BE5(1.849,-21.526) BE45(21.779,-21.526) BE46(22.205,-21.801) BE47(22.674,-21.625) BE48(23.187,-21.51) BE49(23.628,-21.773) BF1(0,-22.274) BF2(0.484,-22.144) BF3(1.105,-22.192) BF47(22.523,-22.192) BF48(23.144,-22.144) BF49(23.628,-22.274) BG2(0.354,-22.628) BG3(0.855,-22.628) BG4(1.355,-22.628) BG46(22.273,-22.628) BG47(22.773,-22.628) BG48(23.274,-22.628) C1(0,-0.855) C2(0.441,-1.118) C3(0.954,-1.003) C4(1.423,-0.827) C5(1.849,-1.102) C45(21.779,-1.102) C46(22.205,-0.827) C47(22.674,-1.003) C48(23.187,-1.118) C49(23.628,-0.855) D1(0,-1.355) D4(1.34,-1.331) D46(22.288,-1.331) D49(23.628,-1.355) E5(2.18,-2.06) E45(21.448,-2.06) F6(2.726,-2.608) F7(3.225,-2.314) F9(3.79,-2.539) F11(4.948,-2.519) F14(6.193,-2.519) F16(7.59,-2.519) F20(9.228,-2.417) F24(11.235,-2.44) F26(12.393,-2.44) F30(14.4,-2.417) F34(16.038,-2.519) F36(17.435,-2.519) F39(18.68,-2.519) F41(19.838,-2.539) F43(20.403,-2.314) F44(20.902,-2.608) G6(2.684,-3.111) G12(5.329,-3.179) G14(6.574,-3.179) G17(7.971,-3.179) G20(9.419,-3.156) G24(11.235,-3.202) G26(12.393,-3.202) G30(14.209,-3.156) G33(15.657,-3.179) G36(17.054,-3.179) G38(18.299,-3.179) G44(20.944,-3.111) H8(3.281,-3.416) H42(20.347,-3.416) J9(3.99,-3.737) J10(4.552,-3.805) J13(5.804,-3.824) J15(6.922,-3.862) J18(8.319,-3.9) J21(9.609,-3.895) J24(11.235,-3.964) J26(12.393,-3.964) J29(14.019,-3.895) J32(15.309,-3.9) J35(16.706,-3.862) J37(17.824,-3.824) J40(19.076,-3.805) J41(19.638,-3.737) K6(2.519,-4.22) K7(3.217,-4.55) K11(4.735,-4.339) K13(6.066,-4.557) K16(7.158,-4.595) K18(8.555,-4.633) K21(9.8,-4.634) K29(13.828,-4.634) K32(15.073,-4.633) K34(16.47,-4.595) K37(17.562,-4.557) K39(18.893,-4.339) K43(20.411,-4.55) K44(21.109,-4.22) L9(3.9,-4.898) L24(11.235,-4.726) L26(12.393,-4.726) L41(19.728,-4.898) M6(2.519,-5.655) M10(4.633,-5.541) M16(7.463,-5.37) M18(8.555,-5.395) M21(9.8,-5.412) M24(11.235,-5.488) M26(12.393,-5.488) M29(13.828,-5.412) M32(15.073,-5.395) M34(16.165,-5.37) M40(18.995,-5.541) M44(21.109,-5.655) N8(3.306,-5.845) N12(5.37,-5.871) N13(6.132,-5.871) N15(6.894,-5.871) N16(7.463,-6.132) N18(8.555,-6.157) N32(15.073,-6.157) N34(16.165,-6.132) N35(16.734,-5.871) N37(17.496,-5.871) N38(18.258,-5.871) N42(20.322,-5.845) P9(3.9,-6.346) P21(9.8,-6.25) P24(11.235,-6.25) P26(12.393,-6.25) P29(13.828,-6.25) P41(19.728,-6.346) R6(2.519,-7.09) R10(4.633,-6.658) R12(5.37,-6.963) R13(6.132,-6.963) R15(6.894,-6.963) R16(7.463,-6.919) R18(8.555,-6.919) R21(9.8,-7.025) R24(11.235,-7.012) R26(12.393,-7.012) R29(13.828,-7.025) R32(15.073,-6.919) R34(16.165,-6.919) R35(16.734,-6.963) R37(17.496,-6.963) R38(18.258,-6.963) R40(18.995,-6.658) R44(21.109,-7.09) T7(3.179,-7.471) T17(8.003,-7.631) T18(8.555,-7.631) T32(15.073,-7.631) T43(20.449,-7.471) U9(3.9,-7.819) U10(4.633,-8.055) U12(5.395,-8.055) U13(6.157,-8.055) U15(6.919,-8.055) U17(7.681,-8.055) U21(9.8,-7.736) U24(11.235,-7.723) U26(12.393,-7.723) U29(13.828,-7.736) U33(15.947,-8.055) U35(16.709,-8.055) U37(17.471,-8.055) U38(18.233,-8.055) U40(18.995,-8.055) U41(19.728,-7.819) V19(8.715,-8.215) V20(9.49,-8.215) V22(10.265,-8.215) V23(11.039,-8.215) V25(11.814,-8.215) V27(12.589,-8.215) V28(13.363,-8.215) V30(14.138,-8.215) V31(14.913,-8.215) W6(2.417,-8.728) W7(3.156,-8.919) W19(8.715,-8.99) W20(9.49,-8.99) W22(10.265,-8.99) W23(11.039,-8.99) W25(11.814,-8.99) W27(12.589,-8.99) W28(13.363,-8.99) W30(14.138,-8.99) W31(14.913,-8.99) W43(20.472,-8.919) W44(21.211,-8.728) Y9(3.895,-9.109) Y10(4.634,-9.3) Y12(5.412,-9.3) Y14(6.25,-9.3) Y15(7.025,-9.3) Y17(7.787,-9.3) Y33(15.841,-9.3) Y35(16.603,-9.3) Y36(17.378,-9.3) Y38(18.216,-9.3) Y40(18.994,-9.3) Y41(19.733,-9.109)
  round 0.279 smd: A5(1.856,0) A45(21.772,0) BC1(0,-20.772) BC49(23.628,-20.772) BG5(1.856,-22.628) BG45(21.772,-22.628) E1(0,-1.856) E49(23.628,-1.856)
  oval 0.203x0.254 smd: A6(2.415,0) A8(3.52,0) A42(20.108,0) A44(21.213,0) BD8(3.403,-21.127) BD12(5.6,-21.127) BD17(7.797,-21.127) BD21(9.994,-21.127) BD29(13.634,-21.127) BD33(15.831,-21.127) BD38(18.028,-21.127) BD42(20.225,-21.127) BE9(4.03,-21.5) BE10(4.531,-21.373) BE14(6.227,-21.5) BE15(6.728,-21.373) BE18(8.424,-21.5) BE19(8.925,-21.373) BE23(10.621,-21.5) BE24(11.122,-21.373) BE26(12.506,-21.373) BE27(13.007,-21.5) BE31(14.703,-21.373) BE32(15.204,-21.5) BE35(16.9,-21.373) BE36(17.401,-21.5) BE40(19.097,-21.373) BE41(19.598,-21.5) BG6(2.415,-22.628) BG8(3.52,-22.628) BG42(20.108,-22.628) BG44(21.213,-22.628) C9(4.03,-1.128) C10(4.531,-1.255) C14(6.227,-1.128) C15(6.728,-1.255) C18(8.424,-1.128) C19(8.925,-1.255) C23(10.621,-1.128) C24(11.122,-1.255) C26(12.506,-1.255) C27(13.007,-1.128) C31(14.703,-1.255) C32(15.204,-1.128) C35(16.9,-1.255) C36(17.401,-1.128) C40(19.097,-1.255) C41(19.598,-1.128) D8(3.403,-1.501) D12(5.6,-1.501) D17(7.797,-1.501) D21(9.994,-1.501) D29(13.634,-1.501) D33(15.831,-1.501) D38(18.028,-1.501) D42(20.225,-1.501)
  oval 0.178x0.254 smd: A13(5.742,0) A17(7.939,0) A22(10.136,0) A25(11.814,0) A28(13.492,0) A33(15.689,0) A37(17.886,0) B10(4.691,-0.711) B12(5.549,-0.498) B14(6.227,-0.627) B15(6.888,-0.711) B17(7.746,-0.498) B18(8.424,-0.627) B19(9.085,-0.711) B21(9.943,-0.498) B23(10.621,-0.627) B24(11.282,-0.711) B25(11.814,-0.508) B26(12.346,-0.711) B27(13.007,-0.627) B29(13.685,-0.498) B31(14.543,-0.711) B32(15.204,-0.627) B33(15.882,-0.498) B35(16.74,-0.711) B36(17.401,-0.627) B38(18.079,-0.498) B40(18.937,-0.711) BE11(5.054,-21.432) BE12(5.519,-21.627) BE16(7.251,-21.432) BE17(7.716,-21.627) BE20(9.448,-21.432) BE21(9.913,-21.627) BE25(11.814,-21.612) BE29(13.715,-21.627) BE30(14.18,-21.432) BE33(15.912,-21.627) BE34(16.377,-21.432) BE38(18.109,-21.627) BE39(18.575,-21.432) BF10(4.691,-21.917) BF12(5.549,-22.129) BF14(6.227,-22) BF15(6.888,-21.917) BF17(7.746,-22.129) BF18(8.424,-22) BF19(9.085,-21.917) BF21(9.943,-22.129) BF23(10.621,-22) BF24(11.282,-21.917) BF25(11.814,-22.12) BF26(12.346,-21.917) BF27(13.007,-22) BF29(13.685,-22.129) BF31(14.543,-21.917) BF32(15.204,-22) BF33(15.882,-22.129) BF35(16.74,-21.917) BF36(17.401,-22) BF38(18.079,-22.129) BF40(18.937,-21.917) BG13(5.742,-22.628) BG17(7.939,-22.628) BG22(10.136,-22.628) BG25(11.814,-22.628) BG28(13.492,-22.628) BG33(15.689,-22.628) BG37(17.886,-22.628) C11(5.054,-1.196) C12(5.519,-1.001) C16(7.251,-1.196) C17(7.716,-1.001) C20(9.448,-1.196) C21(9.913,-1.001) C25(11.814,-1.016) C29(13.715,-1.001) C30(14.18,-1.196) C33(15.912,-1.001) C34(16.377,-1.196) C38(18.109,-1.001) C39(18.575,-1.196)
  oval 0.254x0.178 smd: AA1(0,-9.636) AA49(23.628,-9.636) AB2(0.627,-10.121) AB48(23.001,-10.121) AC2(0.711,-10.782) AC48(22.917,-10.782) AD1(0,-11.314) AD2(0.508,-11.314) AD3(1.016,-11.314) AD47(22.612,-11.314) AD48(23.12,-11.314) AD49(23.628,-11.314) AE2(0.711,-11.846) AE48(22.917,-11.846) AF2(0.627,-12.507) AF48(23.001,-12.507) AG1(0,-12.992) AG49(23.628,-12.992) AH2(0.498,-13.185) AH3(1.001,-13.215) AH47(22.627,-13.215) AH48(23.13,-13.185) AJ3(1.196,-13.68) AJ47(22.432,-13.68) AK2(0.711,-14.043) AK48(22.917,-14.043) AL2(0.627,-14.704) AL48(23.001,-14.704) AM1(0,-15.189) AM2(0.498,-15.382) AM3(1.001,-15.412) AM47(22.627,-15.412) AM48(23.13,-15.382) AM49(23.628,-15.189) AN3(1.196,-15.877) AN47(22.432,-15.877) AP2(0.711,-16.24) AP48(22.917,-16.24) P2(0.711,-6.388) P48(22.917,-6.388) R3(1.196,-6.751) R47(22.432,-6.751) T1(0,-7.439) T2(0.498,-7.246) T3(1.001,-7.216) T47(22.627,-7.216) T48(23.13,-7.246) T49(23.628,-7.439) U2(0.627,-7.924) U48(23.001,-7.924) V2(0.711,-8.585) V48(22.917,-8.585) W3(1.196,-8.948) W47(22.432,-8.948) Y2(0.498,-9.443) Y3(1.001,-9.413) Y47(22.627,-9.413) Y48(23.13,-9.443)
  round 0.254 smd: AA5(1.958,-9.712) AA45(21.67,-9.712) AC4(1.754,-10.735) AC46(21.874,-10.735) AE4(1.754,-11.893) AE46(21.874,-11.893) AG5(1.958,-12.915) AG45(21.67,-12.915) AJ4(1.716,-13.588) AJ46(21.912,-13.588) AK4(1.754,-14.09) AK46(21.874,-14.09) AM5(1.958,-15.112) AM45(21.67,-15.112) AN4(1.716,-15.785) AN46(21.912,-15.785) AP4(1.754,-16.287) AP46(21.874,-16.287) AT5(1.958,-17.31) AT45(21.67,-17.31) AV4(1.716,-17.982) AV46(21.912,-17.982) AW4(1.754,-18.484) AW46(21.874,-18.484) B6(2.417,-0.503) B44(21.211,-0.503) BA2(0.498,-19.84) BA3(1.005,-19.908) BA4(1.51,-19.782) BA5(1.958,-19.507) BA45(21.67,-19.507) BA46(22.118,-19.782) BA47(22.623,-19.908) BA48(23.13,-19.84) BB3(0.496,-20.629) BB4(0.989,-20.44) BB46(22.64,-20.44) BB47(23.132,-20.629) BC8(3.621,-20.67) BC10(4.644,-20.874) BC13(5.818,-20.67) BC15(6.841,-20.874) BC17(8.015,-20.67) BC19(9.038,-20.874) BC22(10.213,-20.67) BC24(11.235,-20.874) BC26(12.393,-20.874) BC28(13.416,-20.67) BC31(14.59,-20.874) BC33(15.613,-20.67) BC35(16.787,-20.874) BC37(17.81,-20.67) BC40(18.984,-20.874) BC42(20.007,-20.67) BD7(2.9,-21.186) BD11(5.146,-20.912) BD16(7.343,-20.912) BD20(9.54,-20.912) BD30(14.088,-20.912) BD34(16.285,-20.912) BD39(18.483,-20.912) BD43(20.728,-21.186) BE6(2.723,-21.671) BE44(20.905,-21.671) BF6(2.417,-22.125) BF44(21.211,-22.125) C6(2.723,-0.957) C44(20.905,-0.957) D7(2.9,-1.441) D11(5.146,-1.716) D16(7.343,-1.716) D20(9.54,-1.716) D30(14.088,-1.716) D34(16.285,-1.716) D39(18.483,-1.716) D43(20.728,-1.441) E8(3.621,-1.958) E10(4.644,-1.754) E13(5.818,-1.958) E15(6.841,-1.754) E17(8.015,-1.958) E19(9.038,-1.754) E22(10.213,-1.958) E24(11.235,-1.754) E26(12.393,-1.754) E28(13.416,-1.958) E31(14.59,-1.754) E33(15.613,-1.958) E35(16.787,-1.754) E37(17.81,-1.958) E40(18.984,-1.754) E42(20.007,-1.958) F3(0.496,-1.999) F4(0.989,-2.187) F46(22.64,-2.187) F47(23.132,-1.999) G2(0.498,-2.788) G3(1.005,-2.72) G4(1.51,-2.846) G5(1.958,-3.121) G45(21.67,-3.121) G46(22.118,-2.846) G47(22.623,-2.72) G48(23.13,-2.788) J4(1.754,-4.144) J46(21.874,-4.144) K4(1.716,-4.645) K46(21.912,-4.645) M5(1.958,-5.318) M45(21.67,-5.318) P4(1.754,-6.341) P46(21.874,-6.341) R4(1.716,-6.843) R46(21.912,-6.843) T5(1.958,-7.515) T45(21.67,-7.515) V4(1.754,-8.538) V46(21.874,-8.538) W4(1.716,-9.04) W46(21.912,-9.04)
  oval 0.254x0.203 smd: AB3(1.128,-10.121) AB47(22.5,-10.121) AC3(1.255,-10.622) AC47(22.373,-10.622) AE3(1.255,-12.006) AE47(22.373,-12.006) AF3(1.128,-12.507) AF47(22.5,-12.507) AH4(1.501,-13.134) AH46(22.127,-13.134) AK3(1.255,-14.197) AK47(22.373,-14.197) AL3(1.128,-14.704) AL47(22.5,-14.704) AM4(1.501,-15.331) AM46(22.127,-15.331) AP3(1.255,-16.394) AP47(22.373,-16.394) AR3(1.128,-16.901) AR47(22.5,-16.901) AT1(0,-17.411) AT49(23.628,-17.411) AU4(1.501,-17.528) AU46(22.127,-17.528) AW3(1.255,-18.591) AW47(22.373,-18.591) AY3(1.128,-19.098) AY47(22.5,-19.098) BA1(0,-19.634) BA49(23.628,-19.634) G1(0,-2.994) G49(23.628,-2.994) H3(1.128,-3.53) H47(22.5,-3.53) J3(1.255,-4.037) J47(22.373,-4.037) L4(1.501,-5.1) L46(22.127,-5.1) M1(0,-5.217) M49(23.628,-5.217) N3(1.128,-5.727) N47(22.5,-5.727) P3(1.255,-6.234) P47(22.373,-6.234) T4(1.501,-7.297) T46(22.127,-7.297) U3(1.128,-7.924) U47(22.5,-7.924) V3(1.255,-8.431) V47(22.373,-8.431) Y4(1.501,-9.494) Y46(22.127,-9.494)
  oval 0.305x0.152 smd: AR2(0.627,-16.901) AR48(23.001,-16.901) AU2(0.498,-17.579) AU3(1.001,-17.609) AU47(22.627,-17.609) AU48(23.13,-17.579) AV3(1.196,-18.074) AV47(22.432,-18.074) AW2(0.711,-18.437) AW48(22.917,-18.437) AY2(0.627,-19.098) AY48(23.001,-19.098) H2(0.627,-3.53) H48(23.001,-3.53) J2(0.711,-4.19) J48(22.917,-4.19) K3(1.196,-4.553) K47(22.432,-4.553) L2(0.498,-5.049) L3(1.001,-5.019) L47(22.627,-5.019) L48(23.13,-5.049) N2(0.627,-5.727) N48(23.001,-5.727)
  oval 0.152x0.305 smd: B8(3.352,-0.498) B9(4.03,-0.627) B41(19.598,-0.627) B42(20.276,-0.498) BE8(3.322,-21.627) BE42(20.307,-21.627) BF8(3.352,-22.129) BF9(4.03,-22) BF41(19.598,-22) BF42(20.276,-22.129) C8(3.322,-1.001) C42(20.307,-1.001)

# Allegro board Alienware Area-51M LA-G881P.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TBTA_ROSC: length 2.1
  TOP w0.127: v2(42.27,47.89) 42.39,48 v1(42.76,48) 43.15,48 43.34,47.82 RT75.1
  BOTTOM w0.076: v2(42.27,47.89) 42.27,47.87 41.97,47.57 UT4.G2
TBTB_I2C_INT: length 3.9
  TOP w0.102: v2(21.39,49.12) 21.37,49.1 20.91,49.1 v1(20.87,49.14) 20.65,49.36 20.48,49.36 RT33.2
  BOTTOM w0.076: v2(21.39,49.12) 21.72,48.79 21.72,48.36 21.61,48.26 21.61,48.21 21.54,48.14 21.54,47.72 21.33,47.51 UT1.E2
THERM#: length 3.1
  BOTTOM w0.112: v1(112.5,9.6) R410.1 113.64,9.6 114.02,9.23 U2408.4
THERMDA: length 0.5
  BOTTOM w0.076: UT1.AB23 UT1.AC23
THERMTRIP#_R: length 17.9
  BOTTOM w0.102: 129.82,75.02 129.84,75 129.86,75 131.04,73.83 132.8,73.83 133.15,73.49 UC1.D11
  BOTTOM w0.112: R395.2 122.33,83.28 v1(122.84,82.76) 126.52,82.76 128.79,80.49 128.79,76.05 129.82,75.02
TOBII_INT#: length 87.2
  TOP w0.112: RE651.1 352.26,34.88 v2(351.76,35.39) ; v2(339.69,39.71) v1(340.32,39.07)
  IN3 w0.104: v2(297.92,38.43) 297.91,38.43 297.91,38.42 296.85,37.36 296.85,36.32 298.09,35.08 299.35,35.08 302.56,31.87 302.56,31.37 303.9,30.04 306.15,30.04 308.26,27.93 309.22,27.93 314.48,22.67 315.87,22.67 316.77,21.76 327.2,21.76 328.29,22.85 330.39,22.85 332.83,25.3 332.83,28.79 335.63,31.58 335.63,38.7 336.27,39.34 338.75,39.34 339.11,39.71 v2(339.69,39.71)
  IN4 w0.084: v2(351.76,35.39) 351.76,36.03 350.61,37.17 349.57,37.17 347.03,39.71 v2(339.69,39.71)
  BOTTOM w0.112: v2(297.92,38.43) 297.91,38.43 297.91,38.42 297.6,38.11 297.02,38.11 296.19,38.94 296.19,39.65 296.6,40.05 RE300.1 295.75,40.28 295.47,40 JTOBII.1
TOBII_PWR_EN#: length 90.3
  TOP w0.112: UE5.41 296.34,8.96 296.79,8.51 296.79,7.75 297.68,6.86 298.78,6.86 302.69,2.94 310.23,2.94 311.5,4.21 313.78,4.21 v1(315.53,5.96) 317.78,8.21 317.78,16 319.59,17.8 319.59,19.12 319.01,19.7 316.37,19.7 316.11,19.95 316.11,22.39 v2(315.11,23.39)
  IN3 w0.104: v2(315.11,23.39) 314.41,23.39 309.27,28.53 308.76,28.53 306.79,30.51 306.79,32.6 306.37,33.02 304.42,33.02 304.2,33.24 304.18,33.26 302.78,33.26 299.03,37.01 299.03,42.27 296.81,44.49 296.81,45.92 297.52,46.63 300.95,46.63 302.1,47.78 v2(302.1,47.98)
  BOTTOM w0.112: v2(302.1,47.98) 302.14,48.02 RE652.2 303.11,47.19 CE79.1 303.06,46.68 303.36,46.38 303.36,45.3 303.08,45.02 UE12.4
TON_1.2V: length 1.6
  TOP w0.254: PR206.2 219.19,114.02 218.82,114.92 PU201.9
TP_CLK: length 240.8
  TOP w0.112: v2(99.78,11.14) 99.69,11.23 99.69,11.36 v1(100.9,12.56) 101.33,12.99 101.33,13.52 RE654.1 ; v2(300.09,21.07) 300.3,21.29 302.17,21.29 303.22,20.23 307.12,20.23 307.16,20.28 UE5.87 308.13,20.28 308.22,20.18 308.92,20.18 309.23,20.5 RE100.2
  IN1 w0.084: v2(300.09,21.07) 300.09,21.15 299.92,21.31 299.33,21.31 297.97,22.67 292.34,22.67 290.41,24.6 287.82,24.6 285.92,22.69 275.87,22.69 272.04,26.52 269.95,26.52 269.52,26.95 260.77,26.95 260.65,27.07 255.88,27.07 251.11,22.29 246.83,22.29 236.28,11.73 230.89,11.73 229.19,13.43 229.19,19.1 227.12,21.17 220.46,21.17 219.77,20.49 191.25,20.49 184.54,13.78 168.75,13.78 161.66,6.7 130.72,6.7 130.15,7.26 122.26,7.26 121.56,7.96 120.43,7.96 119.67,7.2 111.92,7.2 108.49,10.63 106.05,10.63 105.06,11.62 99.81,11.62 99.66,11.48 99.66,11.25 v2(99.78,11.14)
TP_CLK_R: length 4.6
  TOP w0.112: RE654.2 101.49,14.91 101.49,17.02 v2(101.53,17.07)
  BOTTOM w0.112: JTP.5 100.95,15.85 100.95,15.85 100.95,16.36 101.53,16.95 v2(101.53,17.07)
TP_DATA: length 241.2
  TOP w0.112: RE101.2 309.32,21.28 308.71,20.68 UE5.88 307.12,20.72 303.43,20.72 302.37,21.78 v2(300.04,21.78) ; RE655.1 100.83,13.2 99.2,11.56 v2(99.2,11.14)
  IN1 w0.084: v2(300.04,21.78) 299.52,21.78 298.16,23.14 292.53,23.14 290.6,25.06 287.63,25.06 285.73,23.16 276.06,23.16 272.24,26.98 270.14,26.98 269.71,27.41 260.96,27.41 260.85,27.53 255.69,27.53 250.92,22.76 246.64,22.76 236.08,12.2 231.08,12.2 229.66,13.62 229.66,19.29 227.31,21.63 220.26,21.63 219.58,20.95 191.05,20.95 184.35,14.25 168.56,14.25 161.47,7.16 130.91,7.16 130.34,7.73 122.45,7.73 121.75,8.43 120.23,8.43 119.47,7.67 112.11,7.67 108.68,11.1 106.24,11.1 105.25,12.09 99.62,12.09 99.2,11.67 v2(99.2,11.14)
TP_DATA_R: length 4.6
  TOP w0.112: v2(100.95,17.07) 101,17.02 v1(101,15.71) 101,14.92 RE655.2
  BOTTOM w0.112: JTP.4 100.45,15.85 100.45,15.85 100.45,16.57 v2(100.95,17.07)
TP_DIMM1_CHA_S2#: length 2.1
  TOP w0.127: TD1.1 254.55,69.11 v2(255.01,69.57)
  BOTTOM w0.127: JDIMM1.162 254.46,69.03 v2(255.01,69.57)
TP_DIMM1_CHA_S3#: length 5.3
  TOP w0.127: TD2.1 249.86,69.31 v2(249.85,69.32)
  BOTTOM w0.127: v2(249.85,69.32) 249.85,69.62 249.57,69.9 246.75,69.9 246.63,69.78 245.6,69.78 JDIMM1.165
TP_DIMM2_CHA_S2#: length 2.7
  TOP w0.127: TD3.1 238.05,69.11 v2(238.05,69.26)
  BOTTOM w0.112: JDIMM3.162 238.29,69.03 v2(238.05,69.26)
TP_DIMM2_CHA_S3#: length 3.3
  TOP w0.127: TD4.1 228.99,70.11 v2(229.14,70.11)
  BOTTOM w0.127: JDIMM3.165 230.74,69.78 230.53,69.57 229.66,69.57 229.26,69.97 229.26,69.98 v2(229.14,70.11)
TP_DIMM3_CHB_S2#: length 5.1
  TOP w0.127: v2(222.96,70.08) 223.13,69.92 223.13,69.91 223.37,69.66 223.38,69.66 TD5.1
  BOTTOM w0.112: v2(222.96,70.08) 224.02,69.03 JDIMM2.162
TP_DIMM3_CHB_S3#: length 4.8
  TOP w0.127: TD6.1 222.21,69.74 222.21,69.92 v2(222.38,70.08)
  BOTTOM w0.127: JDIMM2.165 219.73,69.78 220.01,69.49 221,69.49 221.01,69.49 222.05,69.49 222.38,69.82 v2(222.38,70.08)
TP_DIMM4_CHB_S2#: length 2.9
  TOP w0.127: v2(214.81,68.46) 214.93,68.33 TD7.1
  BOTTOM w0.127: v2(214.81,68.46) 214.81,68.58 214.36,69.03 JDIMM4.162
TP_DIMM4_CHB_S3#: length 5.3
  TOP w0.127: v2(201.62,71.88) 201.57,71.93 TD8.1
  BOTTOM w0.127: JDIMM4.165 204.7,69.78 202.56,69.78 201.62,70.71 v2(201.62,71.88)
TP_EN: length 257.9
  TOP w0.112: UE5.81 306.25,17.88 306.22,17.85 304.57,17.85 v2(304.57,17.85) ; QT2.2 v1(84.99,8.71) 85.67,8.71 85.88,8.91 85.88,10.55 v2(85.85,10.57)
  IN3 w0.104: v2(117.71,8.56) 118.25,9.1 120.03,9.1 120.69,8.44 124.9,8.44 125.18,8.16 134.22,8.16 134.47,8.41 140.08,8.41 140.59,7.9 167.08,7.9 167.76,7.21 185.38,7.21 190.18,12.02 196.03,12.02 197.37,10.68 223.92,10.68 224.71,9.89 232.4,9.89 233.72,11.2 239.82,11.2 243.14,14.52 246.3,14.52 246.63,14.19 248.98,14.19 249.08,14.29 250.33,14.29 250.63,13.99 251.28,13.99 252.06,14.77 260.75,14.77 268.13,22.15 282.78,22.15 286.43,18.51 290.33,18.51 291.13,17.7 295.84,17.7 296,17.86 304.56,17.86 v2(304.57,17.85)
  BOTTOM w0.112: UT5.3 88.88,19.09 CT114.1 86.45,19.4 86.07,19.02 86.07,17.74 85.68,17.35 85.68,10.76 85.85,10.59 v2(85.85,10.57) 86.33,10.1 86.33,7.19 86.77,6.74 93.61,6.74 96.61,9.74 109.25,9.74 112.02,12.51 115.29,12.51 117.71,10.09 v2(117.71,8.56)
TP_INT#: length 339.3
  TOP w0.089: v2(286.03,67.02) 285.97,67.02 285.53,66.57 v1(285.53,66.25) 285.53,66.13 285.7,65.95 285.7,63.06 285.62,62.98 UH1.BE15
  TOP w0.112: UE5.38 295.14,8.53 v2(295.62,8.05)
  IN1 w0.084: v2(122.86,2.17) 126.15,2.17 127.19,3.21 172.14,3.21 173.25,2.1 189.59,2.1 190.25,1.45 193.95,1.45 195.93,3.42 218.45,3.42 219.26,2.61 221.92,2.61 223.45,4.14 237.63,4.14 242.15,8.66 242.15,11.05 246.69,15.59 255.63,15.59 259.33,19.29 268.98,19.29 269.79,18.48 274.1,18.48 274.95,17.64 274.95,13.9 276.43,12.42 276.43,11.83 v2(276.5,11.76) 277.51,11.76 278.94,10.32 288.66,10.32 290.68,8.3 292.28,8.3 293.55,7.04 294.91,7.04 295.62,7.75 v2(295.62,8.05)
  IN3 w0.104: v2(259.08,72.35) 260.49,70.94 262.03,70.94 262.24,70.74 269.66,70.74 270.32,70.07 276.24,70.07 276.69,69.62 279.5,69.62 279.8,69.92 281.94,69.92 282.5,69.36 283.49,69.36 284.1,68.75 284.4,68.75 286.03,67.13 v2(286.03,67.02)
  BOTTOM w0.112: RE661.2 104.57,17.3 103.99,16.72 103.41,16.72 102.95,16.27 JTP.9 102.95,14.02 103.63,13.34 106.72,13.34 108.26,14.89 108.26,15.57 108.72,16.03 109.93,16.03 112.91,13.05 115.52,13.05 118.91,9.66 123.48,9.66 124.56,8.58 124.56,3.1 123.68,2.21 122.9,2.21 v2(122.86,2.17) ; v2(276.5,11.76) 276.5,12.53 275.29,15.45 275.29,19.13 272.35,22.08 267.63,22.08 265.53,24.18 265.53,28.11 260.31,33.33 260.31,35.47 257.84,37.94 257.84,49.37 258.45,49.99 258.45,51.67 256.45,53.68 256.45,65.75 257.95,67.26 257.95,70.6 259.08,71.72 v2(259.08,72.35)
TP_LED_B#_DRV#: length 286.3
  TOP w0.112: UE3.9 153.65,174.47 153.42,174.25 v2(152.49,174.25)
  IN1 w0.084: 129.82,83.45 129.81,83.45 129.37,83.01 116.05,83.01 111.49,78.45 111.49,75.45 108.3,72.25 108.3,66.34 100.04,58.08 98.53,58.08 97.96,57.51 97.96,54.14 89.63,45.81 86.26,45.81 84.84,44.39 84.84,43.44 83.9,42.5 72.42,42.5 66.25,36.33 65.51,36.33 64.23,35.04 60.3,35.04 59.24,33.98 59.24,31.2 62.01,28.44 62.01,27.03 62.62,26.42 63.55,26.42 64.1,25.86 69.73,25.86 71.01,24.58 77.51,24.58 79.38,22.71 80.26,22.71 81.19,21.79 83.47,21.79 83.9,22.21 87.6,22.21 88,22.61 93.01,22.61 95.64,19.98 104.42,19.98 v2(105.15,20.71) ; 134.74,84.99 136.13,86.38 136.13,91.1 140,94.97 140,100.22 142.87,103.09 142.87,106.51 144.69,108.33 147.92,108.33 150.15,110.56 150.15,116.34 v2(149.82,116.67)
  IN1 w0.102: 129.82,83.45 131.33,83.45 132.7,84.82 134.58,84.82 134.74,84.99
  IN4 w0.084: v2(149.82,116.67) 153.61,116.67 155.62,118.69 156.57,118.69 164.36,126.48 164.36,144.36 148.04,160.68 148.04,167.47 151.09,170.52 151.09,173.86 151.75,174.52 152.22,174.52 v2(152.49,174.25)
  BOTTOM w0.112: JTP.14 105.45,15.57 105.74,15.85 108,15.85 108.3,16.15 108.3,16.83 105.15,19.98 v2(105.15,20.71)
TP_LED_EN: length 243.8
  TOP w0.112: v2(82.9,7.17) 83.06,7.01 85.9,7.01 87.12,8.23 v1(87.12,8.91) 87.12,11.53 87.12,12.43 87.21,12.93 87.21,14.04 87.76,14.58 87.76,15.81 88.96,17.01 Q2410.2 ; UE5.25 289.89,14.28 289.2,13.59 v2(288.89,13.29)
  IN1 w0.084: v2(82.9,7.17) 82.9,7.14 83.21,6.83 93.49,6.83 95.69,9.04 108.17,9.04 111.46,5.74 118.79,5.74 121.33,3.2 125.76,3.2 126.61,4.05 173.97,4.05 175.04,2.98 189.96,2.98 190.61,2.33 193.58,2.33 195.6,4.35 218.72,4.35 219.61,3.45 221.57,3.45 223.1,4.98 237.12,4.98 241.3,9.16 241.3,11.4 246.35,16.44 255.28,16.44 258.98,20.14 269.33,20.14 270.14,19.32 274.45,19.32 275.79,17.99 275.79,14.67 278.54,11.91 287.59,11.91 288.69,13.02 288.69,13.09 v2(288.89,13.29)
TP_LED_G#_DRV#: length 285.5
  TOP w0.112: UE3.8 152.53,175.51 152.42,175.4 152.42,175.14 v2(152.7,174.86)
  IN1 w0.084: v2(104.57,20.79) 104.57,20.57 104.33,20.33 95.59,20.33 93.1,22.82 89.44,22.82 88.74,23.52 87.27,23.52 86.77,23.02 84.41,23.02 83.39,22 81.27,22 80.35,22.92 79.46,22.92 77.53,24.86 71.13,24.86 69.85,26.13 64.22,26.13 63.72,26.63 62.71,26.63 62.22,27.12 62.22,28.52 59.45,31.29 59.45,33.89 60.39,34.83 64.31,34.83 65.6,36.12 66.33,36.12 72.51,42.29 83.99,42.29 85.05,43.35 85.05,44.3 86.32,45.57 89.69,45.57 98.18,54.06 98.18,57.42 98.62,57.87 100.13,57.87 108.51,66.25 108.51,72.16 111.71,75.36 111.71,78.36 116.14,82.8 129.56,82.8 129.82,83.05 ; v2(149.82,117.26) 150.36,116.72 150.36,110.47 148.01,108.12 144.78,108.12 143.08,106.43 143.08,103 140.21,100.14 140.21,94.88 136.34,91.01 136.34,86.29 135.04,84.99
  IN1 w0.102: 129.82,83.05 129.94,83.17 131.33,83.17 132.78,84.62 134.67,84.62 135.04,84.99
  IN4 w0.084: v2(152.7,174.86) 152.57,174.73 151.66,174.73 150.88,173.95 150.88,170.61 147.83,167.56 147.83,160.59 164.15,144.27 164.15,126.57 156.48,118.9 155.53,118.9 153.9,117.26 v2(149.82,117.26)
  BOTTOM w0.112: v2(104.57,20.79) 104.57,20.22 107.27,17.52 107.27,16.43 106.92,16.09 105.64,16.09 105.32,15.77 105.06,15.77 104.95,15.66 JTP.13
TP_LED_R#_DRV#: length 287.5
  TOP w0.112: UE3.6 151.9,176.51 v2(151.82,176.43) ; v2(103.99,20.72) v3(103.41,20.72)
  IN1 w0.084: 135.34,84.99 136.55,86.2 136.55,90.93 140.42,94.8 140.42,100.05 143.29,102.92 143.29,106.34 144.87,107.91 148.1,107.91 150.57,110.39 150.57,117.4 v2(150.32,117.66) ; v2(103.99,20.72) 103.8,20.54 95.84,20.54 93.35,23.03 90.52,23.03 88.42,25.13 84.33,25.13 83.86,24.66 83.86,22.77 83.3,22.21 81.36,22.21 80.44,23.13 79.55,23.13 77.62,25.07 71.21,25.07 69.93,26.35 64.3,26.35 63.81,26.84 62.8,26.84 62.43,27.21 62.43,28.61 59.67,31.37 59.67,33.81 60.48,34.62 64.4,34.62 65.69,35.91 66.42,35.91 72.59,42.08 84.08,42.08 85.26,43.26 85.26,44.21 86.41,45.36 89.78,45.36 98.39,53.97 98.39,57.34 98.71,57.66 100.22,57.66 108.72,66.16 108.72,72.07 111.92,75.27 111.92,78.28 115.52,81.87 129.82,81.87
  IN1 w0.102: 129.82,81.87 130.33,81.87 132.87,84.41 134.77,84.41 135.34,84.99
  IN4 w0.084: v2(150.32,117.66) 154,117.66 155.45,119.11 156.39,119.11 163.94,126.65 163.94,144.18 147.62,160.5 147.62,167.65 150.67,170.7 150.67,174.03 151.84,175.2 151.84,176.42 v2(151.82,176.43)
  BOTTOM w0.112: v2(103.99,20.72) 103.99,20.46 107.03,17.42 107.03,16.53 106.83,16.33 105.54,16.33 105.22,16.01 104.87,16.01 104.45,15.59 JTP.12
TRIP_+1VALWP: length 1.5
  TOP w0.254: PU101.2 261.38,9.84 261.23,9.98 PR103.2
TRONB_LED_B_DRV#: length 166.3
  TOP w0.112: UE3.21 158.86,177.51 159.19,177.18 v2(159.81,177.18) v3(160.56,177.18)
  IN3 w0.104: v2(161.91,148.63) 163.11,148.63 164.6,147.14 172.56,147.14 173.11,146.59 173.11,145.15 173.87,144.38 175.93,144.38 177.36,145.81 178.92,145.81 179.37,146.26 180.74,146.26 181.12,145.88 183.53,145.88 183.99,145.42 192.14,145.42 198.25,139.31 199.78,139.31 202.11,136.97 202.11,136.1 202.52,135.7 203,135.7 204.86,133.83 204.86,130.12 201.71,126.96 201.71,116.86 200.98,116.13 200.98,112.07 200.01,111.1 200.01,109.58 204.08,105.5 213.56,105.5 213.92,105.15 237.52,105.15 v2(238.8,103.87)
  IN4 w0.084: v2(161.91,148.63) 161.3,149.24 161.3,154.07 156.42,158.95 156.42,171.96 156.01,172.38 156.01,176.09 157.29,177.38 159.62,177.38 v2(159.81,177.18)
  BOTTOM w0.112: v2(238.8,103.87) JTRON.19 238.8,100.15 239.13,99.82 243.55,99.82 243.8,100.07 JTRON.9
TRONB_LED_G_DRV#: length 164.5
  TOP w0.112: v3(159.29,175.98) 159.29,176.32 v2(158.71,176.9) 158.6,177.01 UE3.20
  IN3 w0.104: v2(239.8,103.87) 238.29,105.38 214.01,105.38 213.65,105.74 204.18,105.74 200.24,109.68 200.24,111.01 201.21,111.98 201.21,116.03 201.94,116.76 201.94,126.87 205.1,130.02 205.1,134.87 202.7,137.27 202.13,137.27 199.87,139.54 198.35,139.54 192.23,145.65 184.09,145.65 183.63,146.12 181.21,146.12 180.83,146.49 179.27,146.49 178.82,146.04 177.73,146.04 176.06,147.7 174.04,147.7 173.71,147.37 164.95,147.37 163.11,149.21 v2(161.91,149.21)
  IN4 w0.084: v2(161.91,149.21) 161.51,149.61 161.51,154.16 156.63,159.04 156.63,172.05 156.22,172.47 156.22,176.01 157.36,177.15 158.46,177.15 v2(158.71,176.9)
  BOTTOM w0.112: JTRON.17 v2(239.8,103.87) 240.41,104.48 244.12,104.48 244.8,103.8 JTRON.7
TRONB_LED_R_DRV#: length 164
  TOP w0.112: v3(162.59,149.44) 162.27,149.44 v2(161.91,149.8) ; UE3.19 158.31,176.51 158.57,176.25 158.57,175.2 v2(158.27,174.9)
  IN3 w0.104: v2(240.8,103.87) 239.06,105.61 214.11,105.61 213.75,105.97 204.27,105.97 200.47,109.77 200.47,110.91 201.44,111.88 201.44,115.94 202.17,116.66 202.17,126.77 205.33,129.93 205.33,134.97 202.79,137.5 202.23,137.5 199.97,139.77 198.44,139.77 192.33,145.88 184.19,145.88 183.72,146.35 181.31,146.35 180.93,146.72 179.18,146.72 178.72,146.27 177.82,146.27 176.16,147.93 173.94,147.93 173.62,147.61 165.3,147.61 163.11,149.8 v2(161.91,149.8)
  IN4 w0.084: v2(240.8,103.87) 241.28,104.35 245.31,104.35 v2(245.8,103.87) ; v2(158.27,174.9) 157.87,175.3 157.02,175.3 156.43,174.71 156.43,172.55 156.85,172.14 156.85,159.13 161.73,154.25 161.73,149.98 v2(161.91,149.8)
  BOTTOM w0.112: JTRON.15 v2(240.8,103.87) ; JTRON.5 v2(245.8,103.87)
TRONT_LED_B_DRV#: length 159.8
  TOP w0.112: v2(157.63,174.9) 157.46,175.07 157.46,175.41 157.56,175.51 UE3.17 ; v2(162.68,152.03) 163.17,152.52 v3(163.17,152.55)
  IN3 w0.104: v2(162.68,152.03) 165.04,149.68 171.89,149.68 172.94,148.63 176.44,148.63 178.11,146.96 178.44,146.96 178.89,147.42 181.22,147.42 181.6,147.04 184.01,147.04 184.47,146.58 192.62,146.58 198.1,141.09 199.79,141.09 202.68,138.2 203.08,138.2 206.02,135.26 206.02,129.64 205.67,129.29 202.86,126.48 202.86,116.38 202.13,115.65 202.13,111.59 201.16,110.62 201.16,110.06 204.56,106.66 214.04,106.66 214.39,106.3 241.43,106.3 v2(243.8,108.67)
  IN4 w0.084: v2(162.68,152.03) 162.68,154.25 157.53,159.41 157.53,172.36 157.98,172.81 157.98,174.56 v2(157.63,174.9)
  BOTTOM w0.112: v2(243.8,108.67) JTRON.10 243.8,105.35 243.63,105.18 239.11,105.18 238.8,105.49 JTRON.20
TRONT_LED_G_DRV#: length 160.1
  TOP w0.112: v3(158.21,173.57) 157.89,173.89 v2(157.58,173.89) 157.45,173.89 157.15,174.19 UE3.16
  IN3 w0.104: v2(244.8,108.67) 242.2,106.07 214.3,106.07 213.94,106.43 204.47,106.43 200.93,109.96 200.93,110.72 201.9,111.69 201.9,115.74 202.63,116.47 202.63,126.58 205.79,129.74 205.79,135.16 202.98,137.97 202.59,137.97 199.69,140.86 198,140.86 192.52,146.34 184.38,146.34 183.91,146.81 181.5,146.81 181.12,147.19 178.99,147.19 178.53,146.73 178.01,146.73 176.35,148.4 172.84,148.4 171.79,149.45 164.68,149.45 v2(162.68,151.45)
  IN4 w0.084: v2(157.58,173.89) 157.58,172.75 157.32,172.49 157.32,159.32 162.2,154.44 162.2,151.94 v2(162.68,151.45)
  BOTTOM w0.112: JTRON.18 239.8,108.08 241.02,109.31 244.16,109.31 v2(244.8,108.67) JTRON.8
TRONT_LED_R_DRV#: length 162.6
  TOP w0.112: UE3.15 156.65,174.05 v2(156.87,173.82) ; v2(162.68,150.86) 162.71,150.84 v3(163.54,150.84)
  IN3 w0.104: v2(162.68,150.86) 162.68,150.6 165.45,147.84 173.52,147.84 173.85,148.16 176.25,148.16 177.92,146.5 178.63,146.5 179.08,146.96 181.03,146.96 181.4,146.58 183.82,146.58 184.28,146.11 192.42,146.11 198.54,140 200.06,140 202.33,137.74 202.89,137.74 205.56,135.07 205.56,129.83 202.4,126.67 202.4,116.57 201.67,115.84 201.67,111.78 200.7,110.81 200.7,109.87 204.37,106.2 213.85,106.2 214.2,105.84 242.97,105.84 v2(245.8,108.67)
  IN4 w0.084: v2(240.97,108.67) 241.61,108.04 245.16,108.04 v2(245.8,108.67) ; v2(162.68,150.86) 161.98,151.56 161.98,154.35 157.1,159.23 157.1,172.57 157.37,172.84 157.37,173.33 v2(156.87,173.82)
  BOTTOM w0.112: v2(240.97,108.67) 240.8,108.5 JTRON.16 ; JTRON.6 v2(245.8,108.67)
TS_EN: length 256.7
  TOP w0.112: UE5.54 301.54,9.04 301.83,8.74 301.83,8.35 v2(302.23,7.96)
  IN2 w0.104: v2(187.94,104.29) 187.69,104.04 186.8,104.04 186.53,104.31 186.53,106.17 186.03,106.66 186.03,109.06 181.63,113.47 181.63,114.84 169.87,126.59 169.87,131.77 171.03,132.93 171.03,134.27 v2(171.41,134.64)
  IN3 w0.104: v2(302.23,7.96) 302.4,8.14 302.41,8.14 302.65,8.38 302.65,8.39 302.66,8.4 302.66,8.8 301.95,9.5 293.1,9.5 292.83,9.23 292.83,7.95 289.49,4.62 286.41,4.62 284.78,6.25 278.47,6.25 274.66,2.44 246.98,2.44 245.62,3.79 243.19,3.79 241.67,5.3 222.62,5.3 221.61,4.29 220.67,4.29 v2(220.37,4.6)
  BOTTOM w0.112: v2(171.41,134.64) 171.67,134.39 172.43,134.39 172.74,134.08 173.28,134.08 173.67,133.69 JDGFF1.F8 ; v2(220.37,4.6) 206.15,4.6 188.63,22.12 v1(188.63,101.56) 188.63,103.6 v2(187.94,104.29)
UART_2_PRXD_DTXD: length 203.5
  TOP w0.089: v2(283.39,67.52) 283.22,67.35 283.22,66.72 282.73,66.23 282.73,64.67 282.84,64.56 282.84,63.22 282.72,63.1 282.67,62.98 282.67,62.49 UH1.BD20
  TOP w0.112: JWDB.3 297.02,6.43 296.71,6.75 292.48,6.75 290.65,4.91 290.65,4.53 v2(290.91,4.27) ; RC62.1 283.06,73.61 283.06,72 283.45,71.61 v2(283.45,71.55) ; v2(348.56,27.39) 348,27.39 342.04,33.36 342.04,37.07 341.17,37.93 RN1.1
  IN1 w0.084: v2(283.45,71.55) 283.82,71.17 283.82,70.78 283.54,70.49 283.54,69.68 283.95,69.28 283.95,68.15 283.39,67.6 v2(283.39,67.52) ; v2(311.96,3.51) 310.12,5.35 292.23,5.35 291.29,4.41 291.05,4.41 v2(290.91,4.27)
  IN4 w0.084: v2(290.91,4.27) 290.91,4.31 289.61,5.61 289.61,6.56 286.03,10.14 278.68,10.14 275.44,13.38 275.44,17.7 271.18,21.95 271.18,25.89 268.42,28.65 268.42,35.57 266.5,37.49 266.5,38.91 268.59,40.99 268.59,42.99 269.17,43.57 269.17,44.13 269.94,44.91 269.94,46.38 270.53,46.96 270.87,46.96 271.28,47.37 272.03,47.37 273,48.33 273.75,48.33 273.97,48.55 275.7,48.55 277.03,49.88 277.03,55.66 277.56,56.19 277.79,56.19 278.48,56.88 278.48,59.11 279.01,59.65 279.01,61.1 278.8,61.31 278.8,62.97 279.49,63.66 282.28,63.66 282.66,64.04 282.66,66.19 283.25,66.77 283.25,67.41 283.36,67.52 v2(283.39,67.52)
  BOTTOM w0.112: v2(348.56,27.39) 347.74,27.39 343.33,22.98 343.33,14.04 341.2,11.91 341.2,9.96 333.45,2.21 312.72,2.21 312.29,2.64 312.29,3.18 v2(311.96,3.51)
UART_2_PTXD_DRXD: length 199.8
  TOP w0.089: v2(283.68,67.02) 283.68,66.91 282.92,66.15 282.92,64.75 283.03,64.64 283.03,63.08 282.9,62.96 UH1.BE20
  TOP w0.112: v2(283.47,72.17) 283.47,73.94 283.49,73.96 RC63.1 ; v2(348.56,28.19) 347.7,28.19 342.27,33.62 342.27,37.17 341,38.44 339.75,38.44 338.93,39.27 338.71,39.27 RN120.1 ; JWDB.2 296.22,6.39 296.11,6.51 292.85,6.51 v1(292.42,6.08) 292.24,5.89 292.24,5.89 291.16,4.81 v2(291.13,4.81)
  IN1 w0.084: v2(312.72,3.51) 310.67,5.56 291.99,5.56 291.24,4.81 v2(291.13,4.81) ; v2(283.47,72.17) 284.03,71.61 284.03,70.69 283.75,70.41 283.75,69.77 284.16,69.36 284.16,68.07 283.79,67.7 283.79,67.12 v2(283.68,67.02)
  IN4 w0.084: v2(283.68,67.02) 283.68,66.91 282.87,66.1 282.87,63.95 282.37,63.45 279.58,63.45 279.01,62.88 279.01,61.39 279.22,61.19 279.22,59.56 278.69,59.03 278.69,56.79 277.88,55.98 277.65,55.98 277.24,55.57 277.24,49.78 275.8,48.34 274.06,48.34 273.84,48.12 273.08,48.12 272.12,47.16 271.37,47.16 270.96,46.75 270.62,46.75 270.16,46.29 270.16,44.82 269.38,44.04 269.38,43.49 268.8,42.91 268.8,40.91 266.71,38.82 266.71,37.57 268.63,35.66 268.63,28.74 271.39,25.97 271.39,22.04 275.65,17.78 275.65,13.47 278.77,10.35 286.12,10.35 289.82,6.65 289.82,6.02 291.03,4.81 v2(291.13,4.81)
  BOTTOM w0.112: v2(348.56,28.19) 348.2,28.19 343.09,23.08 343.09,14.14 340.96,12.01 340.96,10.06 333.35,2.45 312.82,2.45 312.53,2.74 312.53,3.32 v2(312.72,3.51)
UG1_ISL95338_1: length 10.9
  TOP w0.112: v2(122.73,144.75) 122.53,144.75 v1(122.2,144.42)
  IN4 w1.016: 113.94,144.49 113.26,145.16 110.81,145.16 110.13,144.49 ; 116.22,144.66 116.68,145.12 121.88,145.12
  vias: v2(109.31,144.1) v2(109.69,143.66) v2(114.79,144.14) v2(115.5,144.16) v2(123.29,144.73)
UG1_ISL95338_2: length 12.8
  TOP w0.112: v2(145,141.82) 144.94,141.82 v1(144.62,141.5)
  IN1 w1.016: 139.08,137.98 139.09,138 139.09,140.12 140.03,141.06 143.82,141.06 144.09,141.32 ; 139.12,131.75 139.12,136.4
  vias: v2(139.34,130.94) v2(139.34,130.36) v2(139.98,137.56) v2(139.98,136.99) v2(145.5,142.07)
UG2_ISL95338_1: length 16.6
  TOP w0.112: v2(126.16,141.88) v1(126.16,141.37)
  IN4 w1.016: 122.76,127.7 124.28,127.7 125.73,129.15 125.73,132.26 126.77,133.3 126.77,141.17 126.69,141.25
  vias: v2(120.87,127.47) v2(121.5,127.47) v2(126.03,142.45)
UG2_ISL95338_2: length 10.3
  TOP w0.112: v2(148.44,139.88) v1(148.03,140.28)
  IN4 w1.016: 149.31,138.64 149.31,135.98 148.87,135.53 148.87,134.33 146.46,131.91 146.46,130.13
  vias: v2(146.11,129.26) v2(146.09,128.67) v2(148.72,139.32)
UG_3V: length 17.6
  TOP w0.112: v2(313.71,44.75) v1(312.92,44.75)
  IN1 w1.016: 326.47,41.55 326.47,44.52 323.42,47.57 316.89,47.57 314.76,45.44
  vias: v2(313.71,45.36) v2(327.33,40.43) v2(327.76,40.08)
UG_5V: length 9.6
  TOP w0.112: v1(326.42,35.77) 326.64,35.99 v2(327.38,35.99)
  IN1 w1.016: 318.16,34.97 325.98,34.97 326.47,35.46
  vias: v2(317.45,35.25) v2(317.45,34.67) v2(327.79,36.4)
UG_+1VALWP: length 8.9
  IN1 w1.016: 265.9,11.07 265.91,11.09 265.91,17.12 267.41,18.62
  BOTTOM w0.112: v2(266.14,10.08) 266.14,10.1 v1(266.67,10.63)
  vias: v2(265.73,9.65) v2(268.4,18.57) v2(269.04,18.57)
UG_CHG:
  vias: v1(200.12,141.44) v2(203.8,138.14) v2(204.18,138.58)
UG_CHG_R: length 6.5
  IN1 w1.016: 200.43,153.05 200.43,146.52 200.44,146.52
  vias: v2(199.41,153.5) v2(199.41,152.87) v2(200.43,145.63) v2(200.43,144.99)
UG_VCCSA: length 7.6
  TOP w0.112: v2(131.5,115.49) v1(130.9,115.49)
  IN4 w1.016: 132.49,114.37 133.07,113.79 137.49,113.79 138.51,114.81 138.51,115.14
  vias: v2(131.88,115.06) v2(138.2,116.3) v2(138.81,116.3)
USB2_COMP: length 6.1
  TOP w0.089: UH1.F4 291.49,43.75 292.05,43.75 292.08,43.78 292.7,43.78 292.89,43.6 293.56,43.6 294.09,43.07 294.09,42.26 295.23,41.12
  TOP w0.102: 295.23,41.12 295.23,41.09 295.33,40.99 RH109.1
USB3_A_DE0: length 4.4
  TOP w0.112: R407.2 30.58,18.36 31.07,18.85 31.07,20.01 R372.2 30.42,20.65 UU6.16
USB3_A_DE1: length 5.5
  TOP w0.112: R399.2 32.85,18.11 v1(33.37,18.63) 33.37,19.77 R374.2 32.11,21.03 31.9,21.03 31.42,21.51 UU6.18
USB3_A_EQ0: length 4.6
  TOP w0.112: UU6.17 30.92,21.19 R373.2 32.11,20.01 32.11,18.6 R400.2
USB3_A_EQ1: length 5.6
  TOP w0.112: v1(28.86,17.74) 29.4,17.74 R406.2 29.45,18.42 29.4,18.42 29.14,18.68 29.14,19.04 29.14,19.13 29.24,19.23 29.24,19.92 R371.2 29.92,20.6 UU6.15
USB3_B_DE0: length 7.2
  TOP w0.112: UU6.3 30.42,26.9 29.84,27.48 R377.2 29.84,28.06 30.35,28.57 30.35,29.26 29.84,29.77 R403.2 29.95,30.33 30.38,30.76 v1(30.38,32.34)
USB3_B_DE1: length 6.4
  TOP w0.112: UU6.6 28.92,26.52 28.35,27.1 28.11,27.1 27.25,27.96 R379.2 26.51,28.71 26.51,29.3 26.19,29.61 v1(26.19,30.25) 26.29,30.35 R405.2
USB3_B_EQ0: length 5.6
  TOP w0.112: R404.2 31.77,30.33 31.91,30.19 v1(31.91,30.12) 31.91,29.52 31.5,29.11 31.5,28.62 30.89,28.01 R378.2 30.92,27.9 UU6.2
USB3_B_EQ1: length 6.1
  TOP w0.112: v1(28.1,30.76) 28.24,30.76 28.68,30.33 R402.2 28.52,29.79 28.52,28.47 R376.2 29.13,27.86 29.13,27.53 29.92,26.74 UU6.4
USB3_PD#: length 2.4
  TOP w0.112: UU6.5 29.42,26.63 28.63,27.43 28.57,27.43 R393.2
USB3_PRX_C_DTX_N8: length 4.6
  TOP w0.112: JCDRA.36 165.75,191.53 165.66,191.44 165.66,190.82 165.74,190.73 v4(165.74,190.21) 165.74,189.16 165.76,189.14 165.76,188.6 165.74,188.58 165.74,188.27 CI38.2
USB3_PRX_C_DTX_P8: length 4.6
  TOP w0.112: CI39.2 165.52,188.27 v4(165.52,188.87) 165.52,189.92 165.5,189.93 165.5,190.47 165.52,190.49 165.52,190.65 165.44,190.73 165.44,191.41 165.35,191.5 JCDRA.37
USB3_PRX_C_RD_DTX_N6: length 1.9
  TOP w0.112: UU6.23 32.69,24.83 32.81,24.7 33.52,24.7 CU112.2
USB3_PRX_C_RD_DTX_P6: length 1.9
  TOP w0.112: UU6.22 32.83,24.33 32.98,24.48 33.6,24.48 CU111.2
USB3_PRX_DTX_N5: length 136.5
  TOP w0.089: UH1.J13 286.22,45.26 v2(286.08,45.13)
  TOP w0.112: v2(372.07,24.09) 371.85,23.87 371.85,23.57 372.2,23.22 375.14,23.22 375.42,23.5 DU13.1 DU13.9 377.23,23.5 377.37,23.36 378.14,23.36 379.69,24.92 382.93,24.92 383.63,25.61 384.03,25.61 384.15,25.73 JUSB3.5
  IN1 w0.084: v2(372.07,24.09) 371.74,23.75 371.74,22.15 370.33,20.75 368.04,20.75 367.2,19.91 357.92,19.91 353.89,15.87 348.03,15.87 345.96,13.81 336.85,13.81 334.02,10.98 320.79,10.98 318.83,12.94 308.54,12.94 305.24,16.24 303.85,16.24 302.54,17.55 302.54,22.63 301.76,23.41 301.76,24.58 300.31,26.02 300.31,29.36 299.28,30.39 299.28,31.04 299.71,31.46 299.71,41.05 298.4,42.36 295.27,42.36 294.02,41.1 292.39,41.1 292.13,41.37 289.47,41.37 287.26,43.58 287.26,44.58 286.39,45.45 286.21,45.45 286.08,45.32 v2(286.08,45.13)
USB3_PRX_DTX_N6: length 294.9
  TOP w0.089: UH1.G14 285.78,44.17 v2(285.67,44.07)
  TOP w0.112: v2(37.32,23.45) 37.18,23.59 37.18,24.02 36.37,24.83 35.74,24.83 35.64,24.72 35.19,24.72 CU112.1
  IN1 w0.084: v2(285.67,44.07) 285.67,44.01 285.62,43.97 285.62,43.64 285.52,43.53 285.52,41.51 285.89,41.14 285.89,38.41 285.25,37.78 285.25,36.99 287.63,34.61 287.63,32.35 283.09,27.81 278.92,27.81 278.65,28.09 274.71,28.09 273.29,29.51 271.19,29.51 270.76,29.94 262.34,29.94 262,30.28 256.79,30.28 256.12,30.95 254.31,30.95 252.51,29.15 245.83,29.15 244.14,27.46 243.33,27.46 238.32,22.45 229.21,22.45 228.13,23.53 213.43,23.53 212.78,22.89 174.51,22.89 160.68,9.06 132.27,9.06 131.54,9.79 123.37,9.79 122.22,10.94 115.43,10.94 114.96,10.48 112.11,10.48 109.6,12.99 107.03,12.99 105.83,14.19 97.87,14.19 92.73,9.06 89.14,9.06 86.12,12.08 69.6,12.08 65.65,16.03 61.33,16.03 60.7,15.4 58.65,15.4 57.95,14.7 55.55,14.7 54.57,15.68 51.95,15.68 50.73,14.47 48.61,14.47 47.71,15.37 44.83,15.37 42.15,18.04 40.37,18.04 37.18,21.23 37.18,23.31 v2(37.32,23.45)
USB3_PRX_DTX_N7: length 157.5
  TOP w0.089: UH1.G17 284.54,44.62 284.85,44.92 284.85,45.05 v2(284.8,45.1)
  TOP w0.112: JUSB2.5 384.15,45.98 383.95,45.78 383.74,45.78 383,45.04 379.25,45.04 378.32,44.11 377.84,44.11 377.82,44.09 377.32,44.09 377.18,44.23 DU12.9 DU12.1 375.57,44.23 375.43,44.09 375.19,44.09 v2(374.99,44.29)
  IN1 w0.084: v2(284.8,45.1) 284.9,44.92 285.14,44.86 285.27,45 285.63,45 286.79,43.84 286.79,43.38 289.98,40.2 292.31,40.2 292.75,40.64 294.21,40.64 295.46,41.89 298.2,41.89 299.24,40.85 299.24,31.73 298.67,31.16 298.67,26.44 300.39,24.72 300.96,24.72 301.29,24.39 301.29,23.16 302.07,22.38 302.07,17.36 307.61,11.82 319.29,11.82 320.6,10.52 334.21,10.52 337.04,13.34 346.15,13.34 348.22,15.41 354.08,15.41 358.12,19.44 369.75,19.44 372.73,22.42 372.73,26.26 371.25,27.74 371.25,40.02 372.79,41.56 372.79,42.32 374.55,44.08 374.78,44.08 v2(374.99,44.29)
USB3_PRX_DTX_N8: length 255.3
  TOP w0.094: v2(283.1,48.46) 283.09,48.46 UH1.R21
  TOP w0.112: CI38.1 165.87,186.99 165.64,186.76 165.64,186.49 165.84,186.28 166.85,186.28 168.78,188.22 174.35,188.22 175.74,186.83 176.07,186.83 v2(176.35,187.12)
  IN1 w0.084: v2(176.35,187.12) 176.14,186.91 175.93,186.91 175.17,186.15 175.17,184.39 176.27,183.28 176.49,183.28 178.47,181.31 178.47,179.54 177.74,178.81 177.74,172.7 175.37,170.33 174.55,170.33 174.01,169.8 169.56,169.8 168.05,168.28 168.05,166.4 171.21,163.24 171.92,163.24 173.4,161.76 174.76,161.76 178.79,157.72 178.79,156.57 181.57,153.79 181.57,146.56 182.08,146.05 182.08,144.36 183.85,142.59 183.85,139.3 183.25,138.69 183.25,134.74 184.11,133.88 184.11,130.77 187.85,127.04 189.43,127.04 206.65,109.82 212.49,109.82 213.38,110.71 215.27,110.71 216.15,109.84 222.4,109.84 223.11,109.12 234.97,109.12 236.14,107.95 251.88,107.95 252.28,107.55 264.71,107.55 286.68,85.58 286.68,74.33 285.76,73.42 285.76,70.03 285.22,69.49 285.22,66.62 285.71,66.13 285.71,65.54 284.94,64.76 284.94,61.06 285.44,60.55 285.44,59.76 286.61,58.6 286.61,57.97 286.61,57.96 286.61,57.83 286.62,57.82 286.62,57.49 286.61,57.48 286.61,57.32 286.94,56.99 287.61,56.99 287.93,56.67 289.07,56.67 289.48,56.27 289.55,56.27 289.85,55.97 289.85,55.64 289.33,55.11 288.53,55.11 285.22,51.8 285.22,50.05 283.28,48.12 283.18,48.12 283.1,48.21 v2(283.1,48.46)
USB3_PRX_DTX_P5: length 136.5
  TOP w0.089: UH1.K13 286.05,46 v2(285.8,45.74)
  TOP w0.112: JUSB3.6 384.15,25.29 384.04,25.39 383.72,25.39 383.03,24.69 379.78,24.69 378.23,23.14 377.37,23.14 377.23,23 DU13.8 DU13.2 372.11,23 371.63,23.48 371.63,23.94 v2(371.49,24.09)
  IN1 w0.084: v2(371.49,24.09) 371.57,24.01 371.57,22.22 370.26,20.91 367.97,20.91 367.13,20.07 357.85,20.07 353.82,16.04 347.96,16.04 345.89,13.98 336.78,13.98 333.95,11.15 320.86,11.15 318.9,13.1 308.61,13.1 305.31,16.41 303.92,16.41 302.71,17.62 302.71,22.7 301.92,23.48 301.92,24.65 300.48,26.09 300.48,29.43 299.45,30.46 299.45,30.97 299.87,31.39 299.87,41.12 298.47,42.52 295.2,42.52 293.95,41.27 292.46,41.27 292.19,41.53 289.54,41.53 287.42,43.65 287.42,44.65 286.46,45.62 285.93,45.62 v2(285.8,45.74)
USB3_PRX_DTX_P6: length 294.9
  TOP w0.089: v2(286.01,43.5) 286.01,43.81 UH1.F14
  TOP w0.112: CU111.1 35.15,24.5 35.73,24.5 35.81,24.59 v4(36.03,24.59) 36.3,24.59 36.96,23.93 36.96,23.68 v2(36.73,23.45)
  IN1 w0.084: v2(286.01,43.5) 285.93,43.58 285.81,43.58 285.69,43.45 285.69,41.58 286.05,41.21 286.05,38.34 285.42,37.71 285.42,37.06 287.8,34.68 287.8,32.28 283.16,27.64 278.85,27.64 278.58,27.92 274.64,27.92 273.22,29.34 271.12,29.34 270.69,29.78 262.27,29.78 261.93,30.11 256.72,30.11 256.05,30.78 254.38,30.78 252.58,28.98 245.9,28.98 244.21,27.29 243.4,27.29 238.39,22.28 229.14,22.28 228.06,23.36 213.5,23.36 212.85,22.72 174.58,22.72 160.75,8.89 132.2,8.89 131.47,9.62 123.3,9.62 122.15,10.78 115.5,10.78 115.03,10.31 112.04,10.31 109.53,12.82 106.96,12.82 105.76,14.03 97.94,14.03 92.8,8.89 89.07,8.89 86.05,11.91 69.53,11.91 65.58,15.86 61.4,15.86 60.77,15.23 58.72,15.23 58.02,14.53 55.48,14.53 54.5,15.51 52.01,15.51 50.8,14.3 48.54,14.3 47.64,15.2 44.76,15.2 42.08,17.88 40.3,17.88 37.01,21.16 37.01,23.18 v2(36.73,23.45)
USB3_PRX_DTX_P7: length 157.5
  TOP w0.089: UH1.F16 285.18,44.38 v2(285.18,44.44)
  TOP w0.112: v2(374.99,43.71) 375.15,43.87 375.41,43.87 375.55,43.73 DU12.2 DU12.8 377.18,43.73 377.32,43.87 v4(378.11,43.87) 378.39,43.87 379.34,44.82 383.09,44.82 383.83,45.56 384.02,45.56 384.15,45.43 JUSB2.6
  IN1 w0.084: v2(285.18,44.44) 285.15,44.48 285.21,44.7 285.34,44.83 285.56,44.83 286.62,43.77 286.62,43.31 289.91,40.03 292.38,40.03 292.82,40.47 294.28,40.47 295.53,41.72 298.13,41.72 299.07,40.78 299.07,31.8 298.5,31.22 298.5,26.37 300.32,24.55 300.89,24.55 301.12,24.32 301.12,23.09 301.91,22.31 301.91,17.29 307.54,11.66 319.22,11.66 320.53,10.35 334.28,10.35 337.11,13.18 346.22,13.18 348.29,15.24 354.15,15.24 358.19,19.27 369.82,19.27 372.9,22.35 372.9,26.33 371.42,27.81 371.42,39.95 372.96,41.49 372.96,42.25 374.62,43.91 374.78,43.91 v2(374.99,43.71)
USB3_PRX_DTX_P8: length 255.3
  TOP w0.094: v2(283.1,47.69) 283.09,47.69 UH1.P21
  TOP w0.112: CI39.1 165.42,186.74 165.42,186.4 165.75,186.06 166.94,186.06 168.87,188 174.26,188 175.65,186.61 176.27,186.61 v2(176.35,186.53)
  IN1 w0.084: v2(283.1,47.69) 283.1,47.87 283.18,47.95 283.35,47.95 285.38,49.98 285.38,51.73 288.6,54.95 289.4,54.95 290.02,55.57 290.02,56.04 289.62,56.43 289.55,56.43 289.14,56.84 288,56.84 287.68,57.16 287.01,57.16 286.77,57.39 286.77,57.42 286.78,57.42 286.78,57.56 286.78,57.56 286.78,57.89 286.78,57.9 286.78,58.67 285.61,59.83 285.61,60.62 285.1,61.13 285.1,64.69 285.88,65.47 285.88,66.2 285.39,66.69 285.39,69.42 285.93,69.96 285.93,73.35 286.85,74.27 286.85,85.65 264.78,107.72 252.35,107.72 251.95,108.12 236.21,108.12 235.04,109.29 223.18,109.29 222.47,110.01 216.22,110.01 215.34,110.88 213.31,110.88 212.42,109.99 206.72,109.99 189.5,127.21 187.92,127.21 184.28,130.84 184.28,133.95 183.41,134.81 183.41,138.62 184.02,139.23 184.02,142.66 182.25,144.43 182.25,146.12 181.74,146.63 181.74,153.86 178.96,156.64 178.96,157.79 174.83,161.93 173.47,161.93 171.99,163.41 171.28,163.41 168.21,166.47 168.21,168.21 169.63,169.63 174.08,169.63 174.62,170.17 175.44,170.17 177.91,172.63 177.91,178.74 178.64,179.47 178.64,181.38 176.56,183.45 176.34,183.45 175.34,184.45 175.34,186.08 176,186.74 176.14,186.74 v2(176.35,186.53)
USB3_PRX_RD_DTX_N6: length 18.6
  TOP w0.112: UU6.8 27.56,24.83 27.46,24.73 27.26,24.73 v2(27.02,24.98) ; v2(23.34,20.72) 23.56,20.94 23.56,21.8 23.39,21.97 22.79,21.97 22.65,21.83 DU2.1 DU2.9 20.89,21.83 20.73,21.99 19.65,21.99 17.93,20.27 17.36,20.27 16.09,19.01 15.79,19.01 15.68,18.9 JUSB1.5
  IN1 w0.084: v2(27.02,24.98) 26.8,24.77 26.68,24.77 26.4,24.48 26.4,23.9 25.49,22.99 25.3,22.99 23.55,21.24 23.55,20.93 v2(23.34,20.72)
USB3_PRX_RD_DTX_P6: length 18.7
  TOP w0.112: v2(23.93,20.72) 23.78,20.87 23.78,21.9 23.48,22.19 22.79,22.19 22.65,22.33 DU2.2 DU2.8 20.88,22.33 20.76,22.22 19.56,22.22 17.84,20.5 17.26,20.5 16,19.24 15.79,19.24 15.68,19.35 JUSB1.6 ; UU6.9 27.6,24.33 27.42,24.51 27.13,24.51 v2(27.02,24.39)
  IN1 w0.084: v2(27.02,24.39) 26.81,24.6 26.75,24.6 26.57,24.41 26.57,23.83 25.56,22.82 25.37,22.82 23.72,21.17 23.72,20.93 v2(23.93,20.72)
USB3_PTX_C_DRX_N5: length 12.4
  TOP w0.112: JUSB3.8 384.15,19.72 384.01,19.58 383.76,19.58 383.06,20.28 v4(381.16,20.28) 380.33,20.28 378.74,21.86 378.34,21.86 378.32,21.88 377.77,21.88 377.75,21.86 377.37,21.86 377.23,22 DU13.7 DU13.4 375.42,22 375.28,21.86 374.17,21.86 CU107.1
USB3_PTX_C_DRX_N6: length 9.9
  TOP w0.112: CU113.1 23.01,23.47 22.61,23.47 22.47,23.33 DU2.4 DU2.7 21.04,23.33 20.9,23.47 20.72,23.47 20.36,23.83 v4(20.03,23.83) 19.78,23.83 19.76,23.85 19.55,23.85 19.07,24.33 18.61,24.79 16.93,24.79 15.95,25.76 15.79,25.76 15.68,25.65 JUSB1.8
USB3_PTX_C_DRX_N7: length 12.7
  TOP w0.112: JUSB2.8 384.15,39.78 384.01,39.65 383.63,39.65 382.87,40.41 381.22,40.41 379.12,42.51 v4(378.3,42.51) 377.4,42.51 377.18,42.73 DU12.7 DU12.4 375.54,42.73 375.4,42.59 375.1,42.59 375.08,42.61 374.64,42.61 374.42,42.82 374.14,42.82 CU50.1
USB3_PTX_C_DRX_P5: length 12.3
  TOP w0.112: CU106.1 374.26,21.64 375.28,21.64 375.42,21.5 DU13.5 DU13.6 377.23,21.5 377.37,21.64 v4(378.04,21.64) 378.65,21.64 380.23,20.06 380.87,20.06 380.88,20.04 381.43,20.04 381.45,20.06 382.97,20.06 383.67,19.36 383.98,19.36 384.15,19.19 JUSB3.9
USB3_PTX_C_DRX_P6: length 9.9
  TOP w0.112: JUSB1.9 15.68,26.1 15.79,25.99 16.04,25.99 17.02,25.01 18.73,25.01 v4(18.92,24.81) 19.08,24.66 19.08,24.63 19.64,24.07 20.33,24.07 20.35,24.05 20.45,24.05 20.81,23.69 20.97,23.69 21.11,23.83 DU2.6 DU2.5 22.42,23.83 22.56,23.69 23.14,23.69 CU114.1
USB3_PTX_C_DRX_P7: length 12.7
  TOP w0.112: CU49.1 374.12,42.6 374.33,42.6 374.57,42.37 v4(374.81,42.37) 375.23,42.37 375.37,42.23 DU12.5 DU12.6 377.18,42.23 377.24,42.29 378.01,42.29 378.03,42.27 378.57,42.27 378.59,42.29 379.02,42.29 381.12,40.19 382.78,40.19 383.54,39.43 384.01,39.43 384.15,39.29 JUSB2.9
USB3_PTX_C_RD_DRX_N6: length 2
  TOP w0.112: CU110.1 33.58,22.88 33.25,22.88 32.95,23.18 32.47,23.18 32.32,23.33 UU6.20
USB3_PTX_C_RD_DRX_P6: length 2
  TOP w0.112: CU12.1 33.48,22.68 33.14,22.68 32.86,22.96 32.51,22.96 32.38,22.83 UU6.19
USB3_PTX_DRX_N5: length 123.9
  TOP w0.089: UH1.C15 285.77,42.54 285.77,40.85 286.09,40.54 286.09,39.44 286.23,39.3 286.36,39.3 v2(286.47,39.42)
  TOP w0.112: CU107.2 372.55,21.8 372.09,21.8 371.85,21.56 371.85,21.08 372.25,20.68 372.25,19.73 v2(372.19,19.67)
  IN1 w0.084: v2(286.47,39.42) 286.7,39.19 292.31,39.19 293.13,40 295.4,40 296.09,40.7 298.03,40.7 298.43,40.3 298.61,40.12 298.61,32.16 297.46,31.01 297.46,26.36 299.53,24.29 299.53,23.73 300.02,23.24 300.27,23.24 301.44,22.07 301.44,17.1 308.66,9.88 334.48,9.88 337.31,12.71 348.46,12.71 348.89,13.14 352.71,13.14 358.38,18.81 372.01,18.81 372.19,18.98 v2(372.19,19.67)
USB3_PTX_DRX_N6: length 297.2
  TOP w0.089: UH1.C17 284.73,42.2 284.95,42.12 285.09,41.78 285.19,41.68 285.19,40.36 285.41,40.15 285.41,38.17 285.89,37.69 286.23,37.69 v2(286.49,37.43)
  TOP w0.112: CU110.2 35.2,22.84 35.48,22.84 35.59,22.95 35.59,23.11 v2(35.41,23.29)
  IN1 w0.084: v2(35.41,23.29) 35.41,21.21 36.49,20.13 36.49,18.26 36,17.77 36,15.83 37.26,14.57 47.36,14.57 48.38,13.55 59.98,13.55 61.66,15.23 65.32,15.23 69.27,11.28 85.78,11.28 88.92,8.14 92.94,8.14 98.2,13.39 105.5,13.39 106.7,12.19 109.27,12.19 111.85,9.61 115.23,9.61 115.76,10.14 121.89,10.14 123.18,8.85 130.99,8.85 131.58,8.26 161.02,8.26 174.84,22.09 213.11,22.09 213.76,22.73 227.79,22.73 228.88,21.65 238.65,21.65 241.94,24.93 244.4,24.93 246.82,27.35 249.25,27.35 250.16,28.27 253.31,28.27 254.86,29.82 256.12,29.82 256.67,29.26 261.56,29.26 261.68,29.14 270.43,29.14 270.86,28.71 272.95,28.71 274.38,27.29 278.32,27.29 278.59,27.01 283.42,27.01 288.43,32.02 288.43,34.94 286.13,37.24 286.13,37.26 286.12,37.27 286.12,37.51 286.22,37.61 286.31,37.61 v2(286.49,37.43)
USB3_PTX_DRX_N7: length 137.9
  TOP w0.089: UH1.A17 284.35,41.5 284.35,41.57 284.44,41.66 284.61,41.66 284.65,41.62 284.65,41.62 284.8,41.47 284.8,41.34 284.23,40.76 284.23,39.77 284.43,39.57 284.64,39.57 v2(284.82,39.39)
  TOP w0.112: CU50.2 372.43,42.74 372.17,42.74 v2(371.9,43)
  BOTTOM w0.112: v2(284.82,39.39) 284.55,39.65 284.18,39.65 283.98,39.46 283.98,38.54 284.38,38.14 284.38,32.33 288.66,28.05 289.24,28.05 291.84,25.45 293.74,25.45 294.42,26.13 298.27,26.13 299.58,24.82 299.58,24.05 300.11,23.52 300.96,23.52 302.85,25.42 305.21,25.42 307.12,23.5 307.12,20.97 313.59,14.5 314.35,14.5 320.96,7.89 337.33,7.89 340.01,10.57 340.01,12.41 342.01,14.4 342.01,18.41 341.66,18.76 341.66,23 350.1,31.44 353.23,31.44 353.78,30.89 357.16,30.89 360.5,34.23 360.5,35.57 362.98,38.04 368.01,38.04 371.02,41.06 371.02,42.4 371.27,42.64 371.54,42.64 v2(371.9,43)
USB3_PTX_DRX_N8: length 277.9
  TOP w0.089: v2(283.17,40.11) 283.17,40.06 283.45,39.77 283.66,39.77 283.76,39.87 283.76,41.3 283.94,41.47 283.94,41.69 283.85,41.78 283.76,41.78 283.61,41.93 283.61,42.15 283.7,42.24 283.84,42.24 283.93,42.15 UH1.B18
  TOP w0.112: JCDRA.42 163.35,191.48 163.26,191.39 163.26,190.74 162.08,189.55 162.08,186.57 163.79,184.86 167.44,184.86 168.95,186.36 173.93,186.36 175.23,185.06 176.01,185.06 v2(176.38,185.42)
  IN1 w0.084: v2(176.38,185.42) 176.38,185.4 175.98,185 175.98,184.88 175.9,184.81 175.9,184.55 176.34,184.11 176.62,184.11 179.1,181.63 179.1,179.28 178.96,179.13 178.96,176.44 179.62,175.77 179.62,174.58 179.18,174.15 179.18,170.65 178.71,170.18 177.75,170.18 177.28,169.7 174.92,169.7 173.81,168.59 171.8,168.59 171.27,169.12 169.84,169.12 168.68,167.96 168.68,166.66 171.43,163.92 172.43,163.92 172.94,163.41 174.02,163.41 176.92,160.5 177.37,160.5 179.4,158.48 179.46,158.48 179.76,158.18 179.76,156.5 182.21,154.05 182.21,146.82 182.71,146.32 182.71,144.63 184.48,142.86 184.48,139.03 183.88,138.43 183.88,135.01 184.74,134.14 184.74,131.04 188.11,127.67 189.69,127.67 206.02,111.35 215.53,111.35 216.3,110.58 222.61,110.58 223.43,109.76 235.23,109.76 235.82,109.16 263.99,109.16 287.6,85.55 287.6,72.68 286.61,71.69 286.61,64.64 287.25,64.01 287.25,61.44 286.79,60.98 286.79,59.51 287.25,59.05 288.67,59.05 288.85,59.23 289.3,59.23 289.88,58.65 289.88,57.15 290.92,56.11 290.92,55.34 290.06,54.48 288.79,54.48 286.08,51.77 286.08,50.02 283.33,47.27 282.73,47.27 282.36,46.9 282.36,46.38 282.66,46.08 282.66,44.11 283.29,43.47 283.29,42.88 283.54,42.63 283.54,40.02 283.46,39.94 283.34,39.94 v2(283.17,40.11)
USB3_PTX_DRX_P5: length 123.9
  TOP w0.089: UH1.B15 285.51,42.15 285.6,42.06 285.6,40.78 285.91,40.46 285.91,39.37 286.22,39.06 286.25,39.06 v2(286.47,38.83)
  TOP w0.112: v2(372.77,19.67) 372.47,19.97 372.47,20.77 372.07,21.17 372.07,21.47 372.18,21.58 372.61,21.58 CU106.2
  IN1 w0.084: v2(372.77,19.67) 372.35,19.25 372.35,18.91 372.08,18.64 358.45,18.64 352.78,12.97 348.96,12.97 348.53,12.54 337.37,12.54 334.55,9.71 308.59,9.71 301.27,17.03 301.27,22 300.2,23.07 299.95,23.07 299.36,23.66 299.36,24.22 297.29,26.29 297.29,31.08 298.44,32.23 298.44,40.05 298.26,40.23 297.96,40.53 296.16,40.53 295.47,39.84 293.2,39.84 292.38,39.02 286.66,39.02 v2(286.47,38.83)
USB3_PTX_DRX_P6: length 297.3
  TOP w0.089: v2(286.49,38.01) 286.35,37.86 285.97,37.86 285.58,38.25 285.58,40.22 285.37,40.43 285.37,41.75 285.24,41.88 285.11,42.18 285.2,42.4 UH1.C16
  TOP w0.112: CU12.2 35.14,22.62 35.57,22.62 35.81,22.86 35.81,23.11 v2(35.99,23.29)
  IN1 w0.084: v2(35.99,23.29) 35.57,22.88 35.57,21.28 36.66,20.2 36.66,18.19 36.17,17.7 36.17,15.9 37.33,14.74 47.43,14.74 48.45,13.71 59.91,13.71 61.59,15.4 65.38,15.4 69.34,11.45 85.85,11.45 88.99,8.3 92.87,8.3 98.13,13.56 105.57,13.56 106.77,12.36 109.33,12.36 111.92,9.78 115.16,9.78 115.69,10.31 121.96,10.31 123.25,9.01 131.06,9.01 131.65,8.43 160.95,8.43 174.77,22.25 213.04,22.25 213.69,22.9 227.86,22.9 228.95,21.81 238.58,21.81 241.87,25.1 244.33,25.1 246.75,27.52 249.18,27.52 250.09,28.44 253.24,28.44 254.79,29.99 256.19,29.99 256.74,29.43 261.63,29.43 261.75,29.31 270.5,29.31 270.93,28.88 273.02,28.88 274.45,27.46 278.38,27.46 278.66,27.18 283.36,27.18 288.26,32.09 288.26,34.87 285.97,37.17 285.97,37.19 285.95,37.2 285.95,37.58 286.15,37.77 286.25,37.77 v2(286.49,38.01)
USB3_PTX_DRX_P7: length 137.9
  TOP w0.089: v2(284.82,39.97) 284.59,39.75 284.5,39.75 284.4,39.85 284.4,40.69 284.98,41.26 284.98,41.56 UH1.B17
  TOP w0.112: v2(371.9,42.42) 372,42.52 372.62,42.52 CU49.2
  BOTTOM w0.112: v2(371.9,42.42) 371.36,42.42 371.25,42.31 371.25,40.97 368.1,37.82 363.07,37.82 360.72,35.48 360.72,34.14 357.25,30.67 353.69,30.67 353.14,31.22 350.19,31.22 341.88,22.91 341.88,18.85 342.23,18.51 342.23,14.31 340.23,12.31 340.23,10.48 337.42,7.67 320.87,7.67 314.26,14.28 313.5,14.28 306.9,20.88 306.9,23.41 305.11,25.19 302.95,25.19 301.05,23.3 300.02,23.3 299.36,23.96 299.36,24.72 298.18,25.91 294.51,25.91 293.83,25.23 291.75,25.23 289.15,27.83 288.57,27.83 284.16,32.24 284.16,38.05 283.76,38.44 283.76,39.55 284.09,39.88 284.72,39.88 v2(284.82,39.97)
USB3_PTX_DRX_P8: length 277.9
  TOP w0.089: v2(283.17,39.53) 283.24,39.6 283.73,39.6 283.94,39.8 283.94,41.22 284.12,41.4 284.12,41.89 284.16,41.93 284.16,42.24 283.93,42.48 UH1.C18
  TOP w0.112: v2(176.38,184.84) 175.14,184.84 173.84,186.14 169.04,186.14 167.53,184.63 163.7,184.63 161.86,186.48 161.86,189.64 163.04,190.83 163.04,191.4 162.95,191.49 JCDRA.43
  IN1 w0.084: v2(176.38,184.84) 176.17,184.84 176.07,184.74 176.07,184.62 176.41,184.28 176.69,184.28 179.27,181.7 179.27,179.21 179.12,179.06 179.12,176.51 179.79,175.84 179.79,174.52 179.35,174.08 179.35,170.58 178.78,170.01 177.82,170.01 177.35,169.53 174.99,169.53 173.88,168.43 171.73,168.43 171.2,168.96 169.91,168.96 168.85,167.89 168.85,166.73 171.5,164.08 172.5,164.08 173.01,163.58 174.09,163.58 176.99,160.67 177.44,160.67 179.46,158.65 179.53,158.65 179.92,158.25 179.92,156.57 182.37,154.12 182.37,146.89 182.88,146.39 182.88,144.7 184.65,142.93 184.65,138.96 184.05,138.36 184.05,135.08 184.91,134.21 184.91,131.11 188.18,127.84 189.76,127.84 206.09,111.51 215.6,111.51 216.37,110.74 222.68,110.74 223.5,109.92 235.3,109.92 235.89,109.33 264.06,109.33 287.77,85.62 287.77,72.61 286.78,71.62 286.78,64.71 287.42,64.08 287.42,61.37 286.96,60.91 286.96,59.58 287.32,59.22 288.6,59.22 288.78,59.4 289.37,59.4 290.05,58.72 290.05,57.22 291.09,56.18 291.09,55.27 290.13,54.31 288.86,54.31 286.25,51.7 286.25,49.95 283.4,47.1 282.8,47.1 282.52,46.83 282.52,46.45 282.83,46.15 282.83,44.18 283.46,43.54 283.46,42.95 283.71,42.7 283.71,39.95 283.53,39.77 283.41,39.77 v2(283.17,39.53)
USB3_PTX_RD_DRX_N6: length 8.8
  TOP w0.112: v2(25.37,20.72) 25.59,20.94 25.59,21.07 25.57,21.09 25.57,21.63 25.59,21.65 25.59,23.26 25.44,23.41 24.68,23.41 CU113.2 ; v2(26.23,22.66) 26.45,22.89 26.45,23.05 26.73,23.33 UU6.11
  IN1 w0.084: v2(26.23,22.66) 26.44,22.46 26.44,21.98 25.64,21.18 25.64,21 v2(25.37,20.72)
USB3_PTX_RD_DRX_P6: length 8.8
  TOP w0.112: UU6.12 27.7,22.83 27.42,23.11 26.82,23.11 26.68,22.96 26.68,22.8 v2(26.81,22.66) ; CU114.2 24.68,23.63 25.53,23.63 25.81,23.35 v4(25.81,21.36) 25.81,20.87 v2(25.96,20.72)
  IN1 w0.084: v2(25.96,20.72) 25.81,20.87 25.81,21.11 26.6,21.91 26.6,22.46 v2(26.81,22.66)
USB3_TEST: length 4.2
  TOP w0.112: R411.2 27.46,19.2 v1(27.84,19.58) 27.89,19.58 R375.2 29.42,21.12 UU6.14
USB20_N1: length 303.8
  TOP w0.089: UH1.J3 291.38,45.48 291.47,45.4 291.81,45.4 291.93,45.51 292.41,45.51 292.54,45.64 294.6,45.64 297.41,42.83 297.41,39.93 v2(297.8,39.55)
  TOP w0.112: UU1.2 37.37,15.5 37.51,15.64 38.16,15.64 38.24,15.56 38.7,15.56 38.72,15.54 v4(38.95,15.54) 39.45,15.54 40.15,14.84 40.15,13.18 v2(39.99,13.02)
  IN1 w0.084: v2(39.99,13.02) 39.99,12.36 40.21,12.15 43.52,12.15 45.24,13.87 47.17,13.87 48.23,12.81 61.96,12.81 62.69,13.54 65.96,13.54 68.95,10.55 85.03,10.55 88.07,7.5 93.21,7.5 97.35,11.64 98.51,11.64 99.59,12.72 105.27,12.72 106.44,11.56 109,11.56 111.59,8.98 115.49,8.98 116.02,9.51 121.62,9.51 122.92,8.21 130.67,8.21 131.26,7.63 161.28,7.63 168.67,15.02 184.46,15.02 190.9,21.45 213.38,21.45 214.02,22.1 227.51,22.1 228.59,21.01 240.39,21.01 243.24,23.85 250.46,23.85 254.06,27.45 254.06,28.12 255.12,29.19 255.8,29.19 256.36,28.63 261.3,28.63 261.42,28.51 270.17,28.51 270.6,28.08 272.69,28.08 274.11,26.66 278.05,26.66 278.46,26.25 283.55,26.25 289.2,31.9 289.2,36.92 290.54,38.25 292.51,38.25 293.46,39.2 295.73,39.2 296.28,39.76 296.86,39.76 297.07,39.55 v2(297.8,39.55)
USB20_N2: length 138.8
  TOP w0.094: v2(286.04,46.82) 285.77,47.09 285.77,47.39 285.91,47.54 286.09,47.54 286.22,47.41 UH1.N13
  IN1 w0.084: v2(369.96,38) 370.17,38.21 370.43,38.21 370.51,38.13 370.51,22.17 369.93,21.59 367.75,21.59 366.87,20.71 357.59,20.71 353.56,16.67 349.21,16.67 348.12,17.77 346.54,17.77 344.2,15.43 339.69,15.43 338.88,14.63 336.54,14.63 333.69,11.78 321.12,11.78 319.08,13.82 310.77,13.82 309.71,14.88 307.73,14.88 305.5,17.1 304.61,17.1 303.34,18.38 303.34,23.01 302.56,23.79 302.56,24.91 301.11,26.36 301.11,29.51 301.44,29.84 301.44,33.59 301.15,33.88 301.15,38.13 300.63,38.65 300.63,41.26 298.73,43.16 294.94,43.16 294.08,42.29 291.21,42.29 290.99,42.52 289.92,42.52 288.14,44.3 288.14,44.87 287.94,45.06 287.94,45.45 287.04,46.35 286.09,46.35 286.06,46.38 285.86,46.38 285.8,46.44 285.8,46.56 286.03,46.79 286.03,46.82 v2(286.04,46.82)
  BOTTOM w0.112: v2(369.96,38) 370.15,38.19 370.54,38.19 371.45,39.09 371.89,39.09 LU4.1 372.03,38.89 RU123.1
USB20_N2_R: length 13.9
  BOTTOM w0.112: JUSB2.2 382.65,42.28 382.54,42.39 379.8,42.39 379.78,42.37 379.33,42.37 379.02,42.06 378.99,42.06 378.36,41.43 v4(378.2,41.27) 378.2,41.27 375.94,39.01 375.61,39.01 375.5,38.9 375.5,38.42 DU10.2 374.99,38.44 374.99,38.92 374.88,39.03 374.41,39.03 374.27,39.17 374.07,39.17 373.85,38.95 CU104.1 373.48,39.13 372.89,39.13 372.72,38.95 LU4.2 372.62,38.95 RU123.2
USB20_N3: length 252.1
  TOP w0.089: v2(293.99,46.38) 293.81,46.56 293.41,46.56 293.16,46.31 292.69,46.31 292.27,45.9 291.51,45.9 291.39,45.77 290.94,45.77 290.76,45.96 290.76,45.96 UH1.K4
  TOP w0.112: LM1.1 162.82,186.52 163.2,186.14 163.99,186.14 164.78,185.35 167.23,185.35 169.17,187.28 173.7,187.28 175.09,185.89 176.7,185.89 v2(176.89,185.71)
  IN1 w0.084: v2(293.99,46.38) 293.76,46.61 293.55,46.61 293.34,46.82 293.34,47.2 294.12,47.98 294.12,49.43 294.61,49.92 294.61,51.24 294.33,51.52 294.33,53.21 293.45,54.1 293.45,55.5 294.34,56.39 294.85,56.39 295.01,56.54 295.01,57.04 294.15,57.89 294.15,58.93 294.06,59.02 294.06,59.11 292.45,60.72 292.45,60.86 292.45,63.1 291.08,64.46 291.08,70.2 291.83,70.95 291.83,75.89 291.07,76.65 291.07,79.58 290.13,80.52 290.13,86.6 265.03,111.7 238.65,111.7 236.45,113.9 207.04,113.9 191.53,129.42 191.53,133.79 188.58,136.73 188.58,141.14 184.8,144.92 184.8,145.55 184.03,146.32 184.03,146.79 183.49,147.33 183.49,154.56 181.03,157.02 181.03,159.19 175.54,164.67 175.54,166.2 175.52,166.22 175.52,168.22 176.25,168.94 179.19,168.94 180.92,170.67 180.92,175.62 180.06,176.47 180.06,177.16 179.95,177.28 179.95,179.23 180.13,179.41 180.13,181.93 179.31,182.74 179.31,184.68 178.07,185.92 177.09,185.92 v2(176.89,185.71)
USB20_N3_R: length 4.8
  TOP w0.112: LM1.2 162.96,188.25 v4(162.96,189) 162.96,189.61 163.47,190.12 163.47,190.15 163.85,190.53 163.88,190.53 164.24,190.89 164.24,191.41 164.15,191.5 JCDRA.40
USB20_N4: length 112.7
  TOP w0.089: v2(288.52,47.08) 288.4,47.2 287.94,47.2 UH1.M10
  TOP w0.112: UE1.32 359.32,29.32 359.44,29.2 359.44,28.7 v2(359.25,28.51)
  IN1 w0.084: v2(288.52,47.08) 288.48,46.68 288.55,46.59 288.6,46.55 288.6,45.43 288.8,45.23 288.8,44.61 289.9,43.51 290.35,43.51 290.44,43.42 291.06,43.42 292.98,45.34 293.8,45.34 293.8,45.34 293.87,45.34 295.35,45.34 295.67,45.66 300.46,45.66 301.89,44.22 301.89,39.18 302.41,38.65 302.41,34.41 302.79,34.03 302.79,30.59 303.04,30.35 303.04,29.76 303.26,29.54 303.26,26.21 304.55,24.92 304.55,24.45 305.28,23.72 305.28,21.41 311,15.69 323.24,15.69 324.9,14.03 328.58,14.03 329.56,13.04 333.16,13.04 336.05,15.94 338.34,15.94 339.1,16.7 343.58,16.7 345.99,19.1 348.58,19.1 349.74,17.94 353.03,17.94 357.31,22.22 357.31,27.12 358.26,28.07 359.37,28.07 359.46,28.16 359.46,28.3 v2(359.25,28.51)

# Allegro board Alienware Area-51M LA-G881P.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+3VALW_TBT on IN1: 14.5,53.46 14.5,43.3 15.87,41.93 21.54,41.93 22.61,43 22.61,44.93 22.28,45.26 18.82,45.26 17.5,46.58 17.5,52.55 16.41,53.64 14.68,53.64
+3VALW_TBT on IN2: outline of 226 points within 21.31,38.38 41.38,47.95
+3VALW_TBT_S5 on TOP (solid shape): 43.91,38.44 43.91,38.12 46.7,35.33 46.7,35.08 45.81,34.19 45.81,33.74 44.92,32.85 44.92,32.54 44.54,32.54 44.54,35.39 44.23,35.71 43.02,35.71 42.76,35.96 42.76,38.38 42.96,38.57 43.78,38.57
+3VALW_TBT_S5 on TOP: 45.97,13.15 45.81,13 45.81,12.27 45.94,12.14 47.08,12.14 47.41,12.47 48.76,12.47 48.84,12.55 48.84,12.64 49.67,13.47 51.23,13.47 51.28,13.52 51.28,13.87 51.23,13.91 49.09,13.91 48.33,13.15
+3VALW_TBT_S5 on TOP: 12.49,51.07 12.49,52.45 12.72,52.67 15.07,52.67 15.23,52.51 15.23,50.33 15.23,49.97 15.04,49.78 13.78,49.78
+3VALW_TBT_S5 on TOP: 49,32.56 49.07,32.48 50.01,32.48 50.04,32.51 50.04,33.9 49.88,34.06 49.24,34.06 49,33.81
+3VALW_TBT_S5 on TOP: 56.03,24.08 56.83,24.08 57.01,24.26 57.01,26.74 56.31,27.44 55.49,27.44 55.03,26.99 55.03,26.11 55.77,25.37 55.77,24.34
+3VALW_TBT_S5 on BOTTOM: 44.98,31.61 45.91,31.61 46.3,31.22 46.3,29.81 46.62,29.49 46.62,28.46 46.5,28.34 45.8,28.34 45.58,28.56 45.58,29.22 45.48,29.32 44.37,29.32 44.28,29.41 43.77,29.41 43.73,29.45 43.73,30.05 43.82,30.14 44.38,30.14 44.49,30.25 44.49,31.12
+3VALW_TBT_S5 on BOTTOM: 14.07,53.01 12.72,53.01 12.51,52.8 12.51,51.71 12.79,51.43 13.94,51.43 14.15,51.64 14.15,52.93
+3VALW_TBT_S5 on IN1: 11.91,50.85 11.91,38.45 12.22,38.15 14.1,38.15 14.4,38.45 14.4,52.78 14.02,53.16 12.77,53.16 12.48,52.87 12.48,51.41
+3VALW_TBT_S5 on IN2: 43.92,10.37 43.4,10.89 42.21,10.89 40.33,12.77 40.33,27.94 31.88,36.4 12.5,36.4 11.84,37.06 11.84,39.39 12.57,40.13 36.14,40.13 36.14,40.08 38.48,37.74 42.13,37.74 43.27,38.89 46.31,38.89 47.46,37.74 47.46,37.73 51.49,33.7 51.49,30.9 51.65,31.07 53.88,31.07 56.59,28.36 56.59,25.44 56.38,25.23 55.98,25.23 55.66,25.55 54.55,25.55 54.26,25.26 54.26,24.03 51.49,21.25 51.49,17.18 50.94,16.63 48.96,16.63 48.51,16.18 48.51,14.5 50.31,12.69 50.31,11.2 49.49,10.37
+3VALWP on TOP (solid shape): 324.92,52.68 324.92,50.67 326.06,49.53 333.73,49.53 334.48,50.27 335.89,50.27 336.06,50.1 336.06,41.58 335.97,41.48 335.07,41.48 334.32,42.24 334.29,42.26 332.41,44.14 324.48,44.14 319.79,48.84 319.79,53.01 320.04,53.26 324.33,53.26
+3VLP on TOP (solid shape): 332.51,38.78 332.51,38.33 332.89,37.95 332.89,37.73 332.8,37.63 331.81,37.63 331.22,38.22 330.17,38.22 330.12,38.28 330.12,38.38 330.2,38.45 331.55,38.45 331.91,38.82 332.47,38.82
+3VLP on TOP: 13.64,33.88 13.64,32.43 13.79,32.28 16.08,32.28 16.2,32.41 16.2,33.45 15.6,34.06 13.82,34.06
+3VS on TOP (solid shape): 204.05,98.07 204.05,95.02 203.73,94.7 201.76,94.7 201.38,95.08 201.38,97.56 202.15,98.32 203.8,98.32
+3VS on TOP (solid shape): 305.55,42.24 305.55,39.64 304.75,38.84 304.39,38.76 304.3,38.4 303.74,37.83 303.74,36.34 303.56,36.17 302.42,36.17 301.48,37.1 301.48,42.59 301.76,42.87 304.91,42.87
+3VS on TOP (solid shape): 261.36,51.77 261.36,51.34 261.3,51.2 261.31,51.04 261.31,50.85 261.42,50.69 261.42,50.63 261.99,50.06 263.55,50.06 263.78,49.83 263.78,48.91 264.15,48.54 264.15,46.95 263.96,46.76 263.2,46.76 263.13,46.82 263.13,47.71 262.56,48.28 261.55,48.28 260.28,49.55 260.28,51.84 260.4,51.96 261.17,51.96
+3VS on BOTTOM (solid shape): 375.35,48.33 375.35,47.82 376.17,47 376.17,46.51 376.08,46.42 375.48,46.42 375.19,46.13 374.59,46.13 374.5,46.22 374.5,48.37 374.56,48.43 375.25,48.43
+3VS on IN1 (solid shape): 352.06,48.05 352.06,45.8 351.86,45.6 349.83,45.6 349.43,46 349.43,48 349.59,48.16 351.95,48.16
+3VS on IN1 (solid shape): outline of 97 points within 370.75,44.91 375.34,48
+3VS on IN2 (solid shape): 203.48,97.43 203.48,95.97 203.42,95.91 199.03,95.91 198.91,96.04 198.91,97.43 199.1,97.62 203.29,97.62
+3VS on IN3 (solid shape): outline of 171 points within 254.1,93.01 270.3,100.37
+3VS on IN4 (solid shape): 222.02,22.48 222.02,20.18 221.96,20.12 220.66,20.12 220.42,20.36 220.42,22.46 220.5,22.53 221.96,22.53
+3VS on IN4 (solid shape): 344.01,26.5 344.01,24.92 343.25,24.15 341.41,24.15 341.15,24.41 341.15,26.82 341.53,27.2 343.31,27.2
+3VS on IN4 (solid shape): 304.95,30.12 304.95,29.52 305.4,29.08 305.4,28.85 305.71,28.53 306.86,28.53 306.92,28.47 306.92,27.58 306.79,27.46 305.21,27.46 303.87,28.79 303.87,30.06 304,30.19 304.89,30.19
+3VS on IN4 (solid shape): 319.37,19.9 319.37,19.76 318.64,19.03 318.64,18.66 318.43,18.45 314.57,18.45 314.43,18.6 314.43,19.15 315.6,19.15 315.6,19.1 315.61,19.05 315.63,19 315.66,18.95 315.69,18.91 315.73,18.88 315.78,18.85 315.82,18.82 315.88,18.81 315.93,18.8 315.98,18.8 316.03,18.81 316.09,18.82 316.13,18.85 316.18,18.88 316.22,18.91 316.25,18.95 316.28,19 316.3,19.05 316.31,19.1 316.31,19.15 316.31,19.21 316.3,19.26 316.28,19.31 316.25,19.36 316.22,19.4 316.18,19.43 316.13,19.46 316.09,19.49 316.03,19.5 315.98,19.51 315.93,19.51 315.88,19.5 315.82,19.49 315.78,19.46 315.73,19.43 315.69,19.4 315.66,19.36 315.63,19.31 315.61,19.26 315.6,19.21 315.6,19.15 314.43,19.15 314.43,20.04 314.6,20.22 319.05,20.22
+3VS on TOP: 343.12,25.19 343.12,24.64 343.11,24.64 342.87,24.64 342.87,24.64 342.87,25.19 342.87,25.19 342.32,25.19 342.32,25.19 342.32,24.64 342.32,24.64 342.07,24.64 342.07,24.64 342.07,25.19 342.07,25.19 341.6,25.19 340.88,25.91 340.88,26.46 339.69,27.65 339.5,27.65 339.44,27.71 339.44,27.84 339.32,27.95 338.22,27.95 336.88,29.28 334.29,29.28 334.01,29.56 334.01,31.37 334.24,31.6 340.54,31.6 344.58,27.55 344.58,26.39 344.72,26.25 345.47,26.25 345.72,25.99 345.72,25.04 345.66,24.98 344.58,24.98 344.37,25.19
+3VS on TOP: 255.17,15.14 255.55,15.14 255.8,15.39 255.8,15.52 255.99,15.71 256.5,15.71 256.63,15.83 256.63,17.61 256.44,17.8 255.04,17.8 254.85,17.61 254.85,15.45
+3VS on TOP: 300.82,71.33 300.51,71.33 298.22,69.05 298.22,68.48 299.81,66.89 299.81,64.6 299.68,64.48 298.92,64.48 298.86,64.41 298.86,58.51 298.92,58.44 300.51,58.44 301.33,57.62 301.33,56.28 302.35,55.27 302.6,55.27 303.75,54.13 308,54.13 308.76,54.89 310.46,54.89 312.25,56.68 316.59,56.68 317.2,57.29 317.2,58.62 315.89,59.92 315.47,59.92 315.11,60.28 314.79,60.28 314.2,60.88 312.91,60.88 312.89,60.9 311.34,60.9 311.11,61.13 311.11,62.95 302.22,71.84 301.33,71.84
+3VS on TOP: 172.07,28.64 172.07,23.34 172.51,22.89 174.71,22.89 174.86,23.05 174.86,28.79 174.73,28.93 172.36,28.93
+3VS on TOP: 178.04,134.77 180.05,134.77 180.36,135.09 181.85,135.09 181.9,135.03 181.9,134.25 181.85,134.2 180.53,134.2 180.04,133.71 180.04,130.86 180,130.82 179.34,130.82 179.26,130.9 179.26,131.73 179.1,131.89 178.56,131.89 178.44,132.02 178.44,132.89 177.89,133.44 177.89,134.62
+3VS on TOP: 270,98.24 275.46,98.24 276.03,97.67 276.03,93.16 275.78,92.91 269.36,92.91 268.48,93.8 268.48,96.72
+3VS on TOP: 311.2,17.02 318.01,17.02 318.57,17.58 318.57,19.26 318.34,19.49 317.21,19.49 316.88,19.17 316.88,18.72 316.01,17.84 311.23,17.84 311.13,17.74 311.13,17.09
+3VS on TOP: 223.58,16.05 225.2,16.05 225.39,16.24 225.39,17.1 221.83,20.67 221.19,20.67 220.45,19.93 220.45,19.18
+3VS on TOP: 346.6,48.19 353.16,48.19 353.73,47.62 353.73,46.28 353.52,46.07 352.78,46.07 352.31,45.6 350.68,45.6 349.86,44.78 346.21,44.78 346.06,44.93 346.06,46.01 346.06,46.01 346.06,47.65
+3VS on TOP: 286.12,72.62 287.06,73.56 287.24,73.56 287.43,73.75 287.43,77.56 291.93,82.07 293.01,82.07 294.73,80.35 294.73,79.39 287.44,72.11 287.32,71.99 287.32,70.98 286.73,70.4 286.73,69.19 286.59,69.05 284.98,69.05 284.13,69.9 284.13,69.91 283.79,70.25 283.79,71.51 283.86,71.59 284.66,71.59 284.93,71.32 285.36,71.32 285.42,71.26 285.42,70.79 285.45,70.76 286.03,70.76 286.12,70.85
+3VS on TOP: 124.84,114.33 151.34,114.33 152.49,113.18 157.92,113.18 159.41,114.67 159.41,118.53 158.91,119.04 157.09,119.04 156.25,118.21 156.25,116.12 155.54,115.4 154.21,115.4 153.57,116.04 153.57,117.31 152.98,117.9 124.51,117.9 124.01,117.4 124.01,115.16
+3VS on TOP: 115.09,12.09 113.05,12.09 112.8,11.83 112.8,11.2 112.99,11.01 115.09,11.01 115.15,11.07 115.15,12.02
+3VS on TOP: 28.8,22.4 28.8,21.66 28.57,21.44 26.84,21.44 26.55,21.15 26.55,19.79 26.68,19.66 27.2,19.66 27.6,20.06 28.05,20.06 28.28,20.29 28.28,20.85 28.41,20.98 28.8,20.98 29.06,21.23 29.06,22.38 28.98,22.45 28.85,22.45
+3VS on BOTTOM: 171.42,130.26 173.16,130.26 173.35,130.08 173.35,129.62 173.18,129.45 167.26,129.45 165.44,131.27 165.44,132.93 165.62,133.12 167.66,133.12 169.44,131.34 170.34,131.34 171.38,130.3
+3VS on BOTTOM: 170.46,145.29 173.14,145.29 173.31,145.12 173.31,144.59 173.19,144.47 170.56,144.47 170.31,144.72 170.31,145.14
+3VS on BOTTOM: 219.93,20.53 219.93,16.91 220.24,16.6 220.75,16.6 221.07,16.91 221.07,17.51 221.39,17.83 223.8,17.83 224.3,18.33 225.28,18.33 225.38,18.43 225.38,18.64 225.34,18.67 222.28,18.67 221.89,19.07 221.89,20.6 221.7,20.79 220.18,20.79
+3VS on BOTTOM: 113.57,6.11 113.51,6.17 113.51,7.36 113.62,7.47 117.3,7.47 117.67,7.11 118.16,7.11 120.06,5.22 122.32,5.22 122.6,5.49 122.6,7.96 122.66,8.03 124.13,8.03 124.23,7.92 124.23,3.71 123.63,3.1 120.34,3.1 117.34,6.11
+3VS on BOTTOM: 58.39,19.12 58.39,16.61 56.26,14.48 56.26,9.45 56.73,8.98 62.96,8.98 63.53,9.55 63.53,11.86 61.77,13.61 61.77,18.73 60.74,19.77 59.04,19.77
+3VS on BOTTOM: 283.84,71.11 283.8,71.15 283.8,72.15 283.81,72.16 283.55,72.41 283.55,73.18 283.23,73.49 282.35,73.49 282.28,73.56 282.28,74.57 283.62,75.91 284.25,75.91 284.95,75.21 286.6,75.21 287.14,75.74 287.14,76.48 286.45,77.17 284.2,77.17 283.55,77.81 282.73,77.81 282.54,77.62 282.54,77.49 282.41,77.37 282.03,77.37 281.9,77.49 281.9,78.9 282.06,79.06 282.59,79.06 282.71,79.17 282.71,79.95 282.95,80.2 289.56,80.2 289.87,79.88 289.87,71.5 289.49,71.11
+3VS on BOTTOM: 86.23,17.61 87.59,17.61 87.65,17.55 87.65,16.22 87.53,16.09 86.16,16.09 85.98,16.27 85.98,17.36
+3VS on BOTTOM: 111.96,10.11 112.05,10.02 114.52,10.02 114.88,10.39 114.88,11.53 114.45,11.96 112.29,11.96 111.96,11.63
+3VS on BOTTOM: 161.72,181.3 161.32,181.7 161.32,183.99 161.7,184.36 162.7,184.36 162.88,184.18 162.88,182.84 162.96,182.77 163.42,182.77 163.5,182.69 163.5,182.2 163.61,182.09 164.47,182.09 164.68,181.88 164.68,181.42 164.56,181.3
+3VS on IN2: 167.41,170.42 164.7,173.13 164.7,174.12 164.94,174.37 167.98,174.37 171.7,178.08 176.15,178.08 177.82,179.75 177.82,185.22 178.2,185.6 179.94,185.6 180.58,184.97 180.58,180.31 180.15,179.88 179.6,179.33 179.6,177.65 177.09,175.15 173.78,175.15 169.06,170.42 ; 1 cut-out
+3VS on IN2: 163.85,181.84 163.85,181.48 164.46,180.87 164.46,180.66 164.42,180.65 164.13,180.3 164.42,179.95 164.46,179.94 164.46,177.37 159.75,172.66 156.56,172.66 155.68,173.54 155.68,179.67 158.72,182.7 158.79,182.73 158.86,182.7 159.2,182.63 159.44,182.88 159.45,182.92 162.78,182.92
+3VS on IN2: 210.78,97.5 211.06,97.77 227.96,97.77 228.39,97.34 228.39,96.02 228.26,95.89 225.29,95.89 225.19,95.96 225.22,96.07 224.99,96.7 224.76,96.07 224.79,95.96 224.7,95.89 222,95.89 221.33,95.22 211.07,95.22 210.78,95.5
+3VS on IN2: 171.22,126.84 170.63,127.43 170.63,130.26 173.38,133.02 173.38,138.71 172.56,139.53 171.33,139.53 162.46,148.4 162.46,160.67 164.18,162.39 164.18,164.59 164.6,165.01 164.6,167.58 163.34,168.85 163.34,171.75 162.81,172.28 162.81,172.88 163.36,173.43 164.16,173.43 168.84,168.75 168.84,166.3 173.07,162.08 173.07,160.81 174.26,159.62 174.26,153.48 171.49,150.71 171.49,149.22 172.93,147.77 173.89,147.77 180.68,140.98 180.68,129.44 178.08,126.84 ; 1 cut-out
+3VS on IN2: 164.67,129.75 164.67,132.8 165.05,133.18 165.68,133.18 166,132.87 166,129.75 165.87,129.63 164.79,129.63
+3VS on IN2: 338.1,45.3 331.43,45.3 327.43,49.3 321.33,49.3 315.68,54.95 315.68,59.78 315.9,59.99 331.57,53.89 348.39,53.7 348.39,27.14 345.91,24.66 342.1,24.66 341.18,25.58 341.18,42.22
+3VS on IN3: 162.43,173.58 162.43,170.37 162.63,170.17 168.98,170.17 169.23,170.43 169.23,173.56 168.76,174.03 162.89,174.03
+3VS on IN4: 302.61,35.07 302.74,34.94 303.67,34.94 303.81,35.07 303.81,37.52 303.8,37.53 303.8,38.5 303.68,38.62 303.17,38.62 302.61,38.05
+3VS on IN4: 156.87,118.7 156.87,117.31 157.06,117.12 158.46,117.12 158.9,117.56 158.9,118.83 158.46,119.28 157.44,119.28
+3VS on IN4: 311.5,25.8 312,25.8 312.45,25.36 312.89,25.36 313.21,25.68 313.47,25.68 313.66,25.49 313.66,23.26 313.4,23.01 312.64,23.01 312.51,23.14 312.51,23.77 311.18,25.11 311.18,25.49
+3VS on IN4: 165.06,130.83 165.06,133.63 165.32,133.88 166.52,133.88 167.03,133.37 167.03,130.83 166.78,130.58 165.32,130.58
+3VS on IN4: 213.77,96.87 213.77,73.68 216.31,71.14 254.05,71.14 258.83,75.92 258.83,95.06 256.36,97.52 214.41,97.52 ; 1 cut-out
+3VS on IN4: 284.16,75.99 275.81,75.99 275.46,76.33 273.26,76.33 272.77,75.84 272.77,72.66 274.94,70.49 279.89,70.49 284.46,75.06 284.46,75.69
+3VS on IN4: 163.67,170.54 165.29,172.16 165.29,178.16 164.45,179 163.06,179 158.49,174.43 158.49,171.06 159.01,170.54
+3VS_ACC on TOP: 278.18,79.5 278.76,79.5 278.92,79.35 279.6,79.35 279.68,79.42 279.68,81 279.53,81.15 278.92,81.15 278.46,80.69 278.26,80.69 278.1,80.54 278.1,79.58
+3VSP_SSD on TOP: 359.35,14.47 359.46,14.58 364.31,14.58 364.51,14.39 364.51,12.48 364.5,12.48 364.5,11.44 364.36,11.3 363.37,11.3 362.46,12.22 359.18,12.22 359.03,12.37 359.03,13.05 359.35,13.38
+5V_HDD on BOTTOM (solid shape): 255,7.93 255,6.66 254.87,6.54 254.36,6.54 254.19,6.37 254.19,4 253.97,3.79 251.4,3.79 251.25,3.93 251.25,7.81 251.48,8.04 254.88,8.04
+5V_HDD on TOP: 254.37,11.89 255.25,11.89 255.32,11.81 255.32,7.62 254.97,7.26 254.97,6.72 254.88,6.63 254.31,6.63 254.16,6.79 251.82,6.79 251.65,6.96 251.65,9.81 251.75,9.92 253.99,9.92 254.27,10.19 254.27,11.78
+5V_TOBII on BOTTOM (solid shape): 300.85,43.38 300.85,42.44 300.35,41.93 298.97,41.93 298.97,42.89 298.98,42.89 299.11,43.01 299.68,43.01 300.19,43.52 300.71,43.52
+5V_USB_PWR1 on TOP: 34.31,14.91 34.31,15.06 34.21,15.16 32.97,15.16 32.89,15.24 31.7,15.24 31.42,14.96 31.42,14.3 30.33,13.21 30.33,11.48 30.35,11.45 30.35,9.07 30.45,9.07 30.68,8.84 32.89,8.84 33.83,9.78 33.83,14.43
+5V_USB_PWR1 on TOP: 19.1,19.3 19.1,14.7 19.43,14.37 21.97,14.37 22.78,15.19 22.78,19.23 22.4,19.61 19.41,19.61
+5V_USB_PWR1 on BOTTOM: 27.34,21.06 26.38,20.11 26.38,19.59 26.14,19.35 23.19,19.35 23.1,19.44 23.1,19.77 22.95,19.91 19.91,19.91 19.18,19.17 19.18,16.97 19.3,16.84 22.87,16.84 23.62,16.09 29.12,16.09 30.86,17.83 30.86,21.96 30.67,22.15 29.06,22.15 28.81,21.91 28.81,21.48 28.4,21.06
+5V_USB_PWR1 on IN4: 21.89,17.45 22.48,18.03 22.48,23.72 19.25,26.95 16.96,26.95 16.59,26.57 16.59,25.5 17.91,24.18 17.92,24.18 18.47,23.62 18.47,17.95 18.98,17.45
+5V_USB_PWR2 on TOP (solid shape): 383.3,39.05 383.3,38.47 382.16,37.33 380.52,37.33 380.3,37.11 377.65,37.11 377.63,37.13 377.6,37.16 377.55,37.19 377.5,37.22 377.45,37.23 377.4,37.24 377.35,37.24 377.29,37.23 377.24,37.22 377.2,37.19 377.15,37.16 377.11,37.13 377.1,37.11 376.01,37.11 375.84,37.28 375.84,37.92 380.52,37.92 380.52,37.87 380.53,37.81 380.55,37.77 380.58,37.72 380.61,37.68 380.65,37.64 380.69,37.61 380.74,37.59 380.79,37.57 380.85,37.56 380.9,37.56 380.95,37.57 381,37.59 381.05,37.61 381.09,37.64 381.13,37.68 381.17,37.72 381.19,37.77 381.21,37.81 381.23,37.87 381.23,37.92 381.23,37.97 381.21,38.03 381.19,38.08 381.17,38.12 381.13,38.16 381.09,38.2 381.05,38.23 381,38.25 380.95,38.27 380.9,38.28 380.85,38.28 380.79,38.27 380.74,38.25 380.69,38.23 380.65,38.2 380.61,38.16 380.58,38.12 380.55,38.08 380.53,38.03 380.52,37.97 380.52,37.92 375.84,37.92 375.84,39.37 375.94,39.46 376.66,39.46 376.73,39.4 380.94,39.4 381.2,39.66 382.69,39.66
+5V_USB_PWR2 on TOP (solid shape): 380.02,19.62 380.68,19.62 380.7,19.6 381.61,19.6 381.63,19.62 382.79,19.62 383.3,19.11 383.3,17.8 382.78,17.28 381.45,17.28 381.38,17.31 381.35,17.39 381.11,17.72 380.71,17.61 380.65,17.58 380.59,17.58 380.38,17.62 380.19,17.54 380.13,17.52 380.06,17.54 380,17.59 379.92,17.61 379.86,17.66 379.85,17.73 379.31,18.11 379.41,17.46 379.47,17.41 379.49,17.34 379.48,17.28 378.57,17.28 378.49,17.37 378.49,20.03 378.66,20.2 379.43,20.2
+5V_USB_PWR2 on IN1 (solid shape): outline of 134 points within 376.94,18.35 383.31,39.75
+5VALW on TOP (solid shape): 265.85,8.46 265.9,8.46 265.9,8.46 267.82,8.46 267.99,8.28 267.99,7.82 267.87,7.69 266.09,7.69 265.7,8.08 265.7,8.29 265.33,8.66 264.63,8.66 264.57,8.72 264.57,8.91 264.63,8.98 265.33,8.98
+5VALW on TOP (solid shape): outline of 178 points within 333.42,15.71 339.93,29.04
+5VALW on TOP: 375.24,39.38 375.32,39.29 375.32,37.82 375.19,37.68 373.47,37.68 372.9,37.11 371.95,37.11 371.69,37.36 371.69,38.57 372.51,39.38
+5VALW on TOP: 114.56,120.64 114.32,120.64 114.1,120.41 114.1,119.84 113.99,119.73 113.99,118.97 114.04,118.91 114.62,118.91 114.7,119 114.7,120.5
+5VALW on TOP: 36.47,15.01 36.47,14.22 36.8,13.89 36.83,13.89 37.41,13.31 38.51,13.31 38.79,13.59 38.79,14.93 38.58,15.14 36.6,15.14
+5VALW on BOTTOM: 178.14,22.25 178.97,22.25 179.16,22.06 179.16,20.47 179.09,20.41 178.08,20.41 178.02,20.47 178.02,22.12
+5VALW on BOTTOM: 242.43,11.51 242.43,11.04 242.39,11 239.87,11 239.45,11.43 239.45,12.04 239.55,12.14 241.54,12.14 242.21,12.8 242.21,13.03 242.21,13.04 242.43,13.04 242.43,12.57 242.44,12.56 242.97,12.56 242.98,12.57 242.98,12.31 242.43,12.31 242.42,12.31 242.42,11.77 242.43,11.76 242.97,11.76 242.97,11.76 242.97,11.52 242.97,11.51 242.43,11.51
+5VALW on BOTTOM: 46.61,45.63 46.63,45.62 46.65,45.61 47.33,44.93 47.6,44.93 47.7,45.03 49.43,45.03 49.79,44.67 49.79,44.29 49.81,44.27 49.81,42.98 53.11,39.67 53.11,31.86 56.31,28.66 56.31,24.82 55.52,24.03 50.04,24.03 49.58,24.48 49.58,36.17 48.08,37.67 46.58,37.67 46.51,37.74 46.51,43.39 46.31,43.59 46.31,43.83 46.43,44.17 46.17,44.41 46.14,44.45 46.14,45.55 46.21,45.63
+5VALW on IN1: 37.67,30.43 37.67,28.8 37.95,28.52 40.13,28.52 40.49,28.88 45.44,28.88 45.69,28.62 46.76,28.62 46.99,28.85 49.94,28.85 50.77,28.03 50.77,23.14 51.27,22.63 53.75,22.63 54.13,23.01 54.84,23.01 55.59,23.76 55.59,26.57 51.15,31.01 38.25,31.01
+5VALW on IN2: 327.18,29.04 336.33,29.04 337.02,28.35 337.02,20.73 338.29,19.45 338.29,17.61 337.66,16.98 335.06,16.98 333.65,18.38 329.2,13.93 319.24,13.93 316.7,11.39 297.27,11.39 293.2,15.45 290.66,15.45 284.7,21.42 272.31,21.42 272.19,21.3 267.55,21.3 260.57,14.31 241.3,14.31 240.69,14.92 235.31,14.92 234.7,14.31 153.06,14.31 152.23,13.49 111.72,13.49 110.9,14.31 108.2,17.01 95.5,17.01 94.14,18.37 77.49,18.37 74.82,21.05 55.09,21.05 54.48,21.66 54.48,24.62 54.94,25.08 56.65,25.08 57.89,23.84 61.17,23.84 62.7,25.37 89.99,25.37 92.8,22.57 107.97,22.57 108.01,22.6 111.69,22.6 112.36,23.26 115.34,23.26 115.59,23.01 167.22,23.01 169.13,24.92 185.44,24.92 189.57,20.79 257.07,20.79 264.38,28.09 290.54,28.09 295.11,23.52 321.65,23.52
+5VALW on IN3: 339.29,23.15 337.6,24.85 334.1,24.85 333.66,25.3 333.66,28.34 334.23,28.92 340.64,28.92 341.6,27.96 342.8,27.96 343.56,28.73 343.56,38.31 343.88,38.63 344.5,38.63 345.09,39.22 345.09,41.65 348.15,44.71 351.63,44.71 355.17,48.25 355.17,52.03 357.98,54.84 367.25,54.84 369.46,52.62 369.46,48.01 373.85,43.61 373.85,37.61 373.26,37.02 370.53,37.02 370.26,37.29 370.26,38.96 366.22,43.01 362.9,43.01 359.27,39.37 350.83,39.37 348.61,37.15 348.61,29.47 347.64,28.5 347.64,27.09 346.18,25.63 346.18,23.93 345.41,23.15
+5VALW on IN4: 37.24,29.03 37.24,13.74 37.44,13.54 40.46,13.54 40.46,20.2 41.3,21.04 41.3,24.71 40.46,25.55 40.46,28.78 40.06,29.18 37.39,29.18
+5VALWP on TOP (solid shape): outline of 83 points within 320.73,19.78 333.8,31.21
+5VS on TOP (solid shape): 257.74,11.65 257.74,8.28 257.34,7.88 257.34,7.14 257.25,7.05 256.68,7.05 256.65,7.08 256.65,7.46 256.52,7.59 256.13,7.59 256.03,7.69 256.03,11.75 256.07,11.8 257.59,11.8
+5VS on TOP (solid shape): 342.24,17.97 342.24,17.43 342.24,17.43 342.79,17.43 342.79,17.43 342.79,17.98 342.79,17.98 343.04,17.98 343.04,17.98 343.04,17.43 343.05,17.43 347.05,17.43 347.22,17.26 347.22,15.54 346.92,15.24 341.73,15.24 341.48,15.49 341.48,17.4 341.51,17.43 341.99,17.43 341.99,17.43 341.99,17.98 342,17.98 342.24,17.98
+5VS on BOTTOM (solid shape): 236.29,11.8 236.29,9.34 236.22,9.27 233.91,9.27 233.77,9.4 233.77,11.84 233.89,11.96 236.14,11.96
+5VS on BOTTOM (solid shape): 173.38,147.53 173.38,146.88 173.23,146.73 172.3,146.73 172.01,147.03 170.78,147.03 170.55,147.25 170.55,147.56 170.65,147.66 173.26,147.66
+5VS on BOTTOM (solid shape): 250.85,109.11 250.85,106.5 250.16,105.8 248.91,105.8 248.42,105.32 248.42,100.34 248.11,100.02 246.65,100.02 246.47,100.2 246.47,108.62 247.37,109.53 250.44,109.53
+5VS on BOTTOM (solid shape): 370.79,50.24 370.79,48.02 370.63,47.85 369.57,47.85 369.44,47.98 369.44,49.12 369.49,49.17 369.95,49.17 370,49.22 370,49.78 369.98,49.81 369.49,49.81 369.44,49.86 369.44,50.29 369.54,50.39 370.64,50.39
+5VS on BOTTOM (solid shape): 171.16,134.14 171.16,132.99 171.53,132.62 173.25,132.62 173.31,132.56 173.31,131.96 173.26,131.91 172.31,131.91 172.24,131.98 170.34,131.98 170.11,132.2 170.11,134.24 170.33,134.45 170.84,134.45
+5VS on BOTTOM (solid shape): 239.25,109.4 239.25,108.58 239.08,108.42 238.5,108.42 238.23,108.15 238.23,107.28 238.22,107.28 238.22,100.2 238.09,100.06 236.5,100.06 236.18,100.38 236.18,105.26 235.96,105.48 233.56,105.48 233.2,105.84 233.2,108.96 233.92,109.68 238.96,109.68
+5VS on IN3 (solid shape): outline of 330 points within 165.32,125.63 180.75,144.74
+5VS on TOP: 321.09,24.15 322.23,24.15 323.12,23.26 323.12,11.45 322.99,11.33 322.99,7.26 324.64,5.61 324.64,5.1 324.45,4.91 320.51,4.91 319.12,6.31 319.12,15.85 321.02,17.76 321.02,19.26 320.58,19.71 320.58,23.65
+5VS on TOP: 87.44,22.05 87.44,21.07 87.64,20.87 92.29,20.87 92.4,20.99 92.4,23.34 92.05,23.69 87.61,23.69 87.11,23.19 87.11,22.38
+5VS on TOP: 178.87,129.51 180.72,129.51 180.8,129.44 180.8,128.95 180.52,128.67 180.52,127.02 180.36,126.87 178.97,126.87 178.61,127.23 178.61,129.26
+5VS on BOTTOM: 154.39,14.1 154.39,12.77 154.11,12.48 152.69,12.48 151.79,13.38 151.79,14.46 151.85,14.52 153.98,14.52
+5VS on BOTTOM: 198.38,107.71 198.82,108.16 198.82,110.42 198.47,110.77 190.72,110.77 190.53,110.96 189.13,110.96 189.01,110.83 189.01,108.29 189.58,107.71
+5VS on IN1: 271.67,112.31 276.76,107.21 276.76,104.8 276.06,104.1 275.11,104.1 269.21,110 269.21,111.87 269.65,112.31
+5VS on IN1: 302.54,66.76 303.18,66.76 305.46,64.48 305.46,62.63 307.31,60.79 308.89,62.38 311.88,62.38 313.02,61.24 313.02,57.62 312.45,57.05 307.31,57.05 303.27,61.08 303.27,62.67 301.21,64.73 301.21,65.43
+5VS on IN2: outline of 91 points within 55.32,1.17 377.72,57.83
+5VS on IN2: 268.44,111.66 270.22,111.66 270.67,111.21 270.67,107.91 270.43,107.67 268.35,107.67 268.13,107.89 268.13,111.34
+5VS on IN2: 189.08,112.61 188.9,112.43 188.9,110.87 189.31,110.46 190.16,110.46 190.36,110.66 190.36,112.12 189.87,112.61
+5VS on IN2: 234.41,108.04 233.93,108.51 198.45,108.51 196.9,110.07 196.82,110.07 196.49,110.39 196.49,113.06 196.7,113.26 246.93,113.26 247.55,112.64 252.82,112.64 253.07,112.4 253.07,109.94 253.07,109.94 253.07,108.29 252.82,108.04
+5VS on IN2: 180.11,128.42 180.11,126.96 180.94,126.13 180.94,120.42 181.57,119.78 184.71,119.78 185.38,120.46 185.38,125.31 182.4,128.29 181.32,128.29 180.87,128.74 180.43,128.74
+5VS on IN4: 311.43,62.13 311.75,62.13 312.89,60.98 312.89,57.62 312.64,57.36 311.37,57.36 310.93,57.81 310.93,61.62
+5VS on IN4: 320.07,26.25 320.13,26.25 322.36,24.03 322.36,23.14 322.1,22.88 320.51,22.88 319.12,24.28 319.12,25.3
+5VS_TP_LED on BOTTOM: 107.77,14.22 108,14.45 108,15.57 107.92,15.64 105.87,15.64 105.79,15.56 105.79,14.48 106.05,14.22
+12V_FAN on BOTTOM (solid shape): 375.62,53.21 375.62,51.81 375.43,51.61 375.24,51.61 373.77,50.14 372.94,50.14 372.47,49.67 372.47,48.47 372.37,48.37 371.02,48.37 370.92,48.47 370.92,50.17 371.7,50.95 371.7,52.45 371.8,52.55 373.43,52.55 374.3,53.42 375.41,53.42
+12V_FAN on TOP: 240.16,1.17 239.48,2.59 238.02,3.17 236.24,4.94 236.24,5.56 237.18,6.49 237.97,6.49 241.83,2.64 241.83,1.62 241.38,1.17
+12V_FAN on TOP: 95.73,17.57 95.73,16.41 95.94,16.2 96.95,16.2 97.08,16.33 97.08,17.45 96.82,17.7 95.86,17.7
+12V_FAN on BOTTOM: 88.42,58.37 87.53,58.37 85.93,56.77 85.93,54.56 86.36,54.13 88.26,54.13 88.52,54.38 88.52,55.14 88.44,55.22 88.44,55.83 89.1,56.49 89.1,57.68
+12V_FAN on BOTTOM: 95.12,18.18 95.12,16.91 95.38,16.66 96.85,16.66 97.08,16.89 97.08,17.88 96.65,18.31 95.25,18.31
+12V_FAN on IN1: 371.36,53.27 375.53,53.27 375.63,53.17 375.63,51.61 375.51,51.49 371.41,51.49 371.23,51.66 371.23,53.15
+12V_FAN on IN1: 240.16,1.17 239.89,2.06 239.27,2.76 239.27,3.52 239.4,3.66 241.88,3.66 242.37,3.17 242.37,1.22 242.32,1.17
+12V_LX on TOP (solid shape): 364.68,53.1 364.68,48.22 364.47,48.02 360.43,48.02 360.41,48.03 360.46,48.33 360.25,48.56 360.25,53.08 360.41,53.24 364.54,53.24
+12V_LX on BOTTOM (solid shape): 363.52,54.22 363.52,48.37 362.99,47.84 360.86,47.84 360.72,47.98 360.72,48.45 360.56,48.61 359.96,48.61 359.94,48.59 358.95,48.59 358.7,48.84 358.7,50.04 358.79,50.13 360.35,50.13 360.6,50.39 360.6,54.32 360.95,54.67 363.07,54.67
+12V_SNUB on TOP (solid shape): 359.41,50.87 359.41,48.22 359.32,48.12 358.51,48.12 358.41,48.22 358.41,48.87 358.27,49.01 357.47,49.01 357.32,49.16 357.32,50.94 357.42,51.04 359.24,51.04
+12V_SS on BOTTOM (solid shape): 357.47,50.07 357.47,49.21 357.36,49.09 356.02,49.09 355.93,49.19 355.93,50.01 356.04,50.12 357.42,50.12
+12V_VIN on BOTTOM (solid shape): 358.5,50.02 358.5,48.66 358.8,48.36 358.8,47.75 358.98,47.57 358.98,47.29 358.84,47.15 358.25,47.15 357.68,47.72 357.68,50.02 357.75,50.08 358.43,50.08
+12V_VIN on BOTTOM (solid shape): 367.31,50.65 369.16,50.65 369.26,50.54 369.26,49.02 369.14,48.89 368.6,48.89 368.4,49.1 367.19,49.1 367.11,49.01 367.11,47 366.69,46.58 364.7,46.58 364.49,46.79 364.49,50.62 364.83,50.96 366.99,50.96
+12VP on TOP (solid shape): 368.1,52.55 369.65,52.55 369.98,52.22 369.98,49.76 369.72,49.5 366.27,49.5 365.96,49.81 365.96,52.68 366.12,52.83 367.82,52.83
+12VP on BOTTOM (solid shape): 367.03,54.43 367.03,53.29 367.77,52.55 371.35,52.55 371.45,52.45 371.45,52.07 371.42,52.04 370.92,52.04 370.92,51.51 371.37,51.51 371.45,51.43 371.45,50.9 371.35,50.8 367.39,50.8 366.9,51.29 364.65,51.29 364.45,51.5 364.45,54.63 364.48,54.66 366.8,54.66
+19V_ADPIN_1 on TOP: 124.93,166.2 127.41,166.2 127.6,166.01 127.6,164.09 127.45,163.95 127.45,163.53 127.6,163.39 127.6,155.51 126.97,154.89 124.92,154.89 124.41,154.38 122.45,154.38 122.45,154.37 121.81,154.37 121.47,154.03 121.47,153.65 121.34,153.53 120.09,153.53 119.85,153.76 119.85,156.31 119.02,157.14 119.02,160.49 119.15,160.61 123.98,160.61 124.48,161.12 124.48,165.76
+19V_ADPIN_1 on BOTTOM: 119.72,166.01 126.77,166.01 127.15,165.63 127.15,156.26 127.56,155.85 127.56,155.32 127.16,154.92 127.16,154.21 127.02,154.07 125.57,154.07 125.29,154.35 120.04,154.35 118.52,155.88 118.52,162.78 118.83,163.1 119.4,163.1 119.59,163.29 119.59,165.89
+19V_ADPIN_2 on TOP: 141.31,163.22 149.5,163.22 149.88,162.84 149.88,156.67 150.95,155.6 153.6,155.6 154.1,155.09 154.1,152.97 152.81,151.68 152.37,151.68 152.25,151.81 152.25,152.45 151.03,153.67 151.03,154.78 150.86,154.95 149.99,154.95 149.88,154.84 149.88,154.26 149.69,154.07 139.66,154.07 139.53,154.2 139.53,154.71 139.92,155.09 140.42,155.09 141.12,155.79 141.12,163.03
+19V_VIN_1 on TOP: 119.34,161.06 119.15,161.25 119.15,162.39 118.01,163.54 116.1,163.54 115.72,163.92 115.72,167.28 115.98,167.54 116.48,167.54 116.74,167.79 116.74,168.55 116.86,168.68 118.7,168.68 118.88,168.5 118.88,168.26 119.09,168.04 119.64,167.12 120.56,166.57 120.61,166.52 120.76,166.52 120.96,166.49 121.17,166.48 123.38,166.48 124.17,165.69 124.17,161.25 123.98,161.06
+19V_VIN_2 on TOP: 149.19,153.95 149.63,153.5 149.63,151.39 149.48,151.24 148.97,151.24 148.76,151.04 148.76,149.46 148.68,149.38 144.75,149.38 144.16,149.96 142.82,149.96 142.14,150.65 139.98,150.65 139.79,150.45 139.79,150.14 139.47,149.82 137.31,149.82 137.06,150.07 137.06,152.87 138.14,153.95
+19V_VIN_2 on BOTTOM: 137.92,152.74 140.74,152.74 141.19,152.3 141.19,148.49 140.99,148.3 138.09,148.3 137.74,148.65 137.74,152.56
+19V_VIN_2 on IN2, IN3: 138.25,154.51 149.07,154.51 149.66,153.92 149.66,150.06 149.05,149.45 140.69,149.45 140.31,149.83 137.82,149.83 137.41,150.24 137.41,153.67
+AVDD09 on BOTTOM (solid shape): 189.96,171.55 189.96,171.16 189.84,171.04 188.61,171.04 188.55,171.09 188.55,171.99 188.62,172.05 189.46,172.05
+AVDD09 on BOTTOM (solid shape): 190.55,164.99 190.55,163.52 190.49,163.46 189.39,163.46 189.3,163.55 189.3,164.96 189.47,165.13 190.42,165.13
+AVDD09 on BOTTOM (solid shape): 189.76,167.98 190.14,167.98 190.26,167.87 190.26,167.27 190.14,167.15 189.48,167.15 189.25,167.38 187.87,167.38 187.83,167.42 187.83,168.31 187.88,168.36 189.39,168.36
+AVDD09 on TOP: 184.84,164.75 184.74,164.75 184.66,164.68 184.66,163.7 184.18,163.22 184.18,162.89 184.32,162.75 184.51,162.75 184.68,162.92 184.68,163.06 184.99,163.36 184.99,163.72 184.92,163.79 184.92,164.67
+AVDD09 on BOTTOM: 187.74,176.62 189.77,176.62 189.83,176.55 189.83,175.92 189.45,175.54 189.45,174.84 189.26,174.65 188.94,174.65 188.81,174.78 188.81,175.47 188.43,175.85 187.74,175.85 187.61,175.98 187.61,176.49
+AVDD09 on BOTTOM: 184.26,165.52 183.33,165.52 183.28,165.47 183.28,163.78 184.31,162.75 184.5,162.75 184.99,163.23 184.99,163.9 184.29,164.59 184.29,165.49
+AVDD09 on IN1: 188.94,175.66 189.58,175.66 189.77,175.47 189.77,173.82 189.58,173.63 189.58,171.92 189.88,171.61 189.88,171.2 189.2,170.52 189.2,168.62 190.21,167.6 190.21,167.28 190.15,167.22 190.02,167.22 189.45,166.65 189.45,165.57 189.89,165.12 189.89,164.59 189.6,164.3 186.13,164.3 184.54,162.71 184.25,162.71 183.61,163.34 183.61,164.36 184.5,165.24 185.17,165.24 188.18,168.25 188.18,174.39 188.75,174.97 188.75,175.47
+AVDD09 on IN2: 188.75,172.17 189.89,172.17 190.15,171.92 190.15,170.97 189.89,170.71 189.45,170.71 189.32,170.58 189.32,169 190.21,168.11 190.21,167.16 189.77,166.71 189.77,166.33 189.83,166.27 189.83,164.74 189.7,164.62 189.26,164.62 188.37,165.5 188.37,171.79
+AVDD18 on BOTTOM (solid shape): 189.44,166.91 190.05,166.91 190.25,166.71 190.25,165.53 190.09,165.37 189.36,165.37 189.17,165.18 188.28,165.18 188.14,165.32 188.14,167.08 188.22,167.16 189.19,167.16
+AVDD18 on IN1 (solid shape): 190.78,173.39 190.78,172.22 191.42,171.59 191.42,166.3 190.34,165.22 189.97,165.22 189.58,165.62 189.58,166.54 190.11,167.07 190.15,167.09 190.2,167.09 190.34,167.23 190.34,167.3 190.38,167.34 190.38,167.66 189.99,168.04 189.99,168.55 190,168.68 189.99,168.74 189.99,169.3 190.06,169.51 189.99,169.73 189.99,170.22 190.02,170.37 189.99,170.51 189.99,171.14 190.01,171.15 190.01,171.18 190.12,171.5 189.91,171.77 189.7,171.97 189.7,173.36 189.8,173.45 190.72,173.45
+AVDD18 on TOP: 185.25,164.74 185.13,164.74 185.06,164.67 185.06,163.29 184.75,162.97 184.75,162.68 184.88,162.55 185.19,162.55 185.28,162.64 185.28,162.8 185.58,163.1 185.58,163.57 185.33,163.82 185.33,164.67
+AVDD18 on BOTTOM: 187.92,174.5 190.34,174.5 190.66,174.18 190.66,172.22 190.37,171.93 189.9,171.93 189.54,172.29 187.86,172.29 187.85,172.3 187.85,174.43
+AVDD18 on BOTTOM: 185.84,165.38 184.76,165.38 184.72,165.33 184.72,164.51 185.17,164.06 185.17,163.51 184.76,163.09 184.76,162.71 185.01,162.45 185.42,162.45 186.01,163.04 186.01,165.21
+AVDD18 on IN3: 184.79,162.56 185.76,162.56 187.13,163.93 188.13,163.93 189.43,165.23 190.26,165.23 190.41,165.38 190.41,166.63 190.26,166.78 187.59,166.78 186.2,165.39 186.2,164.66 184.69,163.15 184.69,162.66
+AVDD25 on BOTTOM (solid shape): 187.54,164.18 187.54,162.36 187.54,162.36 187.54,162.14 187.54,161.82 187.54,160.85 187.37,160.55 187.54,160.25 187.54,158.94 187.29,158.68 186.85,158.68 186.66,158.87 186.66,161.53 186.54,161.66 185.98,161.66 185.92,161.72 185.92,162.73 186.15,162.96 186.15,164.42 186.25,164.52 187.2,164.52
+AVDD25 on IN4: 187.99,170.84 189.64,170.84 190.28,170.2 190.28,167.98 189.58,167.28 189.58,165.57 188.49,164.48 188.49,163.71 187.1,162.33 185.7,162.33 185.51,162.52 185.51,165.38 187.23,167.09 187.23,170.08
+AVDD33 on TOP (solid shape): 191.57,174.59 191.57,174.58 191.74,174.41 191.74,173.7 191.57,173.53 191.57,172.63 191.41,172.47 190.43,172.47 190.31,172.59 190.15,172.59 190.02,172.62 189.89,172.59 188.45,172.59 188.39,172.65 188.39,172.78 188.43,172.82 189.4,172.82 189.49,172.92 189.8,172.92 190.16,172.84 190.4,173.13 190.43,173.16 190.43,173.53 190.12,173.84 190.12,174.79 190.33,175 191.16,175
+AVDD33 on BOTTOM (solid shape): 191.37,170.27 191.37,169.43 191.08,169.14 189.71,169.14 189.41,169.44 189.41,169.72 189.56,169.88 189.82,169.88 190.32,170.37 191.27,170.37
+DVDD09 on TOP (solid shape): 182.11,164.73 182.11,162.75 181.92,162.56 181.62,162.56 181.48,162.69 181.48,164.72 181.5,164.74 182.1,164.74
+DVDD09 on BOTTOM (solid shape): 183.04,164.36 183.04,163.92 182.53,163.41 182.53,161.82 181.32,160.61 180.75,160.61 180.69,160.68 180.69,161.57 181.32,161.57 181.51,161.76 181.51,163.54 181.39,163.66 181.39,164.42 181.45,164.49 182.91,164.49
+DVDD09 on TOP: 183.86,173.94 183.86,175.33 183.48,175.71 183.48,176.08 183.64,176.23 183.88,176.23 184.47,175.64 184.47,175.12 184.12,174.77 184.12,173.95 184.08,173.91 183.9,173.91
+DVDD09 on TOP: 179.17,171.64 177.11,171.64 177.02,171.54 177.02,171.11 177.14,170.99 179.19,170.99 179.23,171.02 179.23,171.58
+DVDD09 on BOTTOM: 177.19,171.01 178.79,171.01 178.88,171.1 178.88,173.63 179.34,174.09 181.24,174.09 181.55,174.4 181.55,175.66 181.87,175.98 181.87,175.98 182.3,176.4 183.31,176.4 183.47,176.24 183.47,175.83 183.87,175.43 183.87,175.12 184.13,174.86 184.13,174.22 184.19,174.16 184.77,174.16 184.84,174.23 184.84,175.78 184.52,176.11 184.52,178.15 184.1,178.57 179.44,178.57 178.86,177.98 178.86,176.45 177.76,175.35 177.76,172.27 177.49,172.01 177.14,172.01 176.95,171.82 176.95,171.25
+DVDD09 on IN2: 181.39,164.61 182.06,165.28 182.06,173.45 183.74,175.13 183.74,175.5 183.48,175.76 183.48,176.27 183.66,176.45 184.55,176.45 184.83,176.17 184.83,173.55 184.27,172.99 184.27,164.59 182.18,162.5 181.5,162.5 181.39,162.61
+DVDD09 on IN3: 177.18,170.98 178.53,170.98 179.8,172.24 179.8,173.62 180.1,173.92 180.1,174.98 179.46,175.61 179.05,175.61 178.83,175.39 178.83,174.43 178.27,173.87 178.27,173.11 176.82,171.67 176.82,171.33
+DVDD18 on TOP (solid shape): 180.93,164.65 180.93,163.56 180.9,163.55 180.8,163.47 180.73,163.36 180.73,163.35 180.63,163.25 180.63,162.34 180.42,162.14 180.17,162.14 179.98,162.32 179.98,162.91 180.02,162.95 180.05,163.01 180.65,163.61 180.65,164.61 180.64,164.67 180.71,164.74 180.85,164.74
+DVDD18 on BOTTOM (solid shape): 181.07,164.38 181.07,163.89 180.67,163.49 180.67,163.07 180.6,163 180.58,163 180.58,162.98 180.46,162.86 180.16,162.86 180.07,162.94 180.07,163 179.97,163.11 179.15,163.11 177.55,161.51 177.07,161.51 176.78,161.8 176.78,162.17 178.64,164.02 178.65,164.03 178.78,164.11 178.86,164.24 178.86,164.25 179.06,164.45 181.01,164.45
+DVDD18 on IN2 (solid shape): 180.66,163.13 180.66,162.58 179.63,161.56 177.2,161.56 177.07,161.69 177.07,162.15 178.88,163.96 179.83,163.96
+DVDD18 on IN3 (solid shape): outline of 170 points within 177.37,169.33 183.69,176.34
+DVDD18 on BOTTOM: 177.37,170.92 177.45,170.84 178.72,170.84 178.85,170.71 178.85,170.14 178.72,170.01 177.7,170.01 177.53,169.84 176.51,169.84 176.37,169.98 176.37,170.77 176.51,170.92
+DVDD18 on BOTTOM: 183.2,176.27 182.66,176.27 182.15,175.76 182.15,174.32 182.3,174.17 182.97,174.17 183.07,174.27 183.07,175.59 183.34,175.87 183.34,176.12
+DVDD18 on IN2: 183.14,176.45 182.32,176.45 181.34,175.47 181.34,174.86 182.01,174.19 182.11,174.19 183.02,175.1 183.02,175.56 183.33,175.87 183.33,176.27
+DVDD18_UPS on TOP: 174.92,165.82 177.32,165.82 177.44,165.69 177.44,165.25 177.19,165 176.3,165 175.67,164.36 173.95,164.36 173.48,164.84 173.48,166.47 173.61,166.6 173.61,167.89 173.79,168.07 174.59,168.07 174.69,167.98 174.69,166.05
+DVDD25_UPS on TOP: 179.03,165.19 178.14,165.19 177.11,164.16 177.11,164.07 177.06,164.02 177.06,163.28 176.87,163.09 175.92,163.09 175.67,162.84 175.67,161.95 175.73,161.88 177.63,161.88 178.14,162.39 178.14,164.11 179.09,165.06 179.09,165.12
+DVDD3318 on TOP: 175.09,174.33 175.67,174.33 176.05,174.71 177.63,174.71 177.76,174.58 177.76,174.33 177.57,174.14 176.68,174.14 176.62,174.08 176.62,173.12 176.05,172.55 174.84,172.55 174.78,172.62 174.78,174.01
+VCC_CORE on TOP: 154.72,71.78 156.18,71.78 156.81,71.14 157.83,71.14 157.89,71.08 157.89,70.38 157.76,70.25 154.78,70.25 154.59,70.44 154.59,71.65
+VCC_CORE on TOP: outline of 160 points within 117.56,24.79 157.89,75.65
+VCC_CORE on BOTTOM: outline of 463 points within 117.4,16.98 158.11,72.92
+VCC_CORE on IN1: outline of 125 points within 117.12,27.46 157.87,76.1 ; 3 cut-outs
+VCC_CORE on GND2: 120.68,27.07 118.34,29.41 118.34,52.19 120.29,54.15 120.29,66.22 120.22,66.3 120.22,69.97 120.37,70.13 125.83,70.13 132.81,63.14 137.14,63.14 137.95,63.95 137.95,70.56 138.92,71.52 156.1,71.52 156.59,71.04 156.59,59.83 157.7,58.72 157.7,55.78 156.15,55.78 155.9,56.03 142.48,56.03 141.32,54.87 141.32,52.33 140.94,51.94 140.94,51.44 138.16,48.66 135.24,48.66 132.55,45.98 132.55,43.86 128.04,39.35 128.04,29.85 125.27,27.07
+VCC_CORE on IN2: 156.96,71.02 156.96,63.58 158.17,62.38 158.17,46 156.95,44.78 153.47,44.78 151.43,42.75 151.43,29.69 149.64,27.9 120.48,27.9 119.34,29.04 119.34,68.48 120.42,69.56 123.6,69.56 129.82,63.33 135.28,63.33 137.82,65.87 137.82,70.8 138.75,71.73 156.24,71.73
+VCC_CORE on IN3: 156.96,71.02 156.96,63.57 158.11,62.42 158.11,45.72 157.1,44.7 153.77,44.7 151.64,42.57 151.64,33.02 148.13,29.51 127.37,29.51 124.74,26.88 119.4,26.88 118.28,28.01 118.28,71.99 119.95,73.65 137.15,73.65 138.6,72.21 138.64,72.25 138.69,72.26 139.62,72.26 139.66,72.26 139.68,72.24 139.71,72.02 139.85,71.86 140.24,71.82 140.44,72.15 140.46,72.23 140.54,72.26 155.72,72.26
+VCC_CORE on IN4: outline of 148 points within 117.18,27.39 157.79,72.26
+VCCGT on TOP: outline of 99 points within 136.91,25.02 162.1,55.01
+VCCGT on BOTTOM: outline of 160 points within 132.18,21.28 159.97,55.13
+VCCGT on IN1: 157.33,52.2 157.3,52.21 157.08,52.49 157.2,52.81 157.24,52.88 157.21,52.96 156.35,53.82 156.35,54.06 156.35,54.06 156.35,54.89 155.94,55.29 155.85,55.29 155.71,55.44 142.63,55.44 141.82,54.63 141.82,52.09 141.51,51.78 141.51,51.33 140.27,50.09 140.36,49.6 139.87,49.5 138.48,48.12 135.57,48.12 135.15,47.7 135.15,46.37 135.21,46.31 135.25,46.35 135.86,46.16 135.33,45.8 135.22,45.8 135.17,45.71 135.17,34.77 135.14,34.73 135.14,32.12 132.26,29.23 132.26,25.52 132.93,24.85 152.49,24.85 152.73,24.61 164.19,24.61 164.82,25.25 164.82,29.89 157.17,37.54 153.26,37.54 152.2,38.61 152.2,41.78 152.58,42.16 154.08,42.16 154.48,41.76 155.55,41.76 157.33,43.53 157.33,48.54 157.3,48.55 157.06,48.88 157.3,49.22 157.33,49.23 157.33,49.46 157.3,49.47 157.08,49.8 157.3,50.13 157.33,50.14 157.33,50.37 157.3,50.38 157.08,50.71 157.3,51.04 157.33,51.06 157.33,51.29 157.3,51.3 157.08,51.63 157.3,51.96 157.33,51.97
+VCCGT on IN4: outline of 116 points within 132.1,26.26 159.89,59.97
+VCCIO on BOTTOM (solid shape): 164.44,107.62 164.44,104.85 164.24,104.65 161.82,104.65 161.75,104.72 161.75,105.05 161.82,105.13 162.18,105.13 162.28,105.23 162.28,107.16 162.23,107.21 161.75,107.21 161.7,107.26 161.7,107.85 161.9,108.05 164.01,108.05
+VCCIO on TOP: 143.6,72.73 145.69,72.73 145.95,72.48 148.81,72.48 149.31,72.98 151.6,72.98 151.98,73.37 154.33,73.37 154.52,73.17 155.1,73.17 155.16,73.11 155.16,72.16 154.97,71.97 153.45,71.97 153.06,71.59 145.16,71.59 144.71,72.03 143.53,72.03 143.47,72.09 143.47,72.6
+VCCIO on BOTTOM: 142.45,76.52 142.18,76.52 142.08,76.42 141.94,76.36 141.92,76.36 141.75,76.19 141.75,76.17 141.4,75.91 141.12,76.24 141.09,76.31 141.02,76.35 140.86,76.4 140.75,76.52 140.47,76.52 140.4,76.45 140.32,76.39 140.32,75.72 140.36,75.64 140.45,75.63 140.73,75.55 140.84,75.28 140.83,75.25 140.88,75.21 140.9,75.22 141.29,74.91 140.94,74.56 140.86,74.53 140.84,74.44 140.84,74.42 140.88,74.38 140.88,73.49 141.32,73.05 146.59,73.05 146.78,72.86 146.78,72.21 147.1,71.89 156.95,71.89 157.38,72.32 157.38,73.59 157.34,73.63 157.33,73.63 157.2,73.71 157.12,73.84 157.12,73.85 156.86,74.11 156.85,74.11 156.75,74.18 156.69,74.28 156.68,74.29 156.38,74.59 156.31,74.64 156.25,74.72 155.95,75.02 155.94,75.02 155.84,75.09 155.77,75.19 155.77,75.2 155.52,75.45 155.51,75.45 155.41,75.52 155.34,75.62 155.34,75.63 155.27,75.7 151.54,75.7 151.24,75.4 149.95,75.4 149.38,75.97 147.6,75.97 147.03,76.54 142.46,76.54
+VCCIO on IN1: outline of 205 points within 142.46,59.59 161.28,78.6
+VCCIO on IN2: 141.2,71.95 156.45,71.95 157,71.41 158.75,71.41 159.69,72.35 159.69,78.6 154.92,83.37 154.92,89.94 159.25,94.27 166.21,94.27 167.52,95.58 167.52,105.52 166.03,107.01 161.63,107.01 160.89,106.27 152.21,106.27 150.48,104.54 150.48,97.15 140.81,87.48 140.81,72.35
+VCCIOP on BOTTOM (solid shape): 161.52,107.82 161.52,104.72 161.39,104.6 160.45,104.6 159.87,105.18 157.33,105.18 156.97,104.82 156.97,103.88 156.82,103.73 154.15,103.73 153.92,103.96 153.92,106.58 154.63,107.29 159.79,107.29 160.45,107.95 161.39,107.95
+VCCSA on BOTTOM (solid shape): 149.35,114.5 149.35,107.44 148.78,106.87 148.78,104.39 148.61,104.21 144.27,104.21 144.11,104.38 144.11,106.46 141.96,108.61 141.96,112.42 142.21,112.67 143.03,112.67 143.16,112.8 143.16,113.69 143.06,113.79 142.14,113.79 142.01,113.92 142.01,114.7 142.24,114.93 148.92,114.93
+VCCSA on TOP: outline of 82 points within 124.87,72.67 151.3,106.61
+VCCSA on BOTTOM: 143.41,77.75 144.87,77.75 145.38,77.24 145.76,77.24 145.89,77.37 146.27,77.37 146.71,77.81 147.35,77.81 147.98,78.45 147.98,78.64 148.11,78.76 149.32,78.76 151.22,76.86 151.22,75.52 151.1,75.4 150.02,75.4 148.94,76.48 148.56,76.48 148.05,75.97 147.73,75.97 147.1,76.6 142.4,76.6 142.02,76.99 141.57,76.99 141.44,76.86 141.32,76.86 141.13,77.05 141.13,77.24 141.7,77.81 142.14,77.81 142.65,77.3 142.97,77.3
+VCCSA on IN2: 148.81,106.89 125.82,106.89 123.16,104.23 123.16,97.18 125,95.34 141.06,95.34 149.38,103.66 149.38,106.32
+VDD09 on BOTTOM (solid shape): 190.03,178.96 190.03,177.39 189.87,177.22 188.88,177.22 188.8,177.3 188.8,177.87 189.04,178.2 188.8,178.54 188.8,178.97 188.97,179.13 189.86,179.13
+VDD09 on IN4 (solid shape): outline of 236 points within 184.08,173.53 190.31,179.19
+VDD09 on TOP: 167.84,164.62 168.06,164.84 169.57,164.84 170.13,164.27 170.13,163.09 168.6,161.57 166.67,161.57 166.51,161.73 166.51,164.18 166.33,164.35 164.83,164.35 164.78,164.41 164.78,165.07 164.83,165.13 166.86,165.13 167.37,164.62
+VDD09 on BOTTOM: 168.59,163.22 171.28,163.22 171.95,163.89 171.95,164.45 171.95,164.45 171.95,165.41 171.8,165.57 168.69,165.57 168.18,165.06 168.18,164.46 167.97,164.25 167.97,163.84
+VDD09 on BOTTOM: 180.55,161.13 180.55,159.62 180.17,159.24 178.76,159.24 178.4,159.6 178.4,160.74 179.27,161.61 180.07,161.61
+VDD09 on IN3: 173.06,159.91 170.51,162.46 168.46,162.46 168.12,162.79 168.12,164.28 168.22,164.37 171.52,164.37 173.92,161.97 175.9,161.97 176.62,162.7 180.51,162.7 180.62,162.58 180.62,159.66 179.54,158.58 174.39,158.58 173.98,158.99
+VDD09 on IN4: 181.85,164.09 182.4,164.65 184,164.65 184.52,164.13 184.52,161.71 183.68,160.87 181.81,160.87 180.17,159.23 179.35,159.23 178.92,159.65 178.92,162.99 180.03,164.09
+VDD18 on TOP: 174.44,173.14 173.9,173.14 173.68,172.92 171.85,172.92 171.61,172.68 171.61,171.09 171.99,170.71 171.99,169.76 171.9,169.67 171.11,169.67 171.04,169.6 171.04,168.4 171.16,168.28 174.53,168.28 174.7,168.45 174.7,169.33 174.54,169.49 174.07,169.49 173.51,170.04 173.51,170.84 173.66,170.98 174.7,170.98 174.85,171.13 174.85,172.11 174.49,172.46 174.49,173.1
+VDD18 on BOTTOM: 191.93,174.84 191.84,174.75 191.48,174.75 191.27,174.97 190.72,174.97 190.59,174.84 189.7,174.84 189.64,174.9 189.64,175.47 189.83,175.66 190.02,175.66 190.83,176.48 191.8,176.48 191.93,176.35
+VDD18 on BOTTOM: 172.95,172.33 172.95,170.87 173.05,170.76 173.05,170.6 173.51,170.14 174.91,170.14 175.23,169.82 175.73,169.82 175.92,170.01 175.92,172.3 175.84,172.39 173,172.39
+VDD18 on IN3: 191.86,174.71 191.23,174.08 191.23,173.19 190.47,172.43 187.86,172.43 182.97,167.54 180.75,167.54 178.3,165.08 174.67,165.08 172.88,166.87 172.88,171.54 173.26,171.92 174.9,171.92 177.69,169.12 180.12,169.12 185.83,174.84 189.32,174.84 190.08,175.6 190.08,176.05 190.52,176.48 191.69,176.48 191.86,176.3
+VDD25 on TOP (solid shape): 190.81,163.5 190.97,163.46 191.14,163.5 191.48,163.5 191.77,163.21 191.77,160.88 191.6,160.71 189.24,160.71 189.19,160.75 189.19,162.43 189.23,162.47 189.96,162.47 190.12,162.63 190.12,163.46 190.15,163.5
+VDD25 on BOTTOM (solid shape): 197.52,164.19 197.52,163.91 196.54,162.93 196.54,162.34 195.82,161.63 192.34,161.63 190.63,159.92 188.26,159.92 188.09,160.09 188.09,161.07 188.22,161.2 189.2,161.2 189.88,161.88 190.57,161.88 191.57,162.89 192.48,162.89 192.94,163.35 193.55,163.35 193.55,163.34 194.56,163.34 194.79,163.57 195.48,163.57 195.88,163.97 196.19,163.97 196.46,164.23 197.48,164.23
+VDD25 on IN3: 173.88,162.1 175.82,162.1 176.49,162.77 181.47,162.77 182.94,161.3 186.6,161.3 187.5,160.39 190.58,160.39 191.8,161.61 191.8,162.79 191.69,162.9 191.01,162.9 190.17,162.07 188.36,162.07 188.03,162.4 183.42,162.4 183.19,162.63 183.19,163.96 182.63,164.52 179.01,164.52 178.54,164.05 174.96,164.05 173.68,162.77 173.68,162.3
GND on TOP (solid shape): 123.21,72.41 123.21,69.62 123.15,69.56 120.42,69.56 120.36,69.62 120.36,72.41 120.55,72.6 123.02,72.6
GND on TOP (solid shape): 129.87,141.29 129.87,139.44 129.68,139.25 128.6,139.25 128.54,139.32 128.54,141.22 128.66,141.35 129.81,141.35
GND on TOP (solid shape): 136.43,102.89 136.43,99.53 136.3,99.4 135.16,99.4 135.09,99.46 135.09,102.83 135.28,103.02 136.3,103.02
GND on TOP (solid shape): 137.76,117.69 137.76,116.8 137.57,116.61 136.3,116.61 136.05,116.86 136.05,117.69 136.24,117.88 137.57,117.88
GND on TOP (solid shape): 145.27,148.66 145.27,148.35 145.13,148.21 142.75,148.21 142.64,148.32 142.64,149.7 142.68,149.74 144.19,149.74
GND on TOP (solid shape): 148.49,54.76 148.49,50.7 147.98,50.19 145.63,50.19 145.19,50.63 145.19,54.95 145.25,55.01 148.23,55.01
GND on TOP (solid shape): 168,30.91 168,27.33 167.94,27.28 165.43,27.28 165.33,27.38 165.33,30.88 165.46,31.01 167.89,31.01
GND on TOP (solid shape): 270.66,31.44 270.66,22.6 270.23,22.17 267.59,22.17 267.08,22.68 267.08,31.37 267.33,31.62 270.48,31.62
GND on TOP (solid shape): 279.11,111.28 279.11,106.07 278.98,105.94 276.19,105.94 275.94,106.2 275.94,111.28 276.19,111.53 278.86,111.53
GND on TOP (solid shape): 313.26,39.65 313.26,39.14 312.39,38.28 311.84,38.28 311.76,38.35 311.76,38.96 312.52,39.72 313.18,39.72
GND on TOP (solid shape): 319.58,23.37 319.58,20.11 319.35,19.89 316.81,19.89 316.59,20.11 316.59,23.34 316.86,23.62 319.33,23.62
GND on TOP (solid shape): 331.63,31.8 331.63,29.59 331.5,29.46 327.92,29.46 327.82,29.56 327.82,31.93 327.94,32.05 331.37,32.05
GND on TOP (solid shape): 333.27,52.98 333.27,50.24 333.02,49.99 326.12,49.99 325.35,50.75 325.35,52.86 325.58,53.09 333.16,53.09
GND on TOP (solid shape): 356.46,12.04 356.46,8.89 356.39,8.82 354.86,8.82 354.65,9.03 354.65,11.31 355.51,12.17 356.32,12.17
GND on TOP (solid shape): 370.05,54.15 370.05,52.91 369.95,52.8 368.48,52.8 368.32,52.96 368.32,54.1 368.53,54.3 369.9,54.3
GND on TOP (solid shape): 147.09,30.25 147.09,27.48 147.04,27.43 144.07,27.43 143.9,27.6 143.9,30.24 144.02,30.35 146.99,30.35
GND on TOP (solid shape): 157.81,30.1 157.81,27.38 157.76,27.33 154.96,27.33 154.71,27.58 154.71,30.07 154.91,30.27 157.63,30.27
GND on TOP (solid shape): 104.93,64.54 104.93,60.86 103.66,59.59 103.15,59.59 102.83,59.9 102.83,60.16 103.91,61.24 103.91,64.48 104.04,64.6 104.86,64.6
GND on TOP (solid shape): 107.91,144.8 107.91,143.72 107.91,143.72 106.52,142.32 106.14,142.32 105.56,142.9 105.56,144.87 105.63,144.93 107.78,144.93
GND on TOP (solid shape): 137.95,121.82 137.95,120.8 137.82,120.67 135.66,120.67 135.56,120.78 135.56,121.97 135.66,122.07 137.69,122.07
GND on TOP (solid shape): 142.48,150.11 142.48,148.74 142.4,148.66 142.18,148.66 141.45,149.4 140.01,149.4 140,149.41 140,150.35 140.06,150.41 142.19,150.41
GND on TOP (solid shape): 294.99,38.52 296.12,38.52 296.15,38.48 296.15,38 296.13,37.97 293.52,37.97 293.36,38.13 293.36,38.88 293.46,38.97 294.53,38.97
GND on TOP (solid shape): 334.06,35.53 334.06,33.14 333.96,33.04 333.2,33.04 333.1,33.14 333.1,35.48 333.3,35.68 333.91,35.68
GND on TOP (solid shape): 340.72,19.44 340.72,14.54 340.52,14.35 339.79,14.35 339.7,14.43 339.7,18.68 339.85,18.83 339.85,19.52 339.92,19.59 340.57,19.59
GND on TOP (solid shape): 353.29,25.3 353.29,24.53 353.16,24.41 351.66,24.41 351.54,24.53 351.54,25.42 351.61,25.5 353.08,25.5
GND on TOP (solid shape): 86.28,24.1 86.28,19.81 86.11,19.63 85.55,19.63 85.15,20.04 84.4,20.04 84.4,21.23 84.68,21.51 84.68,23.9 85.04,24.25 86.13,24.25
GND on TOP (solid shape): 125.56,150.42 125.56,149.63 125.51,149.58 125.01,149.58 124.59,149.16 123.82,149.16 123.75,149.22 123.75,151.1 123.93,151.27 124.72,151.27
GND on TOP (solid shape): 193.36,133.05 193.36,127.96 192.94,127.53 191.94,127.53 191.73,127.74 191.73,133.12 191.79,133.18 193.23,133.18
GND on TOP (solid shape): 216.42,120.38 216.42,119.43 216.24,119.25 211.47,119.25 211.37,119.35 211.38,119.37 211.38,121.01 211.61,121.24 215.56,121.24
GND on TOP (solid shape): 271.68,122.2 271.68,121.82 269.46,119.59 269.46,113.69 269.08,113.31 266.03,113.31 265.65,113.69 265.65,121.82 266.22,122.39 271.49,122.39
GND on TOP (solid shape): 314.2,34.82 314.2,33.91 314.07,33.78 312.14,33.78 309.55,33.78 309.47,33.86 309.47,34.49 309.68,34.69 312.72,34.69 312.93,34.9 314.12,34.9
GND on TOP (solid shape): 149.31,144.1 149.82,144.1 149.95,143.98 149.95,141.5 149.76,141.31 147.41,141.31 147.15,141.56 147.15,143.09 146.96,143.28 146.52,143.28 146.46,143.34 146.46,144.1 146.58,144.23 149.19,144.23
GND on TOP (solid shape): 215.65,96.7 215.65,95.37 215.49,95.22 212.32,95.22 212.24,95.3 212.24,95.5 212.17,95.58 210.95,95.58 210.87,95.65 210.87,96.87 211,97 215.34,97
GND on TOP (solid shape): 239.77,97.79 239.77,96.73 239.67,96.63 237.68,96.63 237.3,96.25 237.3,96.08 237.2,95.98 236.22,95.98 236.15,96.05 236.15,96.8 236.33,96.99 236.72,96.99 237.72,97.98 239.58,97.98

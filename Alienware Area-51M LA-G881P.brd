# Allegro board Alienware Area-51M LA-G881P.brd (continued)
## Nets (continued)
GND: C1.2 C2.2 C3.2 C4.2 C5.2 C6.2 C8.2 C11.2 C29.2 C256.2 C257.2 C258.2 C260.2 C261.2 C262.2 C263.2 C264.2 C265.2 C266.2 C267.2 C268.2 C269.2 C270.2 C617.2 C618.2 C620.2 C621.2 C622.2 C623.2 C624.2 C625.2 C627.2 C628.2 C631.2 C635.2 C636.2 C637.2 C638.2 C641.2 C2498.2 C2501.2 C2506.2 C2507.2 C2508.2 C2509.2 C2512.2 C2513.2 C2514.2 C2515.2 C2516.2 C2518.2 C2519.2 C2521.2 C2522.2 C2523.2 C2524.2 C2525.2 C2531.2 C5360.2 CC1.2 CC2.2 CC3.2 CC4.2 CC22.2 CC23.2 CC24.2 CC25.2 CC26.2 CC27.2 CC28.2 CC29.2 CC30.2 CC31.2 CC32.2 CC33.2 CC34.2 CC35.2 CC36.2 CC37.2 CC38.2 CC46.1 CC47.2 CC48.2 CC49.2 CC50.2 CC51.2 CC52.2 CD1.2 CD2.2 CD3.2 CD4.2 CD5.2 CD6.2 CD7.2 CD8.2 CD9.2 CD10.2 CD11.2 CD12.2 CD13.2 CD14.2 CD15.2 CD16.2 CD17.2 CD18.2 CD19.1 CD20.2 CD21.2 CD22.2 CD23.1 CD24.2 CD25.2 CD27.2 CD28.2 CD29.2 CD30.2 CD32.2 CD33.2 CD34.2 CD35.2 CD36.2 CD37.2 CD38.2 CD39.2 CD40.2 CD41.2 CD42.2 CD43.2 CD44.2 CD45.2 CD46.2 CD47.2 CD48.2 CD49.2 CD50.2 CD51.1 CD52.1 CD53.2 CD54.2 CD55.1 CD56.2 CD58.2 CD59.2 CD64.2 CD65.2 CD66.2 CD67.2 CD68.2 CD69.2 CD70.2 CD71.2 CD72.2 CD73.2 CD74.2 CD75.2 CD76.2 CD77.2 CD78.2 CD79.2 CD80.2 CD81.2 CD82.1 CD83.2 CD84.2 CD85.2 CD86.1 CD87.2 CD88.2 CD89.2 CD90.2 CD94.2 CD95.2 CD96.2 CD97.2 CD98.2 CD99.2 CD100.2 CD101.2 CD102.2 CD103.2 CD104.2 CD105.2 CD106.2 CD107.2 CD108.2 CD109.2 CD110.2 CD111.2 CD112.2 CD113.1 CD114.1 CD115.2 CD116.2 CD117.1 CD118.2 CD119.2 CD120.2 CD125.2 CD131.2 CD132.2 CD133.2 CD134.2 CE1.2 CE2.2 CE5.2 CE6.2 CE7.2 CE8.2 CE9.2 CE19.2 CE22.2 CE24.2 CE28.2 CE29.2 CE30.2 CE31.1 CE32.1 CE34.2 CE38.1 CE40.1 CE41.2 CE42.1 CE43.2 CE44.2 CE45.2 CE46.2 CE51.2 CE59.2 CE60.2 CE61.2 CE62.2 CE63.1 CE64.2 CE65.2 CE79.2 CE80.2 CE81.2 CE82.2 CE86.2 CE87.2 CE169.2 CE170.2 CE171.2 CE173.2 CE174.2 CE175.2 CE176.2 CE177.2 CE201.2 CE202.1 CE203.2 CE204.2 CE205.2 CF4.2 CF5.2 CF6.2 CF7.2 CH36.2 CH45.2 CH46.2 CH47.2 CH48.2 CH49.2 CH52.2 CH53.2 CH56.2 CH80.2 CH81.2 CH82.2 CH83.2 CH173.2 CH174.2 CH175.2 CH176.2 CH177.2 CH180.2 CH181.2 CH182.2 CH183.2 CH184.2 CH185.2 CH186.2 CH187.2 CH188.2 CH189.2 CH190.2 CH192.2 CH197.2 CH201.2 CH226.2 CH231.2 CH232.2 CH233.2 CH234.2 CH235.2 CH236.2 CH237.2 CH238.2 CH239.2 CH240.2 CH241.2 CH242.2 CH243.2 CH244.2 CH245.1 CH246.2 CH263.2 CH264.1 CL1.2 CL2.2 CL3.2 CL4.2 CL9.2 CL10.1 CL20.2 CL22.2 CL23.2 CL24.2 CL26.2 CL27.2 CL28.2 CL29.2 CL31.2 CL40.2 CL41.2 CL42.2 CL43.2 CL44.2 CL45.2 CL46.2 CL47.2 CL48.2 CL49.2 CL50.2 CL51.2 CL52.2 CL53.2 CL54.2 CL55.2 CL56.2 CL57.2 CL58.2 CL59.2 CL60.2 CL61.2 CL62.2 CL63.2 CL64.2 CL65.2 CL66.2 CL67.2 CL68.2 CL69.2 CL70.2 CL71.1 CL72.1 CL73.1 CL74.1 CL75.1 CL76.1 CL77.2 CL78.2 CL79.2 CL80.2 CL81.2 CL82.2 CL90.2 CL91.2 CL92.2 CL93.2 CL94.2 CL95.2 CL96.2 CL97.2 CL98.2 CL99.2 CL100.2 CL102.2 CL103.2 CL104.2 CL107.2 CL108.2 CL109.2 CL110.2 CL111.2 CL112.2 CL113.2 CL114.2 CL115.2 CL116.2 CL117.2 CL118.2 CL119.2 CL120.2 CL121.2 CL122.2 CL123.2 CL124.2 CL125.2 CL126.2 CL127.2 CL129.2 CLIP1.1(TP-1) CLIP2.1(TP-1) CLRP1.2 CM9.2 CM16.2 CM17.2 CM18.2 CM19.2 CM20.2 CM21.2 CM22.2 CM23.2 CM29.2 CM30.2 CM31.2 CM32.2 CM33.2 CM34.2 CM35.2 CM36.2 CM37.2 CM38.2 CM70.2 CN1.2 CN2.2 CN3.2 CN4.2 CN5.2 CN8.2 CN9.2 CS1.2 CS2.2 CS5.2 CS6.2 CS7.2 CS16.2 CS17.2 CS18.2 CS19.2 CS20.2 CT37.2 CT38.2 CT45.2 CT46.2 CT47.2 CT48.2 CT49.2 CT50.2 CT51.2 CT52.2 CT53.2 CT54.2 CT55.2 CT56.2 CT57.2 CT58.2 CT59.2 CT60.2 CT61.2 CT62.2 CT63.2 CT64.2 CT65.2 CT66.2 CT67.2 CT68.2 CT69.2 CT70.2 CT71.2 CT72.2 CT73.2 CT74.2 CT75.2 CT77.2 CT78.2 CT79.2 CT80.2 CT81.2 CT82.2 CT83.2 CT84.2 CT85.2 CT86.2 CT88.2 CT90.2 CT91.2 CT92.2 CT93.2 CT94.1 CT95.1 CT96.2 CT97.2 CT98.2 CT99.2 CT100.2 CT101.2 CT102.2 CT103.2 CT104.2 CT106.2 CT112.2 CT113.2 CT114.2 CT115.2 CT116.2 CT117.2 CT118.2 CT121.2 CT122.2 CT123.2 CT124.2 CT153.2 CT154.2 CT155.2 CT156.2 CT157.2 CT200.2 CT201.2 CT202.2 CT203.2 CT204.2 CT205.2 CT206.2 CT207.2 CT208.2 CT209.2 CT210.2 CT213.2 CT214.2 CT215.2 CT216.2 CT217.2 CT218.2 CT219.2 CT5361.2 CU2.2 CU3.2 CU6.2 CU7.2 CU10.2 CU11.2 CU16.2 CU17.2 CU26.2 CU28.2 CU29.2 CU45.2 CU46.2 CU47.2 CU48.2 CU101.2 CU102.2 CU108.1 CU109.1 CU242.2 CU243.2 CU244.2 CU245.2 CV19.2 CV21.2 CV23.2 CV24.2 CV805.2 CV806.2 CV902.2 CV903.2 CV956.2 CV957.2 CV1071.2 CV1073.2 CV1074.2 CV1076.2 CV1078.2 CV1079.2 CV1080.2 CV1081.2 CV1082.2 CV1083.2 CV1084.2 CV1085.2 CV1101.2 CV1102.2 CV1103.2 CV1104.2 CV1105.2 CV1106.2 CV1107.2 CV1108.2 CV1109.2 DK1.1 DK2.1 DK3.1 DT1.2 DT2.2 DT3.2 DT4.2 DT5.2 DT6.2 DT7.2 DT8.2 DT9.2 DT10.3 DT11.2 DT12.2 DT13.2 DT14.2 DT15.1 DU2.3 DU9.1 DU10.1 DU11.1 DU12.3 DU13.3 H1.1(TP-1) H2.1(TP-1) H3.1(TP-1) H4.1(TP-1) H5.1(TP-1) H8.1(TP-1) H42.1(TP-1) H43.1(TP-1) H44.1(TP-1) H45.1(TP-1) H46.1(TP-1) H47.1(TP-1) H48.1(TP-1) H49.1(TP-1) H50.1(TP-1) H51.1(TP-1) H52.1(TP-1) H53.1(TP-1) H54.1(TP-1) H55.1(TP-1) H56.1(TP-1) H57.1(TP-1) H58.1(TP-1) H59.1(TP-1) H60.1(TP-1) H63.1(TP-1) H65.1(TP-1) H70.1(TP-1) JAUDIO.21 JAUDIO.26 JAUDIO.27 JAUDIO.31 JAUDIO.32 JAUDIO.33 JAUDIO.34 JCDRA.5 JCDRA.8 JCDRA.11 JCDRA.14 JCDRA.17 JCDRA.20 JCDRA.23 JCDRA.29 JCDRA.32 JCDRA.35 JCDRA.38 JCDRA.41 JCDRA.44 JCDRA.47 JCDRA.48 JCDRA.49 JCDRA.50 JDG.1 JDG.2 JDG.3 JDG.4 JDG.5 JDGFF1.A3 JDGFF1.A6 JDGFF1.A9 JDGFF1.B1 JDGFF1.B4 JDGFF1.B7 JDGFF1.B10 JDGFF1.C1 JDGFF1.C3 JDGFF1.C6 JDGFF1.F3 JDGFF1.F6 JDGFF1.G1 JDGFF1.G4 JDGFF1.G7 JDGFF1.G10 JDGFF1.H3 JDGFF1.H6 JDGFF1.H9 JDGFF2.A3 JDGFF2.A6 JDGFF2.A9 JDGFF2.B1 JDGFF2.B4 JDGFF2.B7 JDGFF2.B10 JDGFF2.C1 JDGFF2.C3 JDGFF2.C6 JDGFF2.F3 JDGFF2.F6 JDGFF2.G1 JDGFF2.G4 JDGFF2.G7 JDGFF2.G10 JDGFF2.H3 JDGFF2.H6 JDGFF2.H9 JDIMM1.1 JDIMM1.2 JDIMM1.5 JDIMM1.6 JDIMM1.9 JDIMM1.10 JDIMM1.14 JDIMM1.15 JDIMM1.18 JDIMM1.19 JDIMM1.22 JDIMM1.23 JDIMM1.26 JDIMM1.27 JDIMM1.30 JDIMM1.31 JDIMM1.35 JDIMM1.36 JDIMM1.39 JDIMM1.40 JDIMM1.43 JDIMM1.44 JDIMM1.47 JDIMM1.48 JDIMM1.51 JDIMM1.52 JDIMM1.56 JDIMM1.57 JDIMM1.60 JDIMM1.61 JDIMM1.64 JDIMM1.65 JDIMM1.68 JDIMM1.69 JDIMM1.72 JDIMM1.73 JDIMM1.77 JDIMM1.78 JDIMM1.81 JDIMM1.82 JDIMM1.85 JDIMM1.86 JDIMM1.89 JDIMM1.90 JDIMM1.93 JDIMM1.94 JDIMM1.98 JDIMM1.99 JDIMM1.102 JDIMM1.103 JDIMM1.106 JDIMM1.107 JDIMM1.167 JDIMM1.168 JDIMM1.171 JDIMM1.172 JDIMM1.175 JDIMM1.176 JDIMM1.180 JDIMM1.181 JDIMM1.184 JDIMM1.185 JDIMM1.188 JDIMM1.189 JDIMM1.192 JDIMM1.193 JDIMM1.196 JDIMM1.197 JDIMM1.201 JDIMM1.202 JDIMM1.205 JDIMM1.206 JDIMM1.209 JDIMM1.210 JDIMM1.213 JDIMM1.214 JDIMM1.217 JDIMM1.218 JDIMM1.222 JDIMM1.223 JDIMM1.226 JDIMM1.227 JDIMM1.230 JDIMM1.231 JDIMM1.234 JDIMM1.235 JDIMM1.238 JDIMM1.239 JDIMM1.243 JDIMM1.244 JDIMM1.247 JDIMM1.248 JDIMM1.251 JDIMM1.252 JDIMM1.261 JDIMM1.262 JDIMM2.1 JDIMM2.2 JDIMM2.5 JDIMM2.6 JDIMM2.9 JDIMM2.10 JDIMM2.14 JDIMM2.15 JDIMM2.18 JDIMM2.19 JDIMM2.22 JDIMM2.23 JDIMM2.26 JDIMM2.27 JDIMM2.30 JDIMM2.31 JDIMM2.35 JDIMM2.36 JDIMM2.39 JDIMM2.40 JDIMM2.43 JDIMM2.44 JDIMM2.47 JDIMM2.48 JDIMM2.51 JDIMM2.52 JDIMM2.56 JDIMM2.57 JDIMM2.60 JDIMM2.61 JDIMM2.64 JDIMM2.65 JDIMM2.68 JDIMM2.69 JDIMM2.72 JDIMM2.73 JDIMM2.77 JDIMM2.78 JDIMM2.81 JDIMM2.82 JDIMM2.85 JDIMM2.86 JDIMM2.89 JDIMM2.90 JDIMM2.93 JDIMM2.94 JDIMM2.98 JDIMM2.99 JDIMM2.102 JDIMM2.103 JDIMM2.106 JDIMM2.107 JDIMM2.167 JDIMM2.168 JDIMM2.171 JDIMM2.172 JDIMM2.175 JDIMM2.176 JDIMM2.180 JDIMM2.181 JDIMM2.184 JDIMM2.185 JDIMM2.188 JDIMM2.189 JDIMM2.192 JDIMM2.193 JDIMM2.196 JDIMM2.197 JDIMM2.201 JDIMM2.202 JDIMM2.205 JDIMM2.206 JDIMM2.209 JDIMM2.210 JDIMM2.213 JDIMM2.214 JDIMM2.217 JDIMM2.218 JDIMM2.222 JDIMM2.223 JDIMM2.226 JDIMM2.227 JDIMM2.230 JDIMM2.231 JDIMM2.234 JDIMM2.235 JDIMM2.238 JDIMM2.239 JDIMM2.243 JDIMM2.244 JDIMM2.247 JDIMM2.248 JDIMM2.251 JDIMM2.252 JDIMM2.261 JDIMM2.262 JDIMM3.1 JDIMM3.2 JDIMM3.5 JDIMM3.6 JDIMM3.9 JDIMM3.10 JDIMM3.14 JDIMM3.15 JDIMM3.18 JDIMM3.19 JDIMM3.22 JDIMM3.23 JDIMM3.26 JDIMM3.27 JDIMM3.30 JDIMM3.31 JDIMM3.35 JDIMM3.36 JDIMM3.39 JDIMM3.40 JDIMM3.43 JDIMM3.44 JDIMM3.47 JDIMM3.48 JDIMM3.51 JDIMM3.52 JDIMM3.56 JDIMM3.57 JDIMM3.60 JDIMM3.61 JDIMM3.64 JDIMM3.65 JDIMM3.68 JDIMM3.69 JDIMM3.72 JDIMM3.73 JDIMM3.77 JDIMM3.78 JDIMM3.81 JDIMM3.82 JDIMM3.85 JDIMM3.86 JDIMM3.89 JDIMM3.90 JDIMM3.93 JDIMM3.94 JDIMM3.98 JDIMM3.99 JDIMM3.102 JDIMM3.103 JDIMM3.106 JDIMM3.107 JDIMM3.167 JDIMM3.168 JDIMM3.171 JDIMM3.172 JDIMM3.175 JDIMM3.176 JDIMM3.180 JDIMM3.181 JDIMM3.184 JDIMM3.185 JDIMM3.188 JDIMM3.189 JDIMM3.192 JDIMM3.193 JDIMM3.196 JDIMM3.197 JDIMM3.201 JDIMM3.202 JDIMM3.205 JDIMM3.206 JDIMM3.209 JDIMM3.210 JDIMM3.213 JDIMM3.214 JDIMM3.217 JDIMM3.218 JDIMM3.222 JDIMM3.223 JDIMM3.226 JDIMM3.227 JDIMM3.230 JDIMM3.231 JDIMM3.234 JDIMM3.235 JDIMM3.238 JDIMM3.239 JDIMM3.243 JDIMM3.244 JDIMM3.247 JDIMM3.248 JDIMM3.251 JDIMM3.252 JDIMM3.261 JDIMM3.262 JDIMM4.1 JDIMM4.2 JDIMM4.5 JDIMM4.6 JDIMM4.9 JDIMM4.10 JDIMM4.14 JDIMM4.15 JDIMM4.18 JDIMM4.19 JDIMM4.22 JDIMM4.23 JDIMM4.26 JDIMM4.27 JDIMM4.30 JDIMM4.31 JDIMM4.35 JDIMM4.36 JDIMM4.39 JDIMM4.40 JDIMM4.43 JDIMM4.44 JDIMM4.47 JDIMM4.48 JDIMM4.51 JDIMM4.52 JDIMM4.56 JDIMM4.57 JDIMM4.60 JDIMM4.61 JDIMM4.64 JDIMM4.65 JDIMM4.68 JDIMM4.69 JDIMM4.72 JDIMM4.73 JDIMM4.77 JDIMM4.78 JDIMM4.81 JDIMM4.82 JDIMM4.85 JDIMM4.86 JDIMM4.89 JDIMM4.90 JDIMM4.93 JDIMM4.94 JDIMM4.98 JDIMM4.99 JDIMM4.102 JDIMM4.103 JDIMM4.106 JDIMM4.107 JDIMM4.167 JDIMM4.168 JDIMM4.171 JDIMM4.172 JDIMM4.175 JDIMM4.176 JDIMM4.180 JDIMM4.181 JDIMM4.184 JDIMM4.185 JDIMM4.188 JDIMM4.189 JDIMM4.192 JDIMM4.193 JDIMM4.196 JDIMM4.197 JDIMM4.201 JDIMM4.202 JDIMM4.205 JDIMM4.206 JDIMM4.209 JDIMM4.210 JDIMM4.213 JDIMM4.214 JDIMM4.217 JDIMM4.218 JDIMM4.222 JDIMM4.223 JDIMM4.226 JDIMM4.227 JDIMM4.230 JDIMM4.231 JDIMM4.234 JDIMM4.235 JDIMM4.238 JDIMM4.239 JDIMM4.243 JDIMM4.244 JDIMM4.247 JDIMM4.248 JDIMM4.251 JDIMM4.252 JDIMM4.261 JDIMM4.262 JELC.3 JELC.5 JELC.9 JFAN1.5 JFAN1.6 JFAN1.7 JFAN2.5 JFAN2.6 JFAN2.7 JFC.5 JFC.9 JFC.10 JFC.11 JFC.12 JHDD.3 JHDD.6 JHDD.8 JHDD.10 JHDD.13 JHDD.14 JHDD.15 JHDD.21 JHDD.22 JHDD.23 JHDD.24 JLAN.14 JLAN.15 JPCMC.19 JPCMC.36 JPK.7 JPK.8 JPK.9 JPK.12 JPK.13 JPK.14 JPK.21 JPK.22 JPWR.11 JPWR.12 JRTC.2 JRTC.3 JRTC.4 JSSD1.1 JSSD1.3 JSSD1.9 JSSD1.15 JSSD1.21 JSSD1.27 JSSD1.33 JSSD1.39 JSSD1.45 JSSD1.51 JSSD1.57 JSSD1.71 JSSD1.73 JSSD1.75 JSSD1.76 JSSD1.77 JSSD2.1 JSSD2.3 JSSD2.9 JSSD2.15 JSSD2.21 JSSD2.27 JSSD2.33 JSSD2.39 JSSD2.45 JSSD2.51 JSSD2.57 JSSD2.71 JSSD2.73 JSSD2.75 JSSD2.76 JSSD2.77 JTOBII.2 JTOBII.6 JTOBII.7 JTOBII.8 JTP.3 JTP.10 JTP.11 JTP.17 JTP.18 JTRON.11 JTRON.12 JTRON.13 JTRON.14 JTRON.25 JTRON.26 JUSB1.4 JUSB1.7 JUSB1.11 JUSB1.12 JUSB1.13 JUSB1.14 JUSB2.4 JUSB2.7 JUSB2.10 JUSB2.11 JUSB2.12 JUSB2.13 JUSB3.4 JUSB3.7 JUSB3.10 JUSB3.11 JUSB3.12 JUSB3.13 JUSBC.1 JUSBC.2 JUSBC.3 JUSBC.4 JUSBC.5 JUSBC.6 JUSBC.A1 JUSBC.A12 JUSBC.B1 JUSBC.B12 JWDB.4 JWDB.5 JWDB.6 JWLAN.1 JWLAN.7 JWLAN.13 JWLAN.18 JWLAN.19 JWLAN.33 JWLAN.39 JWLAN.45 JWLAN.51 JWLAN.57 JWLAN.63 JWLAN.69 JWLAN.75 JWLAN.76 JWLAN.77 LE2.1 PBATT1.8 PBATT1.9 PBATT1.10 PBATT1.11 PBATT1.12 PBATT1.13 PC1.2 PC2.2 PC3.2 PC4.2 PC5.2 PC6.2 PC7.2 PC8.2 PC9.2 PC10.2 PC11.2 PC12.2 PC13.2 PC16.2 PC17.2 PC19.2 PC20.2 PC21.2 PC22.2 PC23.2 PC24.2 PC101.2 PC102.2 PC103.2 PC104.2 PC105.2 PC106.2 PC108.2 PC109.2 PC110.2 PC111.2 PC112.2 PC200.2 PC201.2 PC202.2 PC203.2 PC205.2 PC206.2 PC207.1 PC208.2 PC209.2 PC210.2 PC211.2 PC212.2 PC213.2 PC214.2 PC215.2 PC216.2 PC217.2 PC218.2 PC219.2 PC220.2 PC301.2 PC302.2 PC303.2 PC304.2 PC305.2 PC306.2 PC307.2 PC308.2 PC309.2 PC312.2 PC313.2 PC314.2 PC315.2 PC316.2 PC317.2 PC318.2 PC319.2 PC705.2 PC711.1 PC748.2 PC749.1 PC751.1 PC752.1 PC753.1 PC757.1 PC760.2 PC761.2 PC762.2 PC763.2 PC764.2 PC765.2 PC766.2 PC767.2 PC768.1 PC769.1 PC775.2 PC776.2 PC777.2 PC778.2 PC780.2 PC781.2 PC792.2 PC793.2 PC794.2 PC795.2 PC796.2 PC797.2 PC798.2 PC800.2 PC1201.2 PC1202.2 PC1203.1 PC1205.2 PC1206.2 PC1207.2 PC1208.2 PC1802.2 PC1803.2 PC1804.2 PC1805.2 PC1806.2 PC1807.2 PC2501.2 PC2502.2 PC2503.2 PC2505.2 PC2506.2 PC2507.2 PCA01.2 PCA02.2 PCA03.2 PCA04.2 PCA05.2 PCA06.2 PCA07.2 PCA08.2 PCA09.2 PCA12.2 PCA13.2 PCA15.2 PCA16.2 PCA17.2 PCA18.2 PCA19.2 PCA20.2 PCA21.2 PCA22.2 PCA23.2 PCA24.2 PCA25.2 PCA26.2 PCF01.2 PCF02.2 PCF03.2 PCF04.2 PCF05.2 PCF07.2 PCF08.2 PCF09.2 PCF10.2 PCF12.2 PCF13.2 PCF14.2 PCF15.2 PCG01.1 PCG02.2 PCG04.2 PCG05.2 PCG06.2 PCG07.2 PCG08.2 PCG09.2 PCG10.2 PCG11.2 PCG12.2 PCG13.1 PCG15.2 PCG16.2 PCG17.2 PCG18.2 PCG19.2 PCG20.2 PCG21.2 PCG22.2 PCG23.2 PCG24.2 PCG25.2 PCG26.2 PCG27.2 PCG28.2 PCG29.2 PCG30.2 PCG31.2 PCG32.2 PCG33.2 PCG34.2 PCG35.2 PCG36.2 PCG37.2 PCG38.2 PCG39.2 PCI06.2 PCI07.1 PCI09.2 PCI10.2 PCI11.2 PCI12.2 PCI13.2 PCI14.2 PCI15.2 PCI16.2 PCI17.2 PCI18.2 PCI19.1 PCI21.2 PCI25.2 PCI26.2 PCI27.2 PCI28.2 PCI29.2 PCI35.2 PCI36.1 PCI38.2 PCI39.2 PCI40.2 PCI41.2 PCI42.2 PCI43.2 PCI44.2 PCI45.2 PCI46.2 PCI48.1 PCI49.2 PCI50.2 PCI51.2 PCI52.2 PCI53.2 PCI54.2 PCI55.2 PCI56.2 PCI62.2 PCI63.1 PCI65.2 PCI66.2 PCI67.2 PCI68.2 PCI69.2 PCI70.2 PCI71.2 PCI72.2 PCI73.2 PCI74.1 PCI76.2 PCI77.2 PCI78.2 PCI79.2 PCI80.2 PCI81.2 PCI82.2 PCI83.2 PCI86.2 PCI87.2 PCI88.2 PCI89.2 PCI90.2 PCI91.2 PCI92.2 PCI93.2 PCI94.2 PCI95.2 PCI96.2 PCI97.2 PCI98.2 PCI99.2 PCI100.2 PCI101.2 PCI102.2 PCI103.2 PCI104.2 PCI105.2 PCI106.2 PCI107.2 PCI108.2 PCI109.2 PCI110.2 PCI111.2 PCI112.2 PCI113.2 PCI114.2 PCI115.2 PCI116.2 PCI117.2 PCI118.2 PCI119.2 PCI120.2 PCI121.2 PCI122.2 PCI123.2 PCI124.2 PCI125.2 PCI126.2 PCI127.2 PCI128.2 PCI129.2 PCI130.2 PCI131.2 PCI132.2 PCI133.2 PCI134.2 PCI135.2 PCI136.2 PCI137.2 PCI138.2 PCI139.2 PCI140.2 PCI141.2 PCI142.2 PCI143.2 PCI144.2 PCI145.2 PCI146.2 PCI147.2 PCI148.2 PCI149.2 PCI150.2 PCI201.2 PCI202.2 PCI204.2 PCI206.2 PCI208.2 PCI210.2 PCI211.2 PCI213.2 PCI215.2 PCS01.2 PCS02.2 PCS03.2 PCS04.2 PCS05.2 PCS06.2 PCS20.2 PCS21.2 PCS23.2 PCS24.2 PCS25.1 PCS27.2 PCS28.2 PCS29.2 PCS30.2 PCS31.2 PCS32.2 PCS42.2 PCS49.2 PCS50.2 PCS52.1 PCS53.1 PCS54.1 PCS56.2 PCS57.2 PCS58.2 PCS61.2 PCS62.2 PCS67.2 PCS68.1 PCS71.2 PCS72.2 PCS73.2 PCS74.2 PCS75.2 PCS76.2 PCS77.2 PCS78.2 PCS79.2 PCS81.2 PCS84.1 PCS85.1 PCS2508.2 PCS2509.2 PCS2510.2 PCS2511.2 PCZ01.2 PCZ02.2 PCZ03.2 PCZ04.2 PCZ05.1 PCZ06.1 PCZ07.1 PCZ08.1 PCZ09.2 PCZ11.2 PCZ15.2 PCZ21.2 PCZ26.2 PCZ27.1 PCZ28.1 PCZ29.2 PCZ30.1 PCZ31.2 PD1.1 PD2.1 PD3.1 PD4.1 PD200.2 PDS03.2 PDS04.2 PDS706.2 PHZ01.1 PHZ04.1 PJPDC1.2 PJPDC1.3 PJPDC1.4 PJPDC1.5 PJPDC1.6 PJPDC1.7 PJPDC2.2 PJPDC2.3 PJPDC2.4 PJPDC2.5 PJPDC2.6 PJPDC2.7 PQ2.3 PQ4.3 PQ6.1 PQ6.4 PQ7.3 PQ9.3 PQ10.1 PQ10.4 PQ11.3 PQ12.3 PQ102.1 PQ102.2 PQ102.3 PQ201.1 PQ201.2 PQ201.3 PQ202.1 PQ202.4 PQ302.1 PQ302.2 PQ302.3 PQ304.1 PQ304.2 PQ304.3 PQ708.1 PQ708.2 PQ708.3 PQ710.3 PQA01.3 PQA01.4 PQA01.5 PQS02.1 PQS02.2 PQS02.3 PQS04.1 PQS04.2 PQS04.3 PQS06.1 PQS06.2 PQS06.3 PQS08.1 PQS08.2 PQS08.3 PQS13.1 PQS13.4 PQS17.1 PQS17.4 PQS18.3 PQS19.3 PQS23.3 PQS28.3 PQS29.1 PQS29.4 PQS30.1 PQS30.4 PQS32.3 PR2.2 PR7.2 PR21.2 PR26.2 PR28.2 PR34.2 PR35.2 PR37.2 PR41.2 PR103.1 PR106.2 PR108.2 PR207.2 PR216.2 PR217.2 PR303.1 PR304.2 PR305.1 PR306.1 PR307.2 PR317.2 PR727.2 PR731.2 PR732.2 PR751.1 PR752.1 PR753.1 PR755.1 PR779.1 PR1204.2 PR1205.2 PR1802.2 PR1805.2 PR2502.2 PR2505.2 PRA08.1 PRA11.1 PRA15.1 PRA16.2 PRA22.2 PRF06.2 PRF10.2 PRF11.1 PRG10.1 PRI202.2 PRI207.2 PRI214.2 PRI216.2 PRI226.2 PRI228.2 PRS18.1 PRS38.1 PRS53.2 PRS55.2 PRS61.2 PRS62.2 PRS65.2 PRS68.2 PRS76.2 PRS77.2 PRS78.2 PRS79.2 PRZ11.1 PRZ14.1 PRZ17.2 PRZ18.2 PRZ19.2 PRZ20.2 PRZ27.2 PRZ39.2 PRZ40.1 PRZ45.1 PU101.11 PU201.1 PU201.3 PU201.14 PU201.21 PU301.21 PU703.33 PU1201.4 PU1201.5 PU1201.11 PU1801.8 PU1801.9 PU2501.8 PU2501.9 PUA01.20 PUA01.21 PUF01.7 PUF01.8 PUF01.18 PUF01.21 PUG01.4 PUG01.10 PUG01.23 PUG01.28 PUG02.4 PUG02.10 PUG02.23 PUG02.28 PUI01.4 PUI01.10 PUI01.23 PUI01.28 PUI02.4 PUI02.10 PUI02.23 PUI02.28 PUI03.4 PUI03.10 PUI03.23 PUI03.28 PUI04.4 PUI04.10 PUI04.23 PUI04.28 PUI05.4 PUI05.10 PUI05.23 PUI05.28 PUI06.4 PUI06.10 PUI06.23 PUI06.28 PUI07.11 PUI08.11 PUI09.11 PUS1.20 PUS1.25 PUS1.32 PUS1.33 PUS2.20 PUS2.32 PUS2.33 PUZ01.49 Q7.1 Q7.4 Q8.1 Q8.4 Q9.1 Q9.4 Q2410.3 QE1.1 QE1.4 QE2.3 QE3.1 QE3.4 QE4.1 QE4.4 QE5.1 QE5.4 QE13.1 QE21.1 QE21.2 QE22.1 QE58.3 QE64.1 QE64.4 QE65.3 QM2.1 QM2.4 QN8.1 QN8.4 QN9.1 QN9.4 QT2.1 QT2.4 R180.2 R185.1 R369.2 R370.1 R393.1 R399.1 R400.1 R402.1 R403.1 R404.1 R405.1 R406.1 R407.1 R411.1 RC26.2 RC35.2 RC348.2 RC686.2 RC687.2 RC690.2 RD4.1 RD5.1 RD6.1 RD10.1 RD11.1 RD15.1 RD16.1 RD17.1 RD29.1 RD30.1 RD31.1 RD41.1 RD42.1 RD43.1 RD54.1 RD56.1 RE5.2 RE31.2 RE42.2 RE44.2 RE66.1 RE75.2 RE83.2 RE645.2 RE650.2 RE662.2 RE685.2 RE693.2 RE699.2 RH9.2 RH11.2 RH14.2 RH26.2 RH28.2 RH30.2 RH88.1 RH109.2 RH135.1 RH184.2 RH185.2 RH186.2 RH187.2 RH188.2 RH199.2 RH213.2 RH214.2 RH215.2 RH216.2 RH220.1 RH580.2 RH581.2 RH589.1 RH590.1 RH628.1 RH635.1 RH636.1 RH637.2 RH1024.2 RH1025.2 RL4.1 RL10.1 RL11.1 RL14.1 RL22.2 RL25.2 RL43.2 RL51.1 RL53.1 RM6.1 RM17.1 RM21.1 RM23.1 RM25.1 RM29.2 RM38.2 RM42.2 RM62.1 RM64.2 RM70.1 RM72.2 RM75.1 RM82.1 RM84.1 RM87.2 RN6.2 RN8.2 RN30.2 RT3.2 RT4.2 RT5.2 RT11.2 RT17.2 RT18.2 RT19.2 RT22.2 RT34.2 RT35.2 RT37.2 RT38.2 RT39.2 RT40.2 RT41.2 RT42.2 RT43.2 RT44.2 RT45.2 RT46.2 RT47.2 RT62.2 RT63.2 RT64.2 RT65.2 RT68.2 RT69.2 RT71.2 RT72.2 RT73.2 RT75.2 RT78.2 RT79.2 RT80.2 RT83.1 RT108.2 RT125.2 RT126.2 RT127.2 RT128.2 RT129.2 RT131.1 RT200.1 RT216.2 RT219.2 RT221.1 RT223.2 RT224.1 RT227.1 RT229.1 RT230.1 RT234.1 RT235.1 RT238.1 RT239.1 RT241.2 RT243.1 RT247.2 RT248.1 RT249.2 RT693.2 RT711.2 RT712.2 RT724.2 RT725.2 RT726.2 RU2.1 RU3.1 RV1.2 SW2.3 SW2.4 SW2.5 SW2.6 SW3.3 SW3.4 SW3.5 SW3.6 U16.5 U17.11 U17.15 U18.2 U19.5 U2407.6 U2408.5 UC1.A4 UC1.A7 UC1.A11 UC1.A13 UC1.A15 UC1.A17 UC1.A24 UC1.AA3 UC1.AA8 UC1.AA33 UC1.AB5 UC1.AB39 UC1.AC3 UC1.AC6 UC1.AC33 UC1.AC34 UC1.AC35 UC1.AD1 UC1.AD4 UC1.AD6 UC1.AD7 UC1.AD8 UC1.AD33 UC1.AD36 UC1.AD37 UC1.AD38 UC1.AD39 UC1.AD40 UC1.AE3 UC1.AE5 UC1.AE8 UC1.AE33 UC1.AE36 UC1.AF1 UC1.AF5 UC1.AF8 UC1.AF33 UC1.AF36 UC1.AF37 UC1.AF40 UC1.AG1 UC1.AG2 UC1.AG3 UC1.AG4 UC1.AG5 UC1.AG8 UC1.AG33 UC1.AG36 UC1.AH5 UC1.AH8 UC1.AH33 UC1.AH36 UC1.AH37 UC1.AH38 UC1.AH39 UC1.AH40 UC1.AJ1 UC1.AJ4 UC1.AJ5 UC1.AJ8 UC1.AJ24 UC1.AJ30 UC1.AJ31 UC1.AJ32 UC1.AJ33 UC1.AJ34 UC1.AJ35 UC1.AJ36 UC1.AK5 UC1.AK6 UC1.AK7 UC1.AK8 UC1.AK9 UC1.AK10 UC1.AK12 UC1.AK13 UC1.AK15 UC1.AK16 UC1.AK17 UC1.AK18 UC1.AK19 UC1.AK20 UC1.AK22 UC1.AK23 UC1.AK25 UC1.AK26 UC1.AK27 UC1.AK28 UC1.AK29 UC1.AK30 UC1.AK36 UC1.AK37 UC1.AK40 UC1.AL1 UC1.AL2 UC1.AL3 UC1.AL4 UC1.AL5 UC1.AL11 UC1.AL14 UC1.AL21 UC1.AL24 UC1.AL27 UC1.AL30 UC1.AL36 UC1.AM5 UC1.AM11 UC1.AM14 UC1.AM17 UC1.AM19 UC1.AM24 UC1.AM27 UC1.AM30 UC1.AM31 UC1.AM32 UC1.AM33 UC1.AM34 UC1.AM35 UC1.AM36 UC1.AM37 UC1.AM38 UC1.AM39 UC1.AM40 UC1.AN1 UC1.AN4 UC1.AN5 UC1.AN6 UC1.AN7 UC1.AN8 UC1.AN9 UC1.AN10 UC1.AN11 UC1.AN14 UC1.AN16 UC1.AN19 UC1.AN22 UC1.AN23 UC1.AN24 UC1.AN27 UC1.AN30 UC1.AN36 UC1.AP5 UC1.AP11 UC1.AP14 UC1.AP24 UC1.AP27 UC1.AP30 UC1.AP36 UC1.AP37 UC1.AP40 UC1.AR1 UC1.AR2 UC1.AR3 UC1.AR4 UC1.AR5 UC1.AR11 UC1.AR14 UC1.AR16 UC1.AR17 UC1.AR18 UC1.AR19 UC1.AR20 UC1.AR21 UC1.AR22 UC1.AR23 UC1.AR24 UC1.AR27 UC1.AR30 UC1.AR31 UC1.AR32 UC1.AR33 UC1.AR34 UC1.AR35 UC1.AR36 UC1.AT5 UC1.AT6 UC1.AT7 UC1.AT8 UC1.AT9 UC1.AT10 UC1.AT11 UC1.AT12 UC1.AT13 UC1.AT14 UC1.AT15 UC1.AT17 UC1.AT24 UC1.AT25 UC1.AT26 UC1.AT27 UC1.AT28 UC1.AT29 UC1.AT30 UC1.AT31 UC1.AT32 UC1.AT34 UC1.AT36 UC1.AT37 UC1.AT38 UC1.AT39 UC1.AT40 UC1.AU1 UC1.AU4 UC1.AU5 UC1.AU7 UC1.AU25 UC1.AU30 UC1.AU34 UC1.AU39 UC1.AU40 UC1.AV2 UC1.AV5 UC1.AV9 UC1.AV26 UC1.AV28 UC1.AV30 UC1.AV34 UC1.AV38 UC1.AV39 UC1.AW3 UC1.AW5 UC1.AW9 UC1.AW30 UC1.AW32 UC1.AW34 UC1.AW36 UC1.AW38 UC1.AY5 UC1.AY7 UC1.AY9 UC1.AY27 UC1.AY30 UC1.B6 UC1.B24 UC1.B26 UC1.B28 UC1.B30 UC1.B38 UC1.C2 UC1.C5 UC1.C8 UC1.C10 UC1.C12 UC1.C14 UC1.C16 UC1.C18 UC1.C20 UC1.C22 UC1.C24 UC1.C31 UC1.C33 UC1.C35 UC1.C37 UC1.D4 UC1.D7 UC1.D24 UC1.D26 UC1.D28 UC1.D30 UC1.D37 UC1.D39 UC1.D40 UC1.E3 UC1.E6 UC1.E9 UC1.E11 UC1.E13 UC1.E15 UC1.E17 UC1.E19 UC1.E21 UC1.E23 UC1.E31 UC1.E33 UC1.E35 UC1.E37 UC1.F1 UC1.F4 UC1.F7 UC1.F10 UC1.F22 UC1.F26 UC1.F28 UC1.F30 UC1.F36 UC1.F40 UC1.G3 UC1.G6 UC1.G11 UC1.G13 UC1.G15 UC1.G17 UC1.G19 UC1.G22 UC1.G31 UC1.G33 UC1.H1 UC1.H4 UC1.H7 UC1.H9 UC1.H11 UC1.H12 UC1.H21 UC1.H24 UC1.H26 UC1.H28 UC1.H30 UC1.H35 UC1.H37 UC1.H39 UC1.J3 UC1.J6 UC1.J10 UC1.J12 UC1.J16 UC1.J18 UC1.J20 UC1.J32 UC1.J34 UC1.K1 UC1.K4 UC1.K7 UC1.K14 UC1.K15 UC1.K17 UC1.K19 UC1.K22 UC1.K24 UC1.K26 UC1.K28 UC1.K30 UC1.K33 UC1.K35 UC1.K37 UC1.K39 UC1.L3 UC1.L6 UC1.L9 UC1.L11 UC1.L13 UC1.L32 UC1.M1 UC1.M4 UC1.M7 UC1.M10 UC1.M12 UC1.M15 UC1.M17 UC1.M19 UC1.M21 UC1.M23 UC1.M25 UC1.M27 UC1.M29 UC1.M35 UC1.M37 UC1.M39 UC1.N3 UC1.N6 UC1.N8 UC1.N33 UC1.P1 UC1.P4 UC1.P35 UC1.P37 UC1.P39 UC1.R3 UC1.R6 UC1.R8 UC1.R33 UC1.T1 UC1.T4 UC1.T35 UC1.T37 UC1.T39 UC1.U3 UC1.U6 UC1.U33 UC1.V1 UC1.V8 UC1.V35 UC1.V37 UC1.V39 UC1.W3 UC1.W6 UC1.W33 UC1.Y5 UC1.Y35 UC1.Y37 UC2.3 UE1.8 UE1.23 UE1.28 UE1.35 UE1.47 UE2.4 UE3.7 UE3.18 UE3.23 UE3.33 UE5.11 UE5.24 UE5.35 UE5.94 UE5.113 UE6.12 UE6.25 UE9.2 UE10.12 UE10.23 UE10.25 UE12.2 UE13.2 UH1.A2 UH1.A3 UH1.A4 UH1.A5 UH1.A8 UH1.A28 UH1.A33 UH1.A37 UH1.A45 UH1.A46 UH1.A47 UH1.A48 UH1.AA5 UH1.AA19 UH1.AA20 UH1.AA25 UH1.AA27 UH1.AA28 UH1.AA30 UH1.AA31 UH1.AA49 UH1.AB19 UH1.AB25 UH1.AB31 UH1.AC4 UH1.AC12 UH1.AC17 UH1.AC33 UH1.AC38 UH1.AC46 UH1.AD1 UH1.AD2 UH1.AD19 UH1.AD22 UH1.AD25 UH1.AD49 UH1.AE4 UH1.AE12 UH1.AE33 UH1.AE38 UH1.AE46 UH1.AF22 UH1.AF25 UH1.AF28 UH1.AG1 UH1.AG22 UH1.AG23 UH1.AG25 UH1.AG27 UH1.AG28 UH1.AG30 UH1.AG49 UH1.AH12 UH1.AH17 UH1.AH33 UH1.AH38 UH1.AJ19 UH1.AJ20 UH1.AJ25 UH1.AJ27 UH1.AJ28 UH1.AJ30 UH1.AJ31 UH1.AK4 UH1.AK19 UH1.AK20 UH1.AK25 UH1.AK27 UH1.AK28 UH1.AK30 UH1.AK31 UH1.AK46 UH1.AL12 UH1.AL17 UH1.AL21 UH1.AL24 UH1.AL26 UH1.AL29 UH1.AL33 UH1.AL38 UH1.AM1 UH1.AM18 UH1.AM32 UH1.AM49 UH1.AN12 UH1.AN16 UH1.AN34 UH1.AN38 UH1.AP4 UH1.AP46 UH1.AR12 UH1.AR16 UH1.AR34 UH1.AR38 UH1.AT1 UH1.AT16 UH1.AT18 UH1.AT21 UH1.AT24 UH1.AT26 UH1.AT29 UH1.AT32 UH1.AT34 UH1.AT45 UH1.AV11 UH1.AV39 UH1.AW4 UH1.AW10 UH1.AW40 UH1.AW46 UH1.B47 UH1.B48 UH1.B49 UH1.BA5 UH1.BA6 UH1.BA12 UH1.BA14 UH1.BA44 UH1.BB9 UH1.BB41 UH1.BB43 UH1.BC8 UH1.BC10 UH1.BC13 UH1.BC15 UH1.BC19 UH1.BC24 UH1.BC26 UH1.BC31 UH1.BC35 UH1.BC40 UH1.BC45 UH1.BD43 UH1.BE44 UH1.BF1 UH1.BF2 UH1.BF3 UH1.BF48 UH1.BF49 UH1.BG2 UH1.BG3 UH1.BG4 UH1.BG17 UH1.BG22 UH1.BG25 UH1.BG28 UH1.BG33 UH1.BG37 UH1.BG48 UH1.C4 UH1.C5 UH1.C12 UH1.C25 UH1.C30 UH1.C48 UH1.D8 UH1.D12 UH1.D16 UH1.D17 UH1.D30 UH1.D33 UH1.E8 UH1.E10 UH1.E13 UH1.E15 UH1.E17 UH1.E19 UH1.E22 UH1.E24 UH1.E26 UH1.E31 UH1.E33 UH1.E35 UH1.E40 UH1.E42 UH1.F41 UH1.F43 UH1.F47 UH1.G6 UH1.G44 UH1.H8 UH1.J4 UH1.J9 UH1.J10 UH1.J26 UH1.J29 UH1.J40 UH1.J46 UH1.J47 UH1.J48 UH1.K11 UH1.K39 UH1.M5 UH1.M16 UH1.M18 UH1.M21 UH1.M24 UH1.M32 UH1.M34 UH1.M49 UH1.N12 UH1.N16 UH1.N34 UH1.N35 UH1.N37 UH1.N38 UH1.P4 UH1.P26 UH1.P29 UH1.P46 UH1.R3 UH1.R4 UH1.R12 UH1.R16 UH1.R26 UH1.R29 UH1.R34 UH1.R38 UH1.T4 UH1.T5 UH1.T7 UH1.T17 UH1.T18 UH1.T32 UH1.T49 UH1.U12 UH1.U15 UH1.U17 UH1.U21 UH1.U24 UH1.U33 UH1.U38 UH1.V4 UH1.V20 UH1.V22 UH1.V46 UH1.W25 UH1.W27 UH1.W28 UH1.W30 UH1.Y9 UH1.Y10 UH1.Y12 UH1.Y17 UH1.Y33 UH1.Y38 UH3.3 UH4.4 UL1.60 UL1.89 UL4.5 UL10.4 UL10.8 UL10.9 UL11.4 UL11.8 UL11.9 UL13.4 UL13.8 UL13.9 UL14.2 UM3.3 UM4.6 UM4.15 UM4.19 UM7.3 UM8.25 UM8.55 US1.5 US1.10 US1.12 US1.13 US1.15 US1.16 US2.2 US2.3 US2.6 US2.7 US3.5 US3.6 US3.7 US3.8 UT1.A1 UT1.A6 UT1.A8 UT1.A10 UT1.A12 UT1.A14 UT1.A16 UT1.A18 UT1.A20 UT1.A22 UT1.AA22 UT1.AA23 UT1.AB1 UT1.AB2 UT1.AB6 UT1.AB8 UT1.AB10 UT1.AB12 UT1.AB14 UT1.AB16 UT1.AB18 UT1.AB20 UT1.AB22 UT1.AC1 UT1.AC2 UT1.AC6 UT1.AC8 UT1.AC10 UT1.AC12 UT1.AC14 UT1.AC16 UT1.AC18 UT1.AC20 UT1.AC22 UT1.B1 UT1.B2 UT1.B6 UT1.B8 UT1.B10 UT1.B12 UT1.B14 UT1.B16 UT1.B18 UT1.B20 UT1.B22 UT1.C22 UT1.C23 UT1.D5 UT1.D6 UT1.D8 UT1.D9 UT1.D11 UT1.D12 UT1.D13 UT1.D15 UT1.D16 UT1.D18 UT1.E4 UT1.E5 UT1.E6 UT1.E8 UT1.E9 UT1.E11 UT1.E15 UT1.E16 UT1.E22 UT1.E23 UT1.F5 UT1.F6 UT1.F9 UT1.F16 UT1.F20 UT1.G22 UT1.G23 UT1.H1 UT1.H2 UT1.H5 UT1.H8 UT1.H12 UT1.H13 UT1.H15 UT1.H16 UT1.H20 UT1.J5 UT1.J8 UT1.J12 UT1.J13 UT1.J15 UT1.J18 UT1.J19 UT1.J20 UT1.J22 UT1.J23 UT1.K1 UT1.K2 UT1.L5 UT1.L13 UT1.L15 UT1.L20 UT1.L22 UT1.L23 UT1.M1 UT1.M2 UT1.M5 UT1.M11 UT1.M12 UT1.M19 UT1.M20 UT1.N5 UT1.N8 UT1.N9 UT1.N11 UT1.N12 UT1.N13 UT1.N15 UT1.N20 UT1.N22 UT1.N23 UT1.P1 UT1.P2 UT1.R5 UT1.R18 UT1.R19 UT1.R20 UT1.R22 UT1.R23 UT1.T1 UT1.T2 UT1.T5 UT1.T6 UT1.T8 UT1.T9 UT1.T13 UT1.T15 UT1.T16 UT1.T18 UT1.T20 UT1.U22 UT1.U23 UT1.V5 UT1.V6 UT1.V8 UT1.V9 UT1.V15 UT1.V16 UT1.V20 UT1.W5 UT1.W6 UT1.W8 UT1.W9 UT1.W13 UT1.W18 UT1.W20 UT1.W22 UT1.W23 UT1.Y9 UT1.Y13 UT1.Y20 UT2.4 UT3.3 UT4.A1 UT4.B8 UT4.D8 UT4.E5 UT4.E6 UT4.E7 UT4.E8 UT4.F5 UT4.F6 UT4.F7 UT4.F8 UT4.G5 UT4.G6 UT4.G7 UT4.G8 UT4.H4 UT4.H5 UT4.H8 UT4.L1 UT4.L11 UT5.5 UT5.9 UT6.55 UT7.6 UT7.15 UT7.19 UT8.2 UT10.2 UU1.14 UU1.17 UU3.2 UU5.3 UU6.10 UU6.21 UU6.25 UV64.5 UV65.2 UZ21.5 UZ21.9 YE1.2 YE1.4 YH2.2 YH2.4 YL1.2 YL1.4 YT1.2 YT1.4
PD100_3/5V: PD301.1 PR314.1
VBAT_CHG: PR745.1 PU703.26
VCC_CORE_PH1: PLI01.1 PRI17.1 PUI01.11 PUI01.12 PUI01.13 PUI01.14 PUI01.15 PUI01.16 PUI01.17 PUI01.18 PUI01.19 PUI01.20 PUI01.21
VCC_CORE_PH2: PLI02.1 PRI35.1 PUI02.11 PUI02.12 PUI02.13 PUI02.14 PUI02.15 PUI02.16 PUI02.17 PUI02.18 PUI02.19 PUI02.20 PUI02.21
VCC_CORE_PH3: PLI03.1 PRI58.1 PUI03.11 PUI03.12 PUI03.13 PUI03.14 PUI03.15 PUI03.16 PUI03.17 PUI03.18 PUI03.19 PUI03.20 PUI03.21
VCC_CORE_PH4: PLI04.1 PRI73.1 PUI04.11 PUI04.12 PUI04.13 PUI04.14 PUI04.15 PUI04.16 PUI04.17 PUI04.18 PUI04.19 PUI04.20 PUI04.21
VCC_CORE_PH5: PLI05.1 PRI98.1 PUI05.11 PUI05.12 PUI05.13 PUI05.14 PUI05.15 PUI05.16 PUI05.17 PUI05.18 PUI05.19 PUI05.20 PUI05.21
VCC_CORE_PH6: PLI06.1 PRI113.1 PUI06.11 PUI06.12 PUI06.13 PUI06.14 PUI06.15 PUI06.16 PUI06.17 PUI06.18 PUI06.19 PUI06.20 PUI06.21
VCC_GT_PH1: PLG01.1 PRG07.1 PUG01.11 PUG01.12 PUG01.13 PUG01.14 PUG01.15 PUG01.16 PUG01.17 PUG01.18 PUG01.19 PUG01.20 PUG01.21
VCC_GT_PH2: PLG02.1 PRG19.1 PUG02.11 PUG02.12 PUG02.13 PUG02.14 PUG02.15 PUG02.16 PUG02.17 PUG02.18 PUG02.19 PUG02.20 PUG02.21
VCC_VCCIO: PCF13.1 PUF01.16 PUF01.17
VCC_VCCSA: PCA09.1 PRA01.1 PRA14.1 PUA01.17
VCC_VCORE: PCZ03.1 PRZ03.2 PUZ01.42
VCCGT_VCC_SEN: PCZ10.1 PRZ28.2 RC691.2 UC1.F39
VCCGT_VSS_SEN: PCZ11.1 PUZ01.6 RC690.1 UC1.F38
VCCIO_PGOOD: PRF02.2 PUF01.9
VCCIO_SENSE: PRF08.2 UC1.AF4
VCCPLL_OC: CC46.2 RC21.1 RC25.1 UC1.AJ9
VCCSA_SENSE: PRA19.2 UC1.AD5
VCCSA_SENSEN: PRA10.2 PRA21.1 PRA22.1
VCCSA_SENSEP: PRA07.2 PRA18.1
VCCST_PWEGD_R: RC13.2 UC1.U2
VDD_1.2V: PC212.1 PR201.1 PR203.2 PU201.11
VDD_CHG: PC768.2 PR741.1 PR749.2 PR750.2 PR760.1 PU703.19
VDD_ISL95338_1: PCS25.2 PRS09.2 PRS54.1 PRS94.1 PUS1.18
VDD_ISL95338_2: PCS54.2 PRS29.2 PRS56.1 PRS95.1 PUS2.18 PUS2.25
VDDP_1.2V: PC207.2 PD200.1 PR204.2 PU201.12
VDDP_ISL95338_1: PCS24.1 PRS09.1 PUS1.8
VDDP_ISL95338_2: PCS53.2 PRS29.1 PUS2.8
VDDSPD1: CD22.1 CD23.2 JDIMM1.255 RD58.1
VDDSPD2: CD54.1 CD55.2 JDIMM3.255 RD59.1
VDDSPD3: CD85.1 CD86.2 JDIMM2.255 RD60.1
VDDSPD4: CD116.1 CD117.2 JDIMM4.255 RD61.1
VSSSAIO_SENSE: PRA21.2 UC1.AE4
+EC_VCCA: CE172.1 LE1.2 UE5.67
+EVDD09: CL77.1 CL78.1 CL79.1 CL80.1 CL81.1 CL82.1 RL40.1 UL1.54 UL1.55 UL1.63
+EVDD18: CL62.1 CL63.1 RL50.1 UL1.53
+LCDVDD: CV1079.1 CV1082.1 CV1083.1 CV1084.1 CV1085.1 CV1101.1 CV1102.1 CV1104.1 CV1107.1 CV1108.1 CV1109.1 JFC.6 JFC.7 JFC.8 RV2.1 UV64.6 UV65.1
+PWR_SRC: CV23.1 CV24.1 JDG.6 JDG.7 JDG.8 JDG.9 JDG.10 PC18.1 PC797.1 PC798.1 PC800.1 PCI09.1 PCI10.1 PD705.1 PJP101.2 PJP203.1 PJPA01.1 PJPF01.1 PL311.1 PL312.1 PL711.1 PLI11.1 PLI12.1 PQ8.4 PQ717.5 PR19.1 PR703.4
+RTC_CELL: CH80.1 CH81.1 CH173.1 CH226.1 PD5.1 QE58.1 RH83.1 RH84.1 RH531.2 UH1.BC49 UH1.BD49
+SDC: PQS31.1 PRS96.2 PRS97.1
+SDC_IN: PCS04.1 PCS05.1 PCS06.1 PCS31.1 PCS32.1 PCS62.1 PCS75.1 PCS76.1 PCS77.1 PCS78.1 PDS706.1 PQS05.5 PQS11.5 PQS22.1 PQS24.1 PQS31.3 PR703.1 PRS13.2 PRS33.2 PRS96.1 PUS1.1 PUS1.2 PUS2.1 PUS2.2
+SDC_PWR: PRS19.2 PRS39.2 PRS97.2
+TBTA_VBUS: CT94.2 CT95.2 CT96.1 CT97.1 CT106.1 DT1.1 DT15.2 DT15.3 JUSBC.A4 JUSBC.A9 JUSBC.B4 JUSBC.B9 UT4.A10 UT4.B10 UT4.H11 UT4.J10 UT4.J11 UT4.K11
AC_PRESENT: DH1.2 RH533.1 RH1025.1 UH1.BG42
ACC1_INT1: RH619.1 US2.4
ACC_ADDRESS: RS16.1 US3.3
ACC_INT1: RH622.1 US3.12
ACC_INT2: RH623.1 US3.11
ACIN#: QE3.3 RE17.2 UE1.18
ACIN_CHG: PC711.2 PR729.2 PR732.1 PU703.1
ACIN_ISL95338_1: PRS73.2 PUS1.19
ACIN_ISL95338_2: PRS74.2 PUS2.19
ACIN_R_1: PCS84.2 PQS18.1 PQS29.6 PRS73.1 PRS75.2 PRS76.1
ACLIM_CHG: PR749.1 PR751.2 PU703.16
ACOK_ISL95338_1: PC23.1 PR35.1 PR36.2 UE5.71
ACOK_ISL95338_2: PC24.1 PR37.1 PR38.2 UE5.72
AD0_0: RE43.2 UE3.31
AD1_0: RE40.2 UE3.32
AD2_0: RE42.1 UE3.1
AD3_0: RE44.1 UE3.2
AD_BID: CE28.1 RE64.1 RE66.2 UE5.66
ADP_I: PC748.1 PR23.1 PR774.1 UE5.65
ADPS_ISL95338_1: PCS67.1 PRS06.2 PUS1.13 PUS1.16
ADPS_ISL95338_2: PCS68.2 PRS26.1 PUS2.13 PUS2.16
AMON_CHG: PR774.2 PU703.6
AMP_SPI_CS_L1: JAUDIO.14 UE5.128
AMP_SPI_CS_L2: JAUDIO.15 UE5.68
AMP_SPI_CS_R1: JAUDIO.16 UE5.34
AMP_SPI_CS_R2: JAUDIO.17 UE5.15
AMP_SPI_MISO: JAUDIO.19 UE5.119
AMP_SPI_MOSI: JAUDIO.18 UE5.120
AMP_SPI_SCLK: JAUDIO.20 UE5.126
ASGATE_CHG: PC791.2 PU703.30
B+_BIAS: JAUDIO.1 JAUDIO.2 JAUDIO.3 JAUDIO.4 PC16.1 PQ8.1 PQ8.2 PQ8.5 PQ8.6 R179.2
B+_VCCIO: PCF01.1 PCF02.1 PCF03.1 PCF04.1 PCF05.1 PJPF01.2 PUF01.2 PUF01.3 PUF01.4 PUF01.5
BA: PQ709.1 PR793.2 PRB66.1
BA_PWR: PDS705.2 PRB66.2
BATGONE_CHG: PR764.2 PU703.13
BATLOW#: RT14.1 RT31.2 UT1.F2
BATT+: PC9.1 PC10.1 PC761.1 PC766.1 PC775.1 PC776.1 PC777.1 PC778.1 PC795.1 PC796.1 PL13.1 PL14.1 PQ709.3 PR745.2 PR765.4 PR793.1
BATT++: PBATT1.1 PBATT1.2 PBATT1.3 PBATT1.4 PC11.1 PC12.1 PL13.2 PL14.2
BATT_CHG_LED: QE1.6 RE23.2 UE1.19
BATT_CHG_LED#: QE1.2 UE10.2
BATT_LOW_LED: QE3.6 RE21.2 UE1.13
BATT_LOW_LED#: QE3.2 UE10.5
BATT_PRS: PBATT1.7 PR13.1
BBS_BIT0: RH130.2 UH1.BA26
BEEP#: JAUDIO.5 UE5.23
BGATE_CHG: PR773.1 PU703.25
BKOFF#: JDGFF1.A5 UE5.105
BMON_CHG: PR775.2 PU703.7
BOARD_ID: RH21.1 UH1.BA20
BOOT_1.2V: PR200.2 PU201.18
BST1_ISL95338_1: PCS22.2 PUS1.12
BST1_ISL95338_2: PCS51.2 PUS2.12
BST1_R_ISL95338_1: PCS22.1 PRS04.2
BST1_R_ISL95338_2: PCS51.1 PRS24.2
BST2_3V: PC310.2 PR309.1
BST2_5V: PC311.1 PR308.2
BST2_+1VALWP: PC107.1 PR102.2
BST2_ISL95338_1: PCS26.1 PUS1.4
BST2_ISL95338_2: PCS55.1 PUS2.4
BST2_R_ISL95338_1: PCS26.2 PRS11.1
BST2_R_ISL95338_2: PCS55.2 PRS31.1
BST2_VCCIO: PCF06.1 PRF03.2
BST_1.2V: PC204.1 PR200.1
BST_3V: PR309.2 PU301.9
BST_5V: PR308.1 PU301.17
BST_+1VALWP: PR102.1 PU101.10
BST_CHG: PR771.1 PU703.24
BST_CHG_R: PC721.1 PR771.2
BST_VCCIO: PRF03.1 PUF01.1
BST_VCCSA: PRA03.2 PUA01.16
BST_VCCSA_R: PCA10.2 PRA03.1
BT_OFF#: DN2.1 RH517.2 RH706.2 UH1.BA24
BT_OFF#_R: DN2.2 JWLAN.54
BUSPOWER#: RT130.2 RT131.2 UT4.F10
CALDERA_ON: JCDRA.1 RM41.2 UE5.49 UM7.2
CALDERA_PRSNT#: JCDRA.21 RM5.2 RM61.1 UE1.22 UE5.56
CALDERA_PWRGD: JCDRA.2 RM42.1 UE5.46
CALDERA_RST#: RM6.2 UE5.45 UM3.1
CCLIM_CHG: PR750.1 PR752.2 PU703.11
CDR_BTN#: JCDRA.26 RM17.2 UE5.125
CDR_ON_ELC: UE1.21 UM7.4
CDR_TXRX_GOOD: UE5.40 UM7.1
CDRA_CLK: JCDRA.45 RM1.1
CDRA_DAT: JCDRA.46 RM2.1
CDRA_LED_RED: JCDRA.28 QM3.1
CDRA_LED_RED_MOS: QM2.5 UE10.10
CDRA_LED_RED_R: QM3.3 RM93.2
CDRA_LED_WHITE: JCDRA.27 QM1.1
CDRA_LED_WHITE_MOS: QM2.2 UE5.21
CDRA_LED_WHITE_R: QM1.3 RM91.2
CDRA_RST#: JCDRA.22 UM3.4
CFG0: JPCMC.1 RH637.1 UC1.H15
CFG2: JPCMC.5 RH184.1 UC1.F16
CFG3: JPCMC.7 RC688.2 UC1.H16
CFG4: JPCMC.9 RH185.1 UC1.F19
CFG5: JPCMC.11 RH186.1 UC1.H18
CFG6: JPCMC.13 RH187.1 UC1.G21
CFG7: JPCMC.15 RH188.1 UC1.H20
CFG8: JPCMC.2 UC1.G16
CFG9: JPCMC.4 UC1.E16
CFG10: JPCMC.6 UC1.F17
CFG11: JPCMC.8 UC1.H17
CFG12: JPCMC.10 UC1.G20
CFG13: JPCMC.12 UC1.F20
CFG14: JPCMC.14 UC1.F21
CFG15: JPCMC.16 UC1.H19
CFG16: JPCMC.21 UC1.E14
CFG17: JPCMC.17 UC1.F14
CFG18: JPCMC.20 UC1.G18
CFG19: JPCMC.18 UC1.F18
CFG_RCOMP: RC26.1 UC1.M11
CHR_USB20_N1: LU3.1 UU1.11
CHR_USB20_N1_R: DU9.3 JUSB1.2 LU3.2
CHR_USB20_P1: LU3.4 UU1.10
CHR_USB20_P1_R: DU9.2 JUSB1.3 LU3.3
CKXTAL1: CL3.1 RL12.1 YL1.1
CKXTAL1_R: RL12.2 UL1.79
CKXTAL2: CL4.1 RL13.1 YL1.3
CKXTAL2_R: RL13.2 UL1.78
CLK_CNV_PRX_DTX_N: RN102.1 UH1.BD4
CLK_CNV_PRX_DTX_N_R: JWLAN.21 RN102.2
CLK_CNV_PRX_DTX_P: RN101.1 UH1.BE3
CLK_CNV_PRX_DTX_P_R: JWLAN.23 RN101.2
CLK_CNV_PTX_DRX_N: RN108.1 UH1.BC5
CLK_CNV_PTX_DRX_N_R: JWLAN.71 RN108.2
CLK_CNV_PTX_DRX_P: RN107.1 UH1.BB6
CLK_CNV_PTX_DRX_P_R: JWLAN.73 RN107.2
CLK_PCI_ESPI: CH244.1 RH89.2 TC20.1(TP-1) UE5.12
CLK_PCIE_DGPU#_C: CM99.2 JCDRA.34
CLK_PCIE_DGPU_C: CM98.2 JCDRA.33
CLK_PCIE_N1: JSSD1.53 UH1.AH9
CLK_PCIE_N2: JSSD2.53 UH1.AE14
CLK_PCIE_N3: RT706.2 RT727.2 UH1.AE6
CLK_PCIE_N3_C: CT212.2 RT711.1 RT713.2 RT727.1 UT1.T19
CLK_PCIE_N4: UH1.AC2 UL1.59
CLK_PCIE_N5: JWLAN.49 UH1.AB2
CLK_PCIE_P1: JSSD1.55 UH1.AH10
CLK_PCIE_P2: JSSD2.55 UH1.AE15
CLK_PCIE_P3: RT705.2 RT728.2 UH1.AE7
CLK_PCIE_P3_C: CT211.2 RT712.1 RT714.2 RT728.1 UT1.V19
CLK_PCIE_P4: UH1.AC3 UL1.58
CLK_PCIE_P5: JWLAN.47 UH1.AB3
CLK_PEG_N0: JDGFF1.A8 UH1.AJ6
CLK_PEG_N6: UH1.W4 UM4.3
CLK_PEG_P0: JDGFF1.A7 UH1.AJ7
CLK_PEG_P6: UH1.W3 UM4.2
CLK_SMB: PBATT1.5 PR11.1
CLKDET#: RH558.1 UH1.BF35
CLKREQ_CNV#: QN9.2 RH725.1 RN8.1 UH1.BA17
CLKREQ_CNV#_D: JWLAN.14 QN9.3 RH723.1
CLKREQ_PCIE#1: JSSD1.52 RP3.6 UH1.BE31
CLKREQ_PCIE#2: JSSD2.52 RP3.7 UH1.AR32
CLKREQ_PCIE#3: RT2.2 RT702.2 UH1.BB30
CLKREQ_PCIE#3_R: RT2.1 RT20.2 UT1.AC5
CLKREQ_PCIE#4: RL58.2 RP3.8 UH1.BA30 UL1.42
CLKREQ_PCIE#5: JWLAN.53 RP8.2 UH1.AN29
CLKREQ_PEG#0: JDGFF2.F9 RP3.5 UH1.BF31
CLKREQ_PEG#6: RP5.2 UE5.43 UH1.AE47 UM4.17
CLKRUN#: RH85.1 UH1.AV32
CMSRC_CHG: PC791.1 PU703.29
CNV_BRI_PRX_DTX: RH181.2 RN109.2 UH1.AY2
CNV_BRI_PRX_DTX_R: JWLAN.22 RN1.2 RN109.1
CNV_BRI_PTX_DRX: RH603.2 RH1021.2 UH1.AV4
CNV_BRI_PTX_DRX_R: JWLAN.36 RH1021.1
CNV_PRX_DTX_N0: RN103.1 UH1.BB3
CNV_PRX_DTX_N0_R: JWLAN.15 RN103.2
CNV_PRX_DTX_N1: RN105.1 UH1.BA3
CNV_PRX_DTX_N1_R: JWLAN.9 RN105.2
CNV_PRX_DTX_P0: RN104.1 UH1.BB4
CNV_PRX_DTX_P0_R: JWLAN.17 RN104.2
CNV_PRX_DTX_P1: RN106.1 UH1.BA2
CNV_PRX_DTX_P1_R: JWLAN.11 RN106.2
CNV_PTX_C_DRX_N0: JWLAN.65 RN125.2
CNV_PTX_C_DRX_N1: JWLAN.59 RN123.2
CNV_PTX_C_DRX_P0: JWLAN.67 RN126.2
CNV_PTX_C_DRX_P1: JWLAN.61 RN124.2
CNV_PTX_DRX_N0: RN125.1 UH1.BE6
CNV_PTX_DRX_N1: RN123.1 UH1.BG6
CNV_PTX_DRX_P0: RN126.1 UH1.BD7
CNV_PTX_DRX_P1: RN124.1 UH1.BF6
CNV_RF_RESET#: QN8.2 RH724.1 RN6.1 UH1.BE16
CNV_RF_RESET#_D: JWLAN.10 QN8.3 RH722.1
CNV_RGI_PRX_DTX: RH182.2 RN111.2 UH1.AV3
CNV_RGI_PRX_DTX_R: JWLAN.34 RN111.1
CNV_RGI_PTX_DRX: RH200.2 UH1.BA4
CNV_RGI_PTX_DRX_R: JWLAN.32 RH200.1 RH219.2 RH220.2 RN120.2
CNV_WT_RCOMP: RH213.1 UH1.BA1
COMP_CHG: PC751.2 PR754.2 PU703.10
COMP_ISL95338_1: PCS27.1 PRS20.1 PUS1.28
COMP_ISL95338_2: PCS56.1 PRS40.2 PUS2.28
CORE_V1N: PCI205.1 PLI01.3 PRI20.2 PRI62.1 PRI102.1 PRI201.1
CORE_V1P: PLI01.2 PRI18.2 PRI19.1 PRI210.1
CORE_V2N: PCI203.1 PLI02.3 PRI36.2 PRI77.1 PRI117.1 PRI204.1
CORE_V2P: PLI02.2 PRI33.2 PRI34.1 PRI203.1
CORE_V3N: PCI209.1 PLI03.3 PRI22.1 PRI61.2 PRI103.1 PRI218.1
CORE_V3P: PLI03.2 PRI59.2 PRI60.1 PRI220.1
CORE_V4N: PCI207.1 PLI04.3 PRI37.1 PRI76.2 PRI118.1 PRI211.1
CORE_V4P: PLI04.2 PRI74.2 PRI75.1 PRI215.1
CORE_V5N: PCI214.1 PLI05.3 PRI23.1 PRI63.1 PRI101.2 PRI230.1
CORE_V5P: PLI05.2 PRI99.2 PRI100.1 PRI221.1
CORE_V6N: PCI212.1 PLI06.3 PRI38.1 PRI78.1 PRI116.2 PRI223.1
CORE_V6P: PLI06.2 PRI114.2 PRI115.1 PRI227.1
CPU_2_PCH_TRIG_C: RC36.2 UC1.B3
CPU_24MHZ_N: UC1.J9 UH1.C6
CPU_24MHZ_P: UC1.K9 UH1.D7
CPU_B+: PCG04.1 PCG05.1 PCG06.1 PCG07.1 PCG08.1 PCG09.1 PCG10.1 PCG15.1 PCG16.1 PCG17.1 PCG18.1 PCG19.1 PCG21.1 PCG22.1 PCG38.1 PCG39.1 PCI11.1 PCI12.1 PCI13.1 PCI14.1 PCI15.1 PCI16.1 PCI21.1 PCI25.1 PCI26.1 PCI27.1 PCI28.1 PCI38.1 PCI39.1 PCI40.1 PCI41.1 PCI42.1 PCI43.1 PCI44.1 PCI49.1 PCI50.1 PCI51.1 PCI52.1 PCI53.1 PCI54.1 PCI55.1 PCI65.1 PCI66.1 PCI67.1 PCI68.1 PCI69.1 PCI70.1 PCI71.1 PCI76.1 PCI77.1 PCI78.1 PCI79.1 PCI80.1 PCI81.1 PCI82.1 PCI139.1 PCI140.1 PCI141.1 PCI142.1 PCI143.1 PCI144.1 PCI145.1 PCI146.1 PCI147.1 PCI148.1 PLI11.2 PLI12.2 PRZ04.2 PUG01.8 PUG01.9 PUG02.8 PUG02.9 PUI01.8 PUI01.9 PUI02.8 PUI02.9 PUI03.8 PUI03.9 PUI04.8 PUI04.9 PUI05.8 PUI05.9 PUI06.8 PUI06.9
CPU_DDC1CLK: RT127.1 UT1.Y5
CPU_DDC1DATA: RT126.1 UT1.R4
CPU_DDC2CLK: RT129.1 UT1.Y8
CPU_DDC2DATA: RT128.1 UT1.N4
CPU_DISPA_BCLK: RH38.1 UC1.V3
CPU_DISPA_BCLK_R: RH38.2 UH1.AM3
CPU_DISPA_SDI: RC1.1 UC1.U1
CPU_DISPA_SDI_R: RC1.2 UH1.AN3
CPU_DISPA_SDO: RH39.1 UC1.V2
CPU_DISPA_SDO_R: RH39.2 UH1.AM2
CPU_DP1_AUXN: CT26.1 UC1.C13
CPU_DP1_AUXN_C: CT26.2 RT76.1 UT1.W11
CPU_DP1_AUXP: CT25.1 UC1.B13
CPU_DP1_AUXP_C: CT25.2 RT78.1 UT1.Y11
CPU_DP1_CTRL_CLK: RH604.2 UH1.AL13
CPU_DP1_CTRL_DATA: RH605.2 UH1.AR8
CPU_DP1_HPD: RT38.1 UH1.AT6 UT1.AA2
CPU_DP1_N0: CT7.1 UC1.D21
CPU_DP1_N0_C: CT7.2 UT1.AC7
CPU_DP1_N1: CT9.1 UC1.E22
CPU_DP1_N1_C: CT9.2 UT1.AC9
CPU_DP1_N2: CT23.1 UC1.A23
CPU_DP1_N2_C: CT23.2 UT1.AC11
CPU_DP1_N3: CT24.1 UC1.D23
CPU_DP1_N3_C: CT24.2 UT1.AC13
CPU_DP1_P0: CT6.1 UC1.C21
CPU_DP1_P0_C: CT6.2 UT1.AB7
CPU_DP1_P1: CT8.1 UC1.D22
CPU_DP1_P1_C: CT8.2 UT1.AB9
CPU_DP1_P2: CT10.1 UC1.B23
CPU_DP1_P2_C: CT10.2 UT1.AB11
CPU_DP1_P3: CT11.1 UC1.C23
CPU_DP1_P3_C: CT11.2 UT1.AB13
CPU_DP2_AUXN: CT36.1 UC1.B12
CPU_DP2_AUXN_C: CT36.2 RT77.1 UT1.W12
CPU_DP2_AUXP: CT35.1 UC1.A12
CPU_DP2_AUXP_C: CT35.2 RT79.1 UT1.Y12
CPU_DP2_CTRL_CLK: RH607.2 UH1.AN13
CPU_DP2_CTRL_DATA: RH606.2 UH1.AL10
CPU_DP2_HPD: RT39.1 UH1.AN10 UT1.Y6
CPU_DP2_N0: CT28.1 UC1.A18
CPU_DP2_N0_C: CT28.2 UT1.AC15
CPU_DP2_N1: CT30.1 UC1.E18
CPU_DP2_N1_C: CT30.2 UT1.AC17
CPU_DP2_N2: CT32.1 UC1.D19
CPU_DP2_N2_C: CT32.2 UT1.AC19
CPU_DP2_N3: CT34.1 UC1.E20
CPU_DP2_N3_C: CT34.2 UT1.AC21
CPU_DP2_P0: CT27.1 UC1.B18
CPU_DP2_P0_C: CT27.2 UT1.AB15
CPU_DP2_P1: CT29.1 UC1.D18
CPU_DP2_P1_C: CT29.2 UT1.AB17
CPU_DP2_P2: CT31.1 UC1.C19
CPU_DP2_P2_C: CT31.2 UT1.AB19
CPU_DP2_P3: CT33.1 UC1.D20
CPU_DP2_P3_C: CT33.2 UT1.AB21
CPU_FAN_FB: DF1.2 RF1.1 UE5.28
CPU_FAN_PWM: JFAN1.3 RF2.1 UE5.26
CPU_PECI: CC2.1 R394.2 RC11.1 UC1.G7
CPU_PLTRST#: CC1.1 UC1.E7 UH1.AG5
CPU_TRIGGER: RC36.1 UH1.AK2
CPU_VCCIO_PWR_GATE#: RH180.2 UH1.AY3
CPU_XDP_TRST#: JPCMC.28 RC687.1 UC1.F12 UH1.AM4
CS1: PR306.2 PU301.1
CS2: PR305.2 PU301.5
CS_1.2V: PR201.2 PU201.13
CSIN_CHG: PC747.1 PC793.1 PR740.2 PU703.31
CSIN_ISL95338_1: PCS19.2 PCS21.1 PRS03.2 PUS1.14
CSIN_ISL95338_2: PCS48.2 PCS50.1 PRS23.2 PUS2.14
CSIP_CHG: PC747.2 PC792.1 PR772.2 PU703.32
CSIP_ISL95338_1: PCS19.1 PCS20.1 PRS02.2 PUS1.15
CSIP_ISL95338_2: PCS48.1 PCS49.1 PRS22.2 PUS2.15
CSON_CHG: PC708.1 PR776.1 PU703.14
CSOP_CHG: PC708.2 PR742.1 PU703.15
CSSN_1: PRS01.3 PRS03.1
CSSN_2: PRS21.3 PRS23.1
CSSP_1: PRS01.2 PRS02.1
CSSP_2: PRS21.2 PRS22.1
CTL1: UE5.58 UU1.6
CTL2: UE5.39 UU1.7
DAT_SMB: PBATT1.6 PR12.1
DCIN_CHG: PC757.2 PR743.1 PU703.18
DCIN_ISL95338_1: PCS23.1 PRS08.2 PUS1.17
DCIN_ISL95338_2: PCS52.2 PRS41.2 PUS2.17
DDR_A_ACT#: JDIMM1.114 JDIMM3.114 UC1.AU24
DDR_A_ALERT#: JDIMM1.116 JDIMM3.116 UC1.AT23
DDR_A_BA0: JDIMM1.150 JDIMM3.150 UC1.AY13
DDR_A_BA1: JDIMM1.145 JDIMM3.145 UC1.AV15
DDR_A_BG0: JDIMM1.115 JDIMM3.115 UC1.AW23
DDR_A_BG1: JDIMM1.113 JDIMM3.113 UC1.AV23
DDR_A_CAS#: JDIMM1.156 JDIMM3.156 UC1.AY11
DDR_A_CKE0: JDIMM3.109 UC1.AY24
DDR_A_CKE1: JDIMM3.110 UC1.AW24
DDR_A_CKE2: JDIMM1.109 UC1.AV24
DDR_A_CKE3: JDIMM1.110 UC1.AV25
DDR_A_CLK0: JDIMM3.137 UC1.AW18
DDR_A_CLK1: JDIMM3.138 UC1.AW17
DDR_A_CLK2: JDIMM1.137 UC1.AW16
DDR_A_CLK3: JDIMM1.138 UC1.AT16
DDR_A_CLK#0: JDIMM3.139 UC1.AV18
DDR_A_CLK#1: JDIMM3.140 UC1.AY17
DDR_A_CLK#2: JDIMM1.139 UC1.AV16
DDR_A_CLK#3: JDIMM1.140 UC1.AU16
DDR_A_CS#0: JDIMM3.149 UC1.AW12
DDR_A_CS#1: JDIMM3.157 UC1.AU11
DDR_A_CS#2: JDIMM1.149 UC1.AV13
DDR_A_CS#3: JDIMM1.157 UC1.AV10
DDR_A_D0: JDIMM1.8 JDIMM3.8 UC1.AE38
DDR_A_D1: JDIMM1.7 JDIMM3.7 UC1.AE37
DDR_A_D2: JDIMM1.20 JDIMM3.20 UC1.AG38
DDR_A_D3: JDIMM1.21 JDIMM3.21 UC1.AG37
DDR_A_D4: JDIMM1.4 JDIMM3.4 UC1.AE39
DDR_A_D5: JDIMM1.3 JDIMM3.3 UC1.AE40
DDR_A_D6: JDIMM1.16 JDIMM3.16 UC1.AG39
DDR_A_D7: JDIMM1.17 JDIMM3.17 UC1.AG40
DDR_A_D8: JDIMM1.28 JDIMM3.28 UC1.AJ38
DDR_A_D9: JDIMM1.29 JDIMM3.29 UC1.AJ37
DDR_A_D10: JDIMM1.41 JDIMM3.41 UC1.AL38
DDR_A_D11: JDIMM1.42 JDIMM3.42 UC1.AL37
DDR_A_D12: JDIMM1.24 JDIMM3.24 UC1.AJ40
DDR_A_D13: JDIMM1.25 JDIMM3.25 UC1.AJ39
DDR_A_D14: JDIMM1.38 JDIMM3.38 UC1.AL39
DDR_A_D15: JDIMM1.37 JDIMM3.37 UC1.AL40
DDR_A_D16: JDIMM1.50 JDIMM3.50 UC1.AN38
DDR_A_D17: JDIMM1.49 JDIMM3.49 UC1.AN40
DDR_A_D18: JDIMM1.62 JDIMM3.62 UC1.AR38
DDR_A_D19: JDIMM1.63 JDIMM3.63 UC1.AR37
DDR_A_D20: JDIMM1.46 JDIMM3.46 UC1.AN39
DDR_A_D21: JDIMM1.45 JDIMM3.45 UC1.AN37
DDR_A_D22: JDIMM1.58 JDIMM3.58 UC1.AR39
DDR_A_D23: JDIMM1.59 JDIMM3.59 UC1.AR40
DDR_A_D24: JDIMM1.70 JDIMM3.70 UC1.AW37
DDR_A_D25: JDIMM1.71 JDIMM3.71 UC1.AU38
DDR_A_D26: JDIMM1.83 JDIMM3.83 UC1.AV35
DDR_A_D27: JDIMM1.84 JDIMM3.84 UC1.AW35
DDR_A_D28: JDIMM1.66 JDIMM3.66 UC1.AU37
DDR_A_D29: JDIMM1.67 JDIMM3.67 UC1.AV37
DDR_A_D30: JDIMM1.79 JDIMM3.79 UC1.AT35
DDR_A_D31: JDIMM1.80 JDIMM3.80 UC1.AU35
DDR_A_D32: JDIMM1.174 JDIMM3.174 UC1.AY8
DDR_A_D33: JDIMM1.173 JDIMM3.173 UC1.AW8
DDR_A_D34: JDIMM1.187 JDIMM3.187 UC1.AV6
DDR_A_D35: JDIMM1.186 JDIMM3.186 UC1.AU6
DDR_A_D36: JDIMM1.170 JDIMM3.170 UC1.AU8
DDR_A_D37: JDIMM1.169 JDIMM3.169 UC1.AV8
DDR_A_D38: JDIMM1.183 JDIMM3.183 UC1.AW6
DDR_A_D39: JDIMM1.182 JDIMM3.182 UC1.AY6
DDR_A_D40: JDIMM1.195 JDIMM3.195 UC1.AY4
DDR_A_D41: JDIMM1.194 JDIMM3.194 UC1.AV4
DDR_A_D42: JDIMM1.207 JDIMM3.207 UC1.AT1
DDR_A_D43: JDIMM1.208 JDIMM3.208 UC1.AT2
DDR_A_D44: JDIMM1.191 JDIMM3.191 UC1.AV3
DDR_A_D45: JDIMM1.190 JDIMM3.190 UC1.AW4
DDR_A_D46: JDIMM1.203 JDIMM3.203 UC1.AT4
DDR_A_D47: JDIMM1.204 JDIMM3.204 UC1.AT3
DDR_A_D48: JDIMM1.216 JDIMM3.216 UC1.AP2
DDR_A_D49: JDIMM1.215 JDIMM3.215 UC1.AM4
DDR_A_D50: JDIMM1.228 JDIMM3.228 UC1.AP3
DDR_A_D51: JDIMM1.229 JDIMM3.229 UC1.AM3
DDR_A_D52: JDIMM1.211 JDIMM3.211 UC1.AP4
DDR_A_D53: JDIMM1.212 JDIMM3.212 UC1.AM2
DDR_A_D54: JDIMM1.224 JDIMM3.224 UC1.AP1
DDR_A_D55: JDIMM1.225 JDIMM3.225 UC1.AM1
DDR_A_D56: JDIMM1.237 JDIMM3.237 UC1.AK3
DDR_A_D57: JDIMM1.236 JDIMM3.236 UC1.AH1
DDR_A_D58: JDIMM1.249 JDIMM3.249 UC1.AK4
DDR_A_D59: JDIMM1.250 JDIMM3.250 UC1.AH2
DDR_A_D60: JDIMM1.232 JDIMM3.232 UC1.AH4
DDR_A_D61: JDIMM1.233 JDIMM3.233 UC1.AK2
DDR_A_D62: JDIMM1.245 JDIMM3.245 UC1.AH3
DDR_A_D63: JDIMM1.246 JDIMM3.246 UC1.AK1
DDR_A_DQS0: JDIMM1.13 JDIMM3.13 UC1.AF38
DDR_A_DQS1: JDIMM1.34 JDIMM3.34 UC1.AK38
DDR_A_DQS2: JDIMM1.55 JDIMM3.55 UC1.AP38
DDR_A_DQS3: JDIMM1.76 JDIMM3.76 UC1.AV36
DDR_A_DQS4: JDIMM1.179 JDIMM3.179 UC1.AV7
DDR_A_DQS5: JDIMM1.200 JDIMM3.200 UC1.AU2
DDR_A_DQS6: JDIMM1.221 JDIMM3.221 UC1.AN2
DDR_A_DQS7: JDIMM1.242 JDIMM3.242 UC1.AJ2
DDR_A_DQS#0: JDIMM1.11 JDIMM3.11 UC1.AF39
DDR_A_DQS#1: JDIMM1.32 JDIMM3.32 UC1.AK39
DDR_A_DQS#2: JDIMM1.53 JDIMM3.53 UC1.AP39
DDR_A_DQS#3: JDIMM1.74 JDIMM3.74 UC1.AU36
DDR_A_DQS#4: JDIMM1.177 JDIMM3.177 UC1.AW7
DDR_A_DQS#5: JDIMM1.198 JDIMM3.198 UC1.AU3
DDR_A_DQS#6: JDIMM1.219 JDIMM3.219 UC1.AN3
DDR_A_DQS#7: JDIMM1.240 JDIMM3.240 UC1.AJ3
DDR_A_DRAMRST#: CD134.1 JDIMM1.108 JDIMM3.108 RD52.1
DDR_A_MA0: JDIMM1.144 JDIMM3.144 UC1.AW15
DDR_A_MA1: JDIMM1.133 JDIMM3.133 UC1.AU18
DDR_A_MA2: JDIMM1.132 JDIMM3.132 UC1.AU17
DDR_A_MA3: JDIMM1.131 JDIMM3.131 UC1.AV19
DDR_A_MA4: JDIMM1.128 JDIMM3.128 UC1.AT19
DDR_A_MA5: JDIMM1.126 JDIMM3.126 UC1.AU20
DDR_A_MA6: JDIMM1.127 JDIMM3.127 UC1.AV20
DDR_A_MA7: JDIMM1.122 JDIMM3.122 UC1.AU21
DDR_A_MA8: JDIMM1.125 JDIMM3.125 UC1.AT20
DDR_A_MA9: JDIMM1.121 JDIMM3.121 UC1.AT22
DDR_A_MA10: JDIMM1.146 JDIMM3.146 UC1.AY14
DDR_A_MA11: JDIMM1.120 JDIMM3.120 UC1.AU22
DDR_A_MA12: JDIMM1.119 JDIMM3.119 UC1.AV22
DDR_A_MA13: JDIMM1.158 JDIMM3.158 UC1.AV12
DDR_A_ODT0: JDIMM3.155 UC1.AW11
DDR_A_ODT1: JDIMM3.161 UC1.AU14
DDR_A_ODT2: JDIMM1.155 UC1.AU12
DDR_A_ODT3: JDIMM1.161 UC1.AY10
DDR_A_PAR: JDIMM1.143 JDIMM3.143 UC1.AY15
DDR_A_RAS#: JDIMM1.152 JDIMM3.152 UC1.AW13
DDR_A_WE#: JDIMM1.151 JDIMM3.151 UC1.AV14
DDR_B_ACT#: JDIMM2.114 JDIMM4.114 UC1.AU28
DDR_B_ALERT#: JDIMM2.116 JDIMM4.116 UC1.AY25
DDR_B_BA0: JDIMM2.150 JDIMM4.150 UC1.AL18
DDR_B_BA1: JDIMM2.145 JDIMM4.145 UC1.AM18
DDR_B_BG0: JDIMM2.115 JDIMM4.115 UC1.AW28
DDR_B_BG1: JDIMM2.113 JDIMM4.113 UC1.AY28
DDR_B_CAS#: JDIMM2.156 JDIMM4.156 UC1.AP16
DDR_B_CKE0: JDIMM4.109 UC1.AY29
DDR_B_CKE1: JDIMM4.110 UC1.AV29
DDR_B_CKE2: JDIMM2.109 UC1.AW29
DDR_B_CKE3: JDIMM2.110 UC1.AU29
DDR_B_CLK0: JDIMM4.137 UC1.AM20
DDR_B_CLK1: JDIMM4.138 UC1.AP22
DDR_B_CLK2: JDIMM2.137 UC1.AN20
DDR_B_CLK3: JDIMM2.138 UC1.AP19
DDR_B_CLK#0: JDIMM4.139 UC1.AM21
DDR_B_CLK#1: JDIMM4.140 UC1.AP21
DDR_B_CLK#2: JDIMM2.139 UC1.AN21
DDR_B_CLK#3: JDIMM2.140 UC1.AP20
DDR_B_CS#0: JDIMM4.149 UC1.AP17
DDR_B_CS#1: JDIMM4.157 UC1.AN15
DDR_B_CS#2: JDIMM2.149 UC1.AN17
DDR_B_CS#3: JDIMM2.157 UC1.AM15
DDR_B_D0: JDIMM2.8 JDIMM4.8 UC1.AD34
DDR_B_D1: JDIMM2.7 JDIMM4.7 UC1.AD35
DDR_B_D2: JDIMM2.20 JDIMM4.20 UC1.AG35
DDR_B_D3: JDIMM2.21 JDIMM4.21 UC1.AH35
DDR_B_D4: JDIMM2.4 JDIMM4.4 UC1.AE35
DDR_B_D5: JDIMM2.3 JDIMM4.3 UC1.AE34
DDR_B_D6: JDIMM2.16 JDIMM4.16 UC1.AG34
DDR_B_D7: JDIMM2.17 JDIMM4.17 UC1.AH34
DDR_B_D8: JDIMM2.28 JDIMM4.28 UC1.AK35
DDR_B_D9: JDIMM2.29 JDIMM4.29 UC1.AL35
DDR_B_D10: JDIMM2.41 JDIMM4.41 UC1.AK32
DDR_B_D11: JDIMM2.42 JDIMM4.42 UC1.AL32
DDR_B_D12: JDIMM2.24 JDIMM4.24 UC1.AK34
DDR_B_D13: JDIMM2.25 JDIMM4.25 UC1.AL34
DDR_B_D14: JDIMM2.38 JDIMM4.38 UC1.AK31
DDR_B_D15: JDIMM2.37 JDIMM4.37 UC1.AL31
DDR_B_D16: JDIMM2.50 JDIMM4.50 UC1.AP35
DDR_B_D17: JDIMM2.49 JDIMM4.49 UC1.AN35
DDR_B_D18: JDIMM2.62 JDIMM4.62 UC1.AN32
DDR_B_D19: JDIMM2.63 JDIMM4.63 UC1.AP32
DDR_B_D20: JDIMM2.46 JDIMM4.46 UC1.AN34
DDR_B_D21: JDIMM2.45 JDIMM4.45 UC1.AP34
DDR_B_D22: JDIMM2.58 JDIMM4.58 UC1.AN31
DDR_B_D23: JDIMM2.59 JDIMM4.59 UC1.AP31
DDR_B_D24: JDIMM2.70 JDIMM4.70 UC1.AL29
DDR_B_D25: JDIMM2.71 JDIMM4.71 UC1.AM29
DDR_B_D26: JDIMM2.83 JDIMM4.83 UC1.AP29
DDR_B_D27: JDIMM2.84 JDIMM4.84 UC1.AR29
DDR_B_D28: JDIMM2.66 JDIMM4.66 UC1.AM28
DDR_B_D29: JDIMM2.67 JDIMM4.67 UC1.AL28
DDR_B_D30: JDIMM2.79 JDIMM4.79 UC1.AR28
DDR_B_D31: JDIMM2.80 JDIMM4.80 UC1.AP28
DDR_B_D32: JDIMM2.174 JDIMM4.174 UC1.AR12
DDR_B_D33: JDIMM2.173 JDIMM4.173 UC1.AP12
DDR_B_D34: JDIMM2.187 JDIMM4.187 UC1.AM13
DDR_B_D35: JDIMM2.186 JDIMM4.186 UC1.AL13
DDR_B_D36: JDIMM2.170 JDIMM4.170 UC1.AR13
DDR_B_D37: JDIMM2.169 JDIMM4.169 UC1.AP13
DDR_B_D38: JDIMM2.183 JDIMM4.183 UC1.AM12
DDR_B_D39: JDIMM2.182 JDIMM4.182 UC1.AL12
DDR_B_D40: JDIMM2.195 JDIMM4.195 UC1.AP10
DDR_B_D41: JDIMM2.194 JDIMM4.194 UC1.AR10
DDR_B_D42: JDIMM2.207 JDIMM4.207 UC1.AR7
DDR_B_D43: JDIMM2.208 JDIMM4.208 UC1.AP7
DDR_B_D44: JDIMM2.191 JDIMM4.191 UC1.AR9
DDR_B_D45: JDIMM2.190 JDIMM4.190 UC1.AP9
DDR_B_D46: JDIMM2.203 JDIMM4.203 UC1.AR6
DDR_B_D47: JDIMM2.204 JDIMM4.204 UC1.AP6
DDR_B_D48: JDIMM2.216 JDIMM4.216 UC1.AM10
DDR_B_D49: JDIMM2.215 JDIMM4.215 UC1.AL10
DDR_B_D50: JDIMM2.228 JDIMM4.228 UC1.AM7
DDR_B_D51: JDIMM2.229 JDIMM4.229 UC1.AL7
DDR_B_D52: JDIMM2.211 JDIMM4.211 UC1.AM9
DDR_B_D53: JDIMM2.212 JDIMM4.212 UC1.AL9
DDR_B_D54: JDIMM2.224 JDIMM4.224 UC1.AM6
DDR_B_D55: JDIMM2.225 JDIMM4.225 UC1.AL6
DDR_B_D56: JDIMM2.237 JDIMM4.237 UC1.AJ6
DDR_B_D57: JDIMM2.236 JDIMM4.236 UC1.AJ7
DDR_B_D58: JDIMM2.249 JDIMM4.249 UC1.AE6
DDR_B_D59: JDIMM2.250 JDIMM4.250 UC1.AF7
DDR_B_D60: JDIMM2.232 JDIMM4.232 UC1.AH7
DDR_B_D61: JDIMM2.233 JDIMM4.233 UC1.AH6
DDR_B_D62: JDIMM2.245 JDIMM4.245 UC1.AE7
DDR_B_D63: JDIMM2.246 JDIMM4.246 UC1.AF6
DDR_B_DQS0: JDIMM2.13 JDIMM4.13 UC1.AF35
DDR_B_DQS1: JDIMM2.34 JDIMM4.34 UC1.AL33
DDR_B_DQS2: JDIMM2.55 JDIMM4.55 UC1.AP33
DDR_B_DQS3: JDIMM2.76 JDIMM4.76 UC1.AN28
DDR_B_DQS4: JDIMM2.179 JDIMM4.179 UC1.AN12
DDR_B_DQS5: JDIMM2.200 JDIMM4.200 UC1.AP8
DDR_B_DQS6: JDIMM2.221 JDIMM4.221 UC1.AL8
DDR_B_DQS7: JDIMM2.242 JDIMM4.242 UC1.AG7
DDR_B_DQS#0: JDIMM2.11 JDIMM4.11 UC1.AF34
DDR_B_DQS#1: JDIMM2.32 JDIMM4.32 UC1.AK33
DDR_B_DQS#2: JDIMM2.53 JDIMM4.53 UC1.AN33
DDR_B_DQS#3: JDIMM2.74 JDIMM4.74 UC1.AN29
DDR_B_DQS#4: JDIMM2.177 JDIMM4.177 UC1.AN13
DDR_B_DQS#5: JDIMM2.198 JDIMM4.198 UC1.AR8
DDR_B_DQS#6: JDIMM2.219 JDIMM4.219 UC1.AM8
DDR_B_DQS#7: JDIMM2.240 JDIMM4.240 UC1.AG6
DDR_B_DRAMRST#: CD133.1 JDIMM2.108 JDIMM4.108 RD62.1
DDR_B_MA0: JDIMM2.144 JDIMM4.144 UC1.AL19
DDR_B_MA1: JDIMM2.133 JDIMM4.133 UC1.AL22
DDR_B_MA2: JDIMM2.132 JDIMM4.132 UC1.AM22
DDR_B_MA3: JDIMM2.131 JDIMM4.131 UC1.AM23
DDR_B_MA4: JDIMM2.128 JDIMM4.128 UC1.AP23
DDR_B_MA5: JDIMM2.126 JDIMM4.126 UC1.AL23
DDR_B_MA6: JDIMM2.127 JDIMM4.127 UC1.AW26
DDR_B_MA7: JDIMM2.122 JDIMM4.122 UC1.AY26
DDR_B_MA8: JDIMM2.125 JDIMM4.125 UC1.AU26
DDR_B_MA9: JDIMM2.121 JDIMM4.121 UC1.AW27
DDR_B_MA10: JDIMM2.146 JDIMM4.146 UC1.AP18
DDR_B_MA11: JDIMM2.120 JDIMM4.120 UC1.AU27
DDR_B_MA12: JDIMM2.119 JDIMM4.119 UC1.AV27
DDR_B_MA13: JDIMM2.158 JDIMM4.158 UC1.AR15
DDR_B_ODT0: JDIMM4.155 UC1.AM16
DDR_B_ODT1: JDIMM4.161 UC1.AL16
DDR_B_ODT2: JDIMM2.155 UC1.AP15
DDR_B_ODT3: JDIMM2.161 UC1.AL15
DDR_B_PAR: JDIMM2.143 JDIMM4.143 UC1.AL20
DDR_B_RAS#: JDIMM2.152 JDIMM4.152 UC1.AN18
DDR_B_WE#: JDIMM2.151 JDIMM4.151 UC1.AL17
DDR_VTT_CNTL: UC1.AC36 UC2.2
DEBUG_CTL1: RT66.2 UT4.E4
DEBUG_CTL2: RT67.2 UT4.D5
DEMB0: RM75.2 RM79.2 UM8.53
DEMB1: RM62.2 RM86.2 UM8.54
DEPOP#_EC: JAUDIO.6 RE688.2 UE5.55
DEVSLP0: JHDD.7 UH1.AL48
DEVSLP1: JSSD2.38 UH1.AH35
DEVSLP4: JSSD1.38 UH1.AR47
DGPU_HOLD_RST#: JDGFF1.C2 UH1.BB20
DGPU_PRSNT#: RH135.2 UH1.BD38
DGPU_PWR_EN: JDGFF2.C2 RH537.1 UE5.97 UH1.AN18
DGPU_PWROK: RH516.2 UH1.BE14
DH_1.2V: PQ200.4 PU201.17
DIMM1_CHA_EVENT#: JDIMM1.134 RD7.2
DIMM2_CHA_EVENT#: JDIMM3.134 RD18.2
DIMM3_CHB_EVENT#: JDIMM2.134 RD32.2
DIMM4_CHB_EVENT#: JDIMM4.134 RD44.2
DL_1.2V: PQ201.4 PU201.15
DMI_CRX_PTX_N0: UC1.Y4 UH1.C33
DMI_CRX_PTX_N1: UC1.AA5 UH1.C32
DMI_CRX_PTX_N2: UC1.AB3 UH1.C31
DMI_CRX_PTX_N3: UC1.AC5 UH1.C29
DMI_CRX_PTX_P0: UC1.Y3 UH1.B33
DMI_CRX_PTX_P1: UC1.AA4 UH1.B32
DMI_CRX_PTX_P2: UC1.AB4 UH1.B31
DMI_CRX_PTX_P3: UC1.AC4 UH1.B29
DMI_CTX_PRX_N0: UC1.AC1 UH1.K34
DMI_CTX_PRX_N1: UC1.AD2 UH1.G33
DMI_CTX_PRX_N2: UC1.AE1 UH1.K32
DMI_CTX_PRX_N3: UC1.AF3 UH1.G30
DMI_CTX_PRX_P0: UC1.AC2 UH1.J35
DMI_CTX_PRX_P1: UC1.AD3 UH1.F34
DMI_CTX_PRX_P2: UC1.AE2 UH1.J32
DMI_CTX_PRX_P3: UC1.AF2 UH1.F30
DP_HPD_PCH: JDGFF1.G9 UH1.AW24
DPSNK_RBIAS: RT19.1 UT1.Y18
DPSRC_RBIAS: RT5.1 UT1.N6
EC_AC_BAT#: JDGFF2.A10 PR44.1 PR45.1 UE5.82
EC_AMP_RST#: JAUDIO.7 RE695.2 UE5.90
EC_CLK1: RE668.1 UE5.83
EC_CODEC_EAPD#: JAUDIO.8 QE64.2 RE696.2 RE699.1
EC_DAT1: RE669.1 UE5.84
EC_EAPD#: QE64.3 RE700.2 UE5.93
EC_EN_AMP: PR17.2 PR20.1 UE10.11
EC_ENBKL: JDGFF2.E2 RE701.2
EC_ESB_CLK: RE642.2 UE5.17 UE6.1 UE10.1
EC_ESB_DAT: RE643.2 UE5.18 UE6.4 UE10.4
EC_ON: PD301.2 UE5.112
EC_PECI: R394.1 RE76.2
EC_PECI_R: RE76.1 UE5.118
EC_RSMRST#: DE2.2 RC355.2 RH88.2 RH1017.2 UE5.100 UH1.BA47
EC_RTCRST: QE5.2 RE650.1 UE10.14
EC_RX: RN119.2 UE5.31
EC_SCI#: RE694.1 RH521.2 UH1.AU26
EC_SMB_CK1: PD3.2 PR11.2 PR770.1 PRS12.1 PRS32.1 RE90.4 RT60.1 RT709.2 UE5.77 UT7.11
EC_SMB_CK2: DK2.2 JDGFF2.F1 JPK.16 QH5.1 R408.1 RE90.2 U2407.10 U2408.8 UE5.79 UM8.50
EC_SMB_DA1: PD3.3 PR12.2 PR769.1 PRS10.1 PRS30.1 RE90.3 RT59.1 RT710.2 UE5.78 UT7.10
EC_SMB_DA2: DK2.3 JDGFF2.F2 JPK.17 QH5.4 R409.1 RE90.1 U2407.9 U2408.7 UE5.80 UM8.49
EC_SRTCRST: QE5.5 RE693.1 UE10.20

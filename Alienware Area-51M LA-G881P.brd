# Allegro board Alienware Area-51M LA-G881P.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DMI_CRX_PTX_N3: length 201.8
  TOP w0.089: UH1.C29 278.76,42.31 278.95,42.31 279.11,42.16 279.11,41.87 279.3,41.68 279.87,41.68 280.31,41.23 280.31,39.9 278.54,38.12 277.86,38.12 v2(277.79,38.05)
  IN1 w0.084: v2(148.94,83.07) 149.14,83.27 150.14,83.27 151.82,84.95 152.05,85.18 152.05,88.64 152.51,89.1 152.86,89.1 156.26,92.49 158.25,92.49 161.33,95.58 162.03,95.58 164.55,98.09 180.2,98.09 181.14,99.03 185.01,99.03 185.1,98.94 198.54,98.94 199.79,100.2 211.21,100.2 211.51,99.9 230.05,99.9 230.48,99.47 243.1,99.47 249.56,93.01 250.34,93.01 254.09,89.26 254.09,86.95 258.48,82.56 258.48,61.07 259.13,60.43 259.13,58.82 259.49,58.46 259.49,56.26 259.11,55.88 259.11,50.99 259.79,50.31 259.79,40.47 261.71,38.56 268.7,38.56 269.27,37.99 277.14,37.99 277.4,38.26 277.58,38.26 v2(277.79,38.05)
  BOTTOM w0.102: UC1.AC5 150.24,79.31 150.24,80.22 150.02,80.45 150.02,81.44 149.38,82.08 149.38,83.16 149.28,83.26 149.13,83.26 v2(148.94,83.07)
DMI_CRX_PTX_P0: length 209.5
  TOP w0.089: v2(277.22,40.43) 277.22,40.64 276.9,40.97 276.9,41.62 276.73,41.78 276.73,42.07 276.64,42.16 276.49,42.16 276.4,42.07 276.4,42 UH1.B33
  IN1 w0.084: v2(277.22,40.43) 277.22,40.85 277.1,40.98 276.3,40.98 275.21,39.89 272.96,39.89 271.99,40.86 265.31,40.86 264.9,40.46 262.49,40.46 261.69,41.26 261.69,51.09 261,51.78 261,54.05 262.07,55.11 262.07,60.11 264.29,62.33 264.29,68.26 263.73,68.82 263.73,74.97 261.33,77.37 261.33,83.27 260.7,83.91 260.7,88.69 257.42,91.97 257.42,94.74 250.73,101.43 231.2,101.43 230.84,101.8 212.41,101.8 212.11,102.09 184.49,102.09 180.36,106.22 173.53,106.22 167.3,99.99 163.76,99.99 161.25,97.48 160.54,97.48 157.46,94.39 155.47,94.39 152.08,91 151.72,91 148.91,88.18 147.79,88.18 v2(147.49,87.88)
  BOTTOM w0.102: 146.96,84.99 146.96,84.98 146.96,84.31 147.06,84.21 147.06,83.3 147.49,82.86 147.49,80.4 147.62,80.27 147.83,80.27 147.93,80.37 147.93,80.71 UC1.Y3
  BOTTOM w0.112: v2(147.49,87.88) 147.23,88.13 147.14,88.13 146.96,87.96 146.96,84.99
DMI_CRX_PTX_P1: length 205.6
  TOP w0.089: UH1.B32 277.15,42.23 277.22,42.31 277.33,42.31 277.38,42.26 277.38,41.95 277.79,41.55 277.79,41.22 278.1,40.91 278.1,40.61 277.27,39.77 276.84,39.77 v2(276.66,39.95)
  IN1 w0.084: v2(276.66,39.95) 276.55,39.84 275.82,39.84 275.4,39.43 269.86,39.43 269.3,39.99 262.3,39.99 261.23,41.07 261.23,50.9 260.54,51.59 260.54,54.3 261.58,55.35 261.58,60.72 263.82,62.96 263.82,67.18 260.99,70.01 260.99,77.05 260.1,77.94 260.1,88.37 255.26,93.22 253.59,93.22 245.9,100.91 231.07,100.91 230.64,101.33 212.2,101.33 211.9,101.63 198.88,101.63 198,100.75 180.83,100.75 179.61,99.52 163.95,99.52 161.44,97.01 160.74,97.01 157.65,93.93 155.66,93.93 152.27,90.53 151.92,90.53 150.62,89.24 150.62,87.75 149.48,86.61 148.01,86.61 147.84,86.43 147.72,86.43 v2(147.51,86.64)
  BOTTOM w0.102: 147.77,84.99 147.77,84.97 147.77,84.96 147.77,83.17 147.98,82.95 147.98,81.54 148.39,81.12 148.39,79.47 148.5,79.37 148.79,79.37 148.9,79.47 148.9,79.74 UC1.AA4
  BOTTOM w0.112: 147.77,84.99 147.77,85.29 148.23,85.75 148.23,86.22 147.99,86.46 147.69,86.46 v2(147.51,86.64)
DMI_CRX_PTX_P2: length 200.8
  TOP w0.089: UH1.B31 278.06,42.15 278.25,41.96 278.25,41.39 278.85,40.79 278.85,39.89 278.46,39.5 278.32,39.5 v2(278.12,39.7)
  IN1 w0.084: v2(148.96,85.41) 149.16,85.21 150.24,85.21 151.25,86.23 151.25,88.97 152.18,89.9 152.53,89.9 155.92,93.29 157.91,93.29 161,96.38 161.7,96.38 164.22,98.89 179.87,98.89 181.07,100.09 198.44,100.09 199.35,101 211.54,101 211.84,100.7 230.38,100.7 230.81,100.27 245.6,100.27 253.5,92.38 253.5,91.85 256.93,88.42 256.93,86.64 259.29,84.28 259.29,73.49 260.23,72.54 260.23,63.27 260.95,62.55 260.95,58.75 260.29,58.09 260.29,55.86 259.91,55.48 259.91,51.33 260.59,50.64 260.59,40.8 262.04,39.36 269.03,39.36 269.6,38.79 276.75,38.79 277.41,39.46 277.87,39.46 v2(278.12,39.7)
  BOTTOM w0.102: 148.39,84.99 148.28,84.89 148.28,82.45 149.11,81.63 149.11,80.61 149.33,80.39 149.47,80.39 149.66,80.19 UC1.AB4
  BOTTOM w0.112: 148.39,84.99 148.59,85.19 148.74,85.19 v2(148.96,85.41)
DMI_CRX_PTX_P3: length 201.8
  TOP w0.089: v2(277.79,38.63) 278.12,38.3 278.47,38.3 280.14,39.97 280.14,41.16 279.8,41.5 279.22,41.5 278.93,41.8 278.93,42.08 278.88,42.14 278.8,42.14 278.67,42 UH1.B29
  IN1 w0.084: v2(148.94,83.65) 149.14,83.45 150.06,83.45 151.73,85.12 151.75,85.12 151.88,85.25 151.88,88.71 152.44,89.27 152.79,89.27 156.19,92.66 158.18,92.66 161.26,95.75 161.97,95.75 164.48,98.26 180.13,98.26 181.07,99.2 185.08,99.2 185.17,99.11 198.47,99.11 199.72,100.36 211.28,100.36 211.58,100.07 230.12,100.07 230.55,99.64 243.17,99.64 249.63,93.18 250.41,93.18 254.26,89.33 254.26,87.02 258.65,82.63 258.65,61.14 259.3,60.5 259.3,58.89 259.66,58.53 259.66,56.19 259.27,55.81 259.27,51.06 259.96,50.38 259.96,40.54 261.78,38.73 268.77,38.73 269.34,38.16 277.07,38.16 277.34,38.43 277.58,38.43 v2(277.79,38.63)
  BOTTOM w0.102: v2(148.94,83.65) 149.13,83.46 149.36,83.46 149.58,83.24 149.58,82.17 150.22,81.52 150.22,80.53 150.42,80.33 150.81,80.33 150.96,80.18 150.96,79.76 150.86,79.65 150.68,79.65 150.58,79.76 UC1.AC4
DMI_CTX_PRX_N0: length 200.3
  TOP w0.094: v2(276.59,45.78) 276.34,46.03 UH1.K34
  IN1 w0.084: v2(152.66,88.1) 152.89,88.33 153.02,88.33 156.55,91.86 158.51,91.86 161.59,94.95 162.3,94.95 164.81,97.46 180.5,97.46 181.44,98.4 184.75,98.4 184.84,98.31 198.8,98.31 200.06,99.56 210.95,99.56 211.24,99.27 229.79,99.27 230.21,98.84 241.44,98.84 245.96,94.32 245.96,93.37 248.82,90.51 248.82,90.02 250.68,88.16 251.68,88.16 253.04,86.8 253.04,84.66 257.36,80.34 257.36,73.35 257.85,72.86 257.85,57.35 257.96,57.24 257.96,53.82 258.47,53.31 258.47,50.73 259.16,50.04 259.16,40.21 261.54,37.83 267.11,37.83 267.58,37.36 278.41,37.36 278.92,37.86 278.92,40.34 278.57,40.68 278.57,41 276.58,42.99 276.58,44.4 277.11,44.93 277.11,45.26 276.88,45.49 276.76,45.52 v2(276.59,45.78)
  BOTTOM w0.102: 150.52,84.99 150.52,84.96 150.51,84.95 150.51,83.43 150.2,83.12 150.2,82.35 150.31,82.24 150.52,82.24 150.6,82.32 150.6,82.61 UC1.AC1
  BOTTOM w0.112: 150.52,84.99 150.52,87.08 151.91,88.46 152.29,88.46 v2(152.66,88.1)
DMI_CTX_PRX_N1: length 199.5
  TOP w0.089: v2(277.18,44.43) 277.15,44.4 276.91,44.4 UH1.G33
  IN1 w0.084: v2(152.5,86.5) 152.72,86.72 153.12,86.72 153.69,87.29 153.69,88.12 156.81,91.23 158.77,91.23 161.85,94.31 162.56,94.31 165.07,96.83 180.76,96.83 181.61,97.68 199.06,97.68 200.32,98.93 210.69,98.93 210.98,98.64 229.52,98.64 229.95,98.21 237.4,98.21 240.97,94.64 243.11,94.64 244.06,93.69 244.71,93.69 247.98,90.42 247.98,86.32 249.97,84.33 251.45,84.33 254.35,81.43 255.3,81.43 256.73,80 256.73,57.58 257.33,56.98 257.33,53.04 257.84,52.53 257.84,50.47 258.53,49.78 258.53,39.95 261.28,37.2 266.85,37.2 267.32,36.73 278.68,36.73 279.65,37.7 279.65,40.5 279.2,40.95 279.2,41.27 277.69,42.78 277.69,43.77 277.18,44.28 v2(277.18,44.43)
  BOTTOM w0.102: 151.35,84.99 151.34,84.98 151.34,83.57 151.11,83.35 151.11,83.11 151.12,83.1 151.12,81.35 151.22,81.25 151.39,81.25 151.49,81.35 UC1.AD2
  BOTTOM w0.112: v2(152.5,86.5) 152.32,86.69 151.46,86.69 151.35,86.57 151.35,84.99
DMI_CTX_PRX_N2: length 200.4
  TOP w0.094: v2(277.76,45.77) 277.74,45.74 277.61,45.74 UH1.K32
  IN1 w0.084: v2(152.7,85.22) 152.9,85.43 153.63,85.43 154.33,86.13 154.33,87.85 157.07,90.6 159.03,90.6 162.12,93.68 162.82,93.68 165.34,96.19 198.48,96.19 200.55,98.26 210.46,98.26 210.72,98 229.26,98 229.69,97.58 236.74,97.58 239.42,94.9 239.42,94.64 240.28,93.77 242.57,93.77 243,93.34 243,92.93 243.53,92.4 243.67,92.4 243.67,92.4 244.65,92.4 246,91.06 246,89.43 247.22,88.21 247.22,84.86 249.4,82.67 252.15,82.67 256.1,78.73 256.1,67.87 256.06,67.84 256.06,57.35 256.7,56.72 256.7,50.25 257.67,49.28 257.67,39.91 261.02,36.57 266.59,36.57 267.06,36.1 279.14,36.1 280.28,37.23 280.28,41.68 279.77,42.19 279.18,42.19 278.41,42.96 278.41,44.8 278.13,45.08 278.13,45.2 277.76,45.57 v2(277.76,45.77)
  BOTTOM w0.102: UC1.AE1 152.41,82.31 152.31,82.22 152.14,82.22 152.04,82.32 152.04,82.91 152.08,82.95 152.08,83.43 152.04,83.47 152.04,84.69 152.04,84.7 152.04,84.89 152.05,84.9 152.05,84.96 152.06,84.97 152.06,84.99
  BOTTOM w0.112: 152.06,84.99 152.06,85.26 152.21,85.41 152.51,85.41 v2(152.7,85.22)
DMI_CTX_PRX_N3: length 202
  TOP w0.094: v2(279.42,44.47) 279.32,44.37 278.36,44.37 UH1.G30
  IN1 w0.084: v2(279.42,44.47) 279.21,44.26 279.07,44.26 278.89,44.08 278.89,43.14 279.37,42.65 279.96,42.65 280.74,41.87 280.74,37.04 278.4,34.7 273.73,34.7 272.79,35.63 267.28,35.63 266.79,35.14 261.78,35.14 257.2,39.72 257.2,49.05 256.23,50.01 256.23,56.52 255.6,57.15 255.6,68.03 255.63,68.07 255.63,77.25 253.13,79.75 253.13,80.69 252.67,81.14 250.15,81.14 246.45,84.84 246.45,88.18 245.51,89.12 245.51,90.82 244.46,91.87 241.21,91.87 238.62,94.45 237.2,94.45 236.09,95.56 232.33,95.56 231.4,96.49 229.83,96.49 229.2,97.12 227.95,97.12 227.5,96.67 226.38,96.67 225.52,97.54 221.67,97.54 221.6,97.47 203.89,97.47 203.22,96.8 199.74,96.8 198.67,95.73 165.53,95.73 163.01,93.22 162.31,93.22 159.23,90.13 157.26,90.13 154.99,87.86 154.99,85.4 153.62,84.03 153.13,84.03 v2(152.92,84.24)
  BOTTOM w0.102: v2(152.92,84.24) 152.73,84.05 152.5,84.05 152.28,83.83 152.28,83.28 152.75,82.81 152.75,81.22 152.99,80.98 153.17,80.98 153.32,80.83 UC1.AF3
DMI_CTX_PRX_P0: length 200.2
  TOP w0.094: UH1.J35 276.37,45.3 v2(276.46,45.21)
  IN1 w0.084: v2(152.66,88.68) 152.83,88.51 152.95,88.51 156.48,92.03 158.44,92.03 161.52,95.11 162.23,95.11 164.74,97.63 180.43,97.63 181.37,98.57 184.82,98.57 184.91,98.48 198.73,98.48 199.99,99.73 211.02,99.73 211.31,99.44 229.85,99.44 230.28,99.01 241.51,99.01 246.13,94.39 246.13,93.44 248.99,90.58 248.99,90.09 250.75,88.33 251.75,88.33 253.2,86.87 253.2,84.73 257.53,80.41 257.53,73.42 258.02,72.93 258.02,57.42 258.13,57.31 258.13,53.89 258.64,53.38 258.64,50.8 259.33,50.11 259.33,40.28 261.61,38 267.18,38 267.65,37.53 278.34,37.53 278.75,37.93 278.75,40.27 278.4,40.62 278.4,40.94 276.42,42.92 276.42,44.47 276.95,45 276.95,45.19 276.79,45.34 276.7,45.36 v2(276.46,45.21)
  BOTTOM w0.102: UC1.AC2 150.58,81.97 150.51,82.04 150.22,82.04 150,82.26 150,83.2 150.31,83.51 150.31,84.95 150.3,84.96 150.3,84.99
  BOTTOM w0.112: v2(152.66,88.68) 151.81,88.68 150.3,87.17 150.3,84.99
DMI_CTX_PRX_P1: length 199.5
  TOP w0.089: v2(276.98,43.84) 276.87,43.96 UH1.F34
  IN1 w0.084: v2(276.98,43.84) 277.1,43.97 277.26,43.97 277.52,43.7 277.52,42.71 279.03,41.2 279.03,40.88 279.48,40.43 279.48,37.77 278.61,36.9 267.39,36.9 266.92,37.37 261.35,37.37 258.7,40.02 258.7,49.85 258.01,50.54 258.01,52.6 257.5,53.11 257.5,57.05 256.9,57.65 256.9,80.07 255.37,81.6 254.42,81.6 251.52,84.49 250.04,84.49 248.15,86.38 248.15,90.49 244.78,93.85 244.13,93.85 243.18,94.81 241.03,94.81 237.46,98.38 230.02,98.38 229.59,98.8 211.05,98.8 210.76,99.1 200.25,99.1 198.99,97.84 181.54,97.84 180.69,96.99 165,96.99 162.49,94.48 161.78,94.48 158.7,91.4 156.74,91.4 153.53,88.19 153.53,87.36 153.06,86.89 152.71,86.89 v2(152.5,87.09)
  BOTTOM w0.102: UC1.AD3 151.25,81.05 151.14,81.05 150.92,81.27 150.92,83.01 150.91,83.02 150.91,83.43 151.13,83.66 151.13,84.95 151.12,84.96 151.12,84.99
  BOTTOM w0.112: 151.12,84.99 151.12,86.67 151.37,86.91 152.32,86.91 v2(152.5,87.09)
DMI_CTX_PRX_P2: length 200.5
  TOP w0.094: UH1.J32 277.37,45.01 277.5,45.01 v2(277.53,45.04)
  IN1 w0.084: v2(152.7,85.81) 152.9,85.6 153.56,85.6 154.16,86.2 154.16,87.92 157,90.76 158.96,90.76 162.05,93.85 162.75,93.85 165.27,96.36 198.41,96.36 200.48,98.43 210.53,98.43 210.79,98.17 229.33,98.17 229.76,97.74 236.81,97.74 239.59,94.97 239.59,94.71 240.35,93.94 242.64,93.94 243.17,93.41 243.17,93 243.6,92.57 244.72,92.57 246.17,91.13 246.17,89.5 247.39,88.28 247.39,84.93 249.47,82.84 252.22,82.84 256.27,78.8 256.27,67.8 256.23,67.77 256.23,57.42 256.86,56.79 256.86,50.32 257.83,49.35 257.83,39.98 261.09,36.73 266.66,36.73 267.13,36.26 279.07,36.26 280.11,37.3 280.11,41.61 279.7,42.02 279.11,42.02 278.24,42.89 278.24,44.73 277.96,45.01 277.96,45.13 277.86,45.24 277.73,45.24 v2(277.53,45.04)
  BOTTOM w0.102: UC1.AE2 152.41,81.82 152.21,82.01 152.05,82.01 151.83,82.23 151.83,82.99 151.87,83.03 151.87,83.35 151.83,83.39 151.83,84.78 151.84,84.78 151.84,84.99
  BOTTOM w0.112: 151.84,84.99 151.84,85.35 152.12,85.63 152.51,85.63 v2(152.7,85.81)
DMI_CTX_PRX_P3: length 201.9
  TOP w0.094: v2(279.42,43.89) 279.17,44.14 278.24,44.14 UH1.F30
  IN1 w0.084: v2(279.42,43.89) 279.22,44.09 279.14,44.09 279.05,44.01 279.05,43.21 279.44,42.82 280.03,42.82 280.91,41.94 280.91,36.97 278.47,34.53 273.66,34.53 272.72,35.46 267.35,35.46 266.86,34.97 261.71,34.97 257.03,39.65 257.03,48.98 256.06,49.94 256.06,56.45 255.43,57.09 255.43,68.1 255.47,68.13 255.47,77.18 252.96,79.68 252.96,80.62 252.6,80.97 250.08,80.97 246.28,84.77 246.28,88.11 245.34,89.05 245.34,90.75 244.39,91.7 241.14,91.7 238.55,94.28 237.13,94.28 236.02,95.39 232.26,95.39 231.33,96.32 229.76,96.32 229.13,96.95 228.02,96.95 227.57,96.51 226.31,96.51 225.45,97.37 221.74,97.37 221.67,97.3 203.96,97.3 203.29,96.63 199.81,96.63 198.74,95.56 165.6,95.56 163.08,93.05 162.38,93.05 159.3,89.96 157.33,89.96 155.16,87.79 155.16,85.33 153.67,83.84 153.11,83.84 v2(152.92,83.65)
  BOTTOM w0.102: v2(152.92,83.65) 152.73,83.84 152.59,83.84 152.48,83.74 152.48,83.36 152.95,82.89 152.95,81.3 153.07,81.18 153.17,81.18 153.22,81.18 153.32,81.28 UC1.AF2
DP_HPD_PCH: length 171.6
  TOP w0.089: UH1.AW24 v2(281.66,60.1)
  TOP w0.112: v2(181.92,137.18) 180.47,137.18 178.62,135.34 v1(173.51,135.34) 173.26,135.34 v2(172.73,134.81)
  IN1 w0.084: v2(181.92,137.18) 181.92,136.12 181.31,135.51 181.31,133.8 180.56,133.05 180.56,129.65 180.89,129.33 180.89,125.22 181.09,125.02 181.09,123.71 182.17,122.63 190.54,122.63 198.34,114.83 198.34,113.99 201.13,111.2 201.97,111.2 206.43,106.74 215.1,106.74 215.76,106.08 234.7,106.08 235.16,105.63 250.53,105.63 251.59,104.57 262.25,104.57 266.96,99.86 268.53,99.86 274.92,93.48 274.92,89.56 282.52,81.96 282.52,74.11 281.04,72.63 281.04,72.05 280.72,71.73 280.4,71.73 279.82,71.14 279.82,69.6 279.48,69.26 279.48,66.68 281.26,64.89 281.26,60.52 281.66,60.12 v2(281.66,60.1)
  BOTTOM w0.112: v2(172.73,134.81) 173.07,135.14 JDGFF1.G9
DPSNK_RBIAS: length 4
  TOP w0.112: v2(28.13,40.61) 28.13,40.25 28.67,39.71 v1(28.67,38.63)
  TOP w0.127: v2(28.13,40.61) 28.13,40.62 RT19.1
  BOTTOM w0.102: UT1.Y18 v2(28.13,40.61)
DPSRC_RBIAS: length 8
  TOP w0.076: v2(24.73,49.07) 24.73,49.29 v1(25.49,50.06)
  IN1 w0.084: v2(25.52,45.17) 25.07,45.62 25.07,46.58 24.49,47.17 24.49,48.72 24.73,48.96 v2(24.73,49.07)
  BOTTOM w0.102: UT1.N6 v2(25.52,45.17)
  BOTTOM w0.112: RT5.1 24.38,50.17 24.64,49.91 24.64,49.15 v2(24.73,49.07)
EC_AC_BAT#: length 287.3
  TOP w0.112: v2(279.35,24.09) 279.35,24.65 v1(280.32,25.62) ; v2(303.89,18.39) 304,18.28 UE5.82
  TOP w0.203: v2(162.26,159.85) 159.54,159.85 157.81,161.58 157.81,165.69 157.12,166.39 155.36,166.39 v2(154.44,165.47)
  IN2 w0.104: v2(162.26,159.85) 162.08,159.68 162.08,150.86 162.78,150.16 162.78,147.68 171.13,139.33 v2(172.55,139.33) 172.55,136.43 173.14,135.83 173.14,134.35 171.6,132.8 171.56,132.8 170.34,131.57 170.34,126.78 186.75,110.37 186.75,106.92 191.95,101.73 195.56,101.73 196.05,101.23 197.17,101.23 197.9,101.96 211.44,101.96 212.42,100.98 236.95,100.98 237.45,100.48 253.79,100.48 254.38,99.89 258.7,99.89 263.36,95.23 263.36,85.3 264.57,84.1 v2(264.57,82.83)
  IN3 w0.104: v2(303.89,18.39) 295.8,18.39 295.57,18.16 291,18.16 290.42,18.74 287.83,18.74 287.03,19.54 285.72,19.54 282.88,22.39 281.06,22.39 v2(279.35,24.09)
  BOTTOM w0.112: v2(264.57,82.83) 265.33,82.07 265.33,68.43 265.85,67.9 265.85,61.76 265.56,61.46 265.56,58.91 265.16,58.51 265.16,55.73 263.78,54.35 263.78,51.43 262.76,50.41 262.76,48.12 262.14,47.5 262.14,39.91 264.81,37.23 264.81,34.91 268.61,31.11 271.36,31.11 274.88,27.59 275.85,27.59 v2(279.35,24.09) ; JDGFF2.A10 172.47,140.44 172.11,140.08 172.11,139.57 172.35,139.33 v2(172.55,139.33)
  BOTTOM w0.254: PR44.1 155.16,164.74 v2(154.44,165.47) 154.44,166.16 152.65,167.96 150.88,167.96 150.64,168.2 PR45.1
EC_AMP_RST#: length 290.4
  TOP w0.112: v2(40.63,16.42) 40.49,16.42 v1(40.22,16.15) ; RE695.2 309.25,22.1 308.67,21.51 v2(308.46,21.51) 308.42,21.48 UE5.90
  IN3 w0.104: v2(40.63,16.42) 40.81,16.24 45.06,16.24 47.1,14.21 47.86,14.21 48.57,13.5 50.3,13.5 50.67,13.12 59.04,13.12 59.69,13.78 61.59,13.78 62.27,13.1 65.08,13.1 66.52,11.66 81.83,11.66 83.57,13.39 87.69,13.39 89.73,15.43 93.12,15.43 95.07,13.49 105.41,13.49 106.26,12.64 108.87,12.64 109.76,12.64 112.15,10.25 115.03,10.25 115.8,11.02 117.98,11.02 118.6,10.41 122.86,10.41 123.13,10.14 125.11,10.14 125.78,9.47 133.09,9.47 133.53,9.9 141.05,9.9 141.51,9.45 155.68,9.45 156.4,10.17 178.62,10.17 179.33,10.88 186.5,10.88 189.18,13.56 232.81,13.56 234.22,14.97 237.01,14.97 239.05,17 259.67,17 267.51,24.84 269.86,24.84 271.22,26.2 283.83,26.2 285.54,24.49 287.87,24.49 288.34,24.96 289.35,24.96 291.92,22.39 292.94,22.39 293.14,22.19 297.18,22.19 297.58,22.58 300.51,22.58 301.98,21.11 308.06,21.11 v2(308.46,21.51)
  BOTTOM w0.112: v2(40.63,16.42) 39.56,15.34 JAUDIO.7
EC_CLK1: length 5
  TOP w0.112: RE668.1 310.84,18.92 v1(310.73,18.82) 310.73,18.76 310.16,18.18 308.58,18.18 308.08,18.68 UE5.83
EC_CODEC_EAPD#: length 308.8
  TOP w0.112: QE64.2 313.27,23.28 313.16,23.39 312.57,23.39 312.14,23.82 RE699.1 RE696.2 313.53,23.9 313.91,23.52 314.4,23.52 315.78,22.14 v1(315.78,20.79) 315.78,19.95 316.39,19.33 316.39,19.02 316.39,18.97 315.32,17.9 v2(313.56,17.9)
  IN3 w0.104: v2(313.56,17.9) 312.36,19.09 311.43,19.09 311.33,19.2 311.33,20.26 310.71,20.88 301.89,20.88 300.42,22.35 298.06,22.35 297.41,21.7 297.41,20.9 297.2,20.7 295.44,20.7 294.81,21.32 292.77,21.32 292.14,21.96 292.03,21.96 289.25,24.73 288.43,24.73 287.96,24.26 285.44,24.26 283.73,25.97 271.31,25.97 269.95,24.61 267.72,24.61 259.88,16.77 239.14,16.77 237.11,14.74 234.31,14.74 232.9,13.33 189.27,13.33 186.59,10.65 179.42,10.65 178.72,9.94 156.5,9.94 155.78,9.22 141.41,9.22 140.96,9.67 133.62,9.67 133.18,9.23 125.63,9.23 124.96,9.9 123.04,9.9 122.77,10.17 118.5,10.17 117.89,10.79 115.9,10.79 115.13,10.02 112.06,10.02 109.66,12.41 108.96,12.41 106.16,12.41 105.32,13.26 94.97,13.26 93.03,15.2 89.83,15.2 87.79,13.16 83.67,13.16 81.92,11.41 64.49,11.41 63.04,12.87 50.6,12.87 50.21,13.26 48.47,13.26 47.76,13.98 47,13.98 44.97,16.01 39.65,16.01 39.45,16.2 v2(39.45,16.2)
  BOTTOM w0.112: JAUDIO.8 39.06,15.35 39.45,15.75 39.45,16 39.46,16.02 39.46,16.18 39.45,16.19 v2(39.45,16.2)
EC_DAT1: length 5.1
  TOP w0.112: RE669.1 309.15,19.52 309.02,19.39 309.02,19.15 309.13,19.04 309.37,19.04 309.49,19.16 309.92,19.16 310.04,19.05 310.04,18.79 309.92,18.68 308.78,18.68 v1(308.73,18.72) 308.38,19.08 UE5.84
EC_EAPD#: length 7.3
  TOP w0.112: UE5.93 308.15,22.68 308.16,22.66 309.13,22.66 309.24,22.78 v1(311.31,22.78) 312.52,22.78 QE64.3 312.3,23.2 312.01,23.2 RE700.2
EC_EN_AMP: length 208.9
  TOP w0.112: UE10.11 245.22,12.56 244.82,12.96 v1(244.82,14.63) 244.82,15.13 244.71,15.24 199.64,15.24 191.26,23.62 179.68,23.62 178.54,22.47 149.24,22.47 146.71,25 138.11,25 135.13,22.02 122.91,22.02 v2(121.44,20.55)
  IN1 w0.084: v2(121.44,20.55) 121.44,16.41 118.38,13.35 112.84,13.35 110.52,15.66 109.1,15.66 107.06,17.7 93.17,17.7 92.18,16.71 87.8,16.71 87.22,16.13 82.74,16.13 76.58,22.29 73.86,22.29 73.01,21.44 68.04,21.44 67.44,22.04 65.03,22.04 64.1,22.97 61.02,22.97 v2(60.86,22.82)
  BOTTOM w0.112: v2(60.86,22.82) 60.81,22.87 PR17.2 58.91,22.88 PR20.1
EC_ENBKL: length 288.4
  TOP w0.112: v2(309.88,12.22) 310.26,11.83 v1(313.21,11.83) 313.46,11.83 313.76,12.13 313.76,14.7 RE701.2
  IN2 w0.104: v2(181.84,142.18) 181.84,142.17 182.27,141.73 182.27,139.28 181.31,138.31 181.31,135.35 180.52,134.57 180.52,130.31 177.38,127.18 177.38,122.57 188.54,111.42 188.54,108.87 191.35,106.06 191.35,105.69 194.16,102.88 211.82,102.88 212.81,101.9 237.33,101.9 237.83,101.4 254.17,101.4 254.76,100.82 259.08,100.82 260.03,99.87 262.82,99.87 264.05,98.64 264.05,87.09 v2(264.57,86.57)
  BOTTOM w0.112: v2(181.84,142.18) 182.19,142.18 184.05,144.04 184.05,145.69 183.81,145.93 182.75,145.93 181.75,144.94 179.55,144.94 178.55,145.93 178.28,145.93 177.27,146.95 JDGFF2.E2 ; v2(264.57,86.57) 263.19,85.2 263.19,83.17 261.39,81.36 261.39,73.62 261.3,73.53 261.3,71.22 260.74,70.66 260.74,67.8 259.94,67 259.94,63.3 260.96,62.29 260.96,61.15 261.06,61.05 261.06,58.73 260.28,57.95 260.28,57.11 259.3,56.13 259.3,53.53 260.37,52.46 260.37,49.17 259.75,48.55 259.75,38.77 262.33,36.19 262.33,34.01 267.71,28.63 269.56,28.63 276.53,21.66 283.58,21.66 285.75,19.49 285.75,18.89 286.46,18.17 286.46,14.68 285.67,13.88 285.67,11.97 283.77,10.07 283.77,7.98 283.3,7.51 283.3,5.19 284.19,4.31 289.55,4.31 292,6.76 292,8.51 293.93,10.43 304.62,10.43 305.45,11.26 305.45,12.07 306.57,13.2 309.31,13.2 309.88,12.63 v2(309.88,12.22)
EC_ESB_CLK: length 60.7
  TOP w0.112: v2(289.97,17.87) 290.01,17.83 290.22,17.83 290.57,17.48 UE5.17 ; RE642.2 249.38,7.21 v2(249.01,7.58) 248.47,8.12 UE10.1 ; v2(284.45,6.94) 284.54,7.04 284.54,7.32 284.43,7.43 UE6.1
  IN1 w0.084: v2(284.45,6.94) 284.25,7.14 282.16,7.14 281.04,8.26 280.05,8.26 277.46,10.85 276.66,10.85 276.05,10.24 271.61,10.24 269.04,7.67 269.04,5.41 267.93,4.3 262.13,4.3 261.39,5.04 253.49,5.04 251.57,6.96 249.63,6.96 v2(249.01,7.58)
  BOTTOM w0.112: v2(289.97,17.87) 289.97,17.76 289.67,17.46 289.11,17.46 287.67,16.02 287.67,14.18 286.91,13.41 286.91,11.44 v1(285.53,10.06) 285.47,10.06 284.98,9.57 284.98,7.48 v2(284.45,6.94)
EC_ESB_DAT: length 61.3
  TOP w0.112: RE643.2 249.17,9.42 v2(249.01,9.42) 248.76,9.42 248.56,9.62 UE10.4 ; v2(285.59,9.04) 285.48,8.93 UE6.4 ; v2(289.37,17.02) 289.77,17.42 290.22,17.42 290.57,17.08 UE5.18
  IN1 w0.084: v2(249.01,9.42) 251,7.42 251.77,7.42 253.68,5.51 261.59,5.51 262.32,4.77 267.74,4.77 268.57,5.6 268.57,7.86 271.42,10.71 275.86,10.71 276.47,11.31 277.65,11.31 279.86,9.1 285.53,9.1 v2(285.59,9.04)
  BOTTOM w0.112: v2(285.59,9.04) 285.47,8.93 285.47,8.3 285.69,8.09 286.24,8.09 287.21,9.06 v1(287.21,10.66) 287.4,10.85 287.4,13.21 288.17,13.97 288.17,15.81 v2(289.37,17.02)
EC_ON: length 39.3
  TOP w0.112: PD301.2 321.81,15.96 321.34,15.5 v1(321.34,15.26) 321.52,15.08 v2(321.52,14.65) ; UE5.112 299.54,24.02 297.37,21.84 297.37,19.24 295.66,17.52 295.66,16.99 295.96,16.69 297.31,16.69 298.22,15.77 300.31,15.77 v2(300.58,16.04)
  IN3 w0.104: v2(300.58,16.04) 300.65,16.12 306.36,16.12 307.17,15.3 320.87,15.3 v2(321.52,14.65)
EC_PECI: length 254.3
  TOP w0.112: v2(296.18,31.05) 296.32,30.92 296.32,30.12 v1(296.19,30) 296.11,29.91 RE76.2
  IN4 w0.084: v2(296.18,31.05) 296.18,31.74 298.04,33.6 298.04,37.36 296.15,39.26 296.15,44.87 296.9,45.62 296.9,50.89 297.66,51.65 299.51,51.65 299.8,51.36 301.52,51.36 301.75,51.59 301.99,51.83 301.99,53.36 299.45,55.9 299.45,68.26 295.18,72.54 295.18,75.04 267.34,102.88 228.54,102.88 227.86,102.2 212.02,102.2 211.33,102.89 184.39,102.89 179.85,107.43 174.84,107.43 169.61,102.2 164.62,102.2 161.78,99.36 156.41,99.36 150.86,93.81 132.58,93.81 126.03,87.26 123.48,87.26 v2(122.31,86.08)
  BOTTOM w0.112: v2(122.31,86.08) 120.54,86.08 119.99,86.64 R394.1
EC_PECI_R: length 2.9
  TOP w0.112: RE76.1 296.13,27.73 296.57,27.3 296.88,27.3 297.14,27.04 UE5.118
EC_RSMRST#: length 372.4
  TOP w0.089: UH1.BA47 269.51,61.57 269.1,61.57 269.05,61.51 268.52,61.51 268.39,61.38 267.77,61.38 265.78,63.38 265.78,65.1 265.63,65.24
  TOP w0.112: v2(305.87,28.93) 305.88,28.93 305.99,28.82 DE2.2 305.52,27.59 305.05,27.59 304.34,26.88 UE5.100 ; v2(53.71,31.52) 54.32,32.13 54.32,33.23 55.09,34 55.09,36.86 v3(54.9,37.05) 54.52,37.43 54.52,41.29 RC355.2 ; 265.63,65.24 265.63,65.98 264.58,67.04 263.9,67.04 262.91,68.02 RH88.2 262.79,68.43 262.33,67.96 261.26,67.96 v2(261.15,68.07) 260.61,68.62 RH1017.2
  IN3 w0.104: v2(305.87,28.93) 305.87,29 305.52,29.34 303.61,29.34 301.87,31.09 301.87,31.58 299.09,34.36 296.47,34.36 295.25,35.58 295.25,41.04 294.31,41.97 294.31,44.66 292.03,46.95 292.03,53 292.09,53.07 292.1,53.07 292.23,53.2 292.23,56.71 291.41,57.54 291.41,60.94 290.41,61.94 290.41,62.65 289.32,63.74 284.42,63.74 283.87,64.29 283.87,64.86 283.68,65.05 282.84,65.05 282.71,64.92 282.71,64.07 282.42,63.78 271.42,63.78 267.24,67.96 264.38,67.96 263.68,68.67 262.15,68.67 261.56,68.07 v2(261.15,68.07)
  IN4 w0.084: v2(261.15,68.07) 259.71,68.07 259.36,67.71 257.26,67.71 255.75,66.21 254.46,66.21 254.14,65.88 254.14,26.47 250.08,22.42 244.06,22.42 239.71,18.07 187.98,18.07 180.92,11.01 169.13,11.01 168.93,10.81 144.09,10.81 143.25,11.65 141.31,11.65 140.86,12.09 130.76,12.09 130.6,12.26 124.6,12.26 123.32,13.54 118.54,13.54 117.69,14.4 113.06,14.4 109.62,17.83 108.62,17.83 108.46,17.68 100.47,17.68 98.97,19.18 91.41,19.18 91.32,19.27 91.1,19.48 87.84,19.48 87.53,19.18 87.36,19.18 62.71,19.18 59.21,22.67 58.62,22.67 56.47,24.82 56.47,27.07 54.32,29.22 54.32,31.07 53.88,31.52 v2(53.71,31.52)
EC_RTCRST: length 4.4
  TOP w0.112: QE5.2 RE650.1 241.62,10.12 v1(242.22,10.12) UE10.14
EC_RX: length 142.6
  TOP w0.112: RN119.2 342.92,42.99 344.91,42.99 345.15,42.76 v1(345.79,42.76) 347.81,42.76 348.51,43.46 349.9,43.46 v2(350.06,43.3) ; v2(298.07,12.55) 297.37,13.25 296.2,13.25 294.83,11.88 UE5.31
  IN1 w0.084: v2(374.08,36.06) 374.45,35.68 374.45,18.93 372.77,17.25 365.72,17.25 364.45,15.98 357.25,15.98 352.85,11.58 340.71,11.58 338.38,9.25 305.73,9.25 305.41,9.57 303.6,9.57 300.22,12.94 298.47,12.94 v2(298.07,12.55)
  IN4 w0.084: v2(374.08,36.06) 374.03,36.01 372.26,36.01 371.48,36.79 368.78,36.79 368.35,37.22 363.39,37.22 362.29,36.12 360.23,36.12 357.62,38.73 354.72,38.73 350.15,43.3 v2(350.06,43.3)
EC_SCI#: length 96.6
  TOP w0.089: v2(279.66,59.73) 279.62,59.69 279.62,59.56 279.84,59.34 UH1.AU26
  TOP w0.112: v2(281.65,72.23) 282.26,72.23 RH521.2 ; v2(280.31,23.99) 280.31,23.01 281.05,22.28 282.06,22.28 286.08,18.26 286.08,16.71 v1(286.54,16.25) RE694.1
  IN2 w0.104: v2(279.66,59.73) 280.06,60.13 280.06,67.49 v2(280.31,67.75) 281.28,68.71 281.28,70.33 281.93,70.98 281.93,71.95 v2(281.65,72.23)
  IN3 w0.104: v2(280.31,67.75) 279.61,67.04 276.41,67.04 274.82,68.63 271.18,68.63 v2(271.01,68.46)
  BOTTOM w0.112: v2(280.31,23.99) 280.31,25.25 277.73,27.83 274.98,27.83 271.46,31.35 268.71,31.35 265.05,35 265.05,37.33 262.37,40.01 262.37,47.4 263,48.02 263,50.31 264.02,51.33 264.02,54.25 265.4,55.63 265.4,56.67 267.25,58.52 267.25,64.7 v2(271.01,68.46)
EC_SMB_CK1: length 683.7
  TOP w0.112: PR11.2 72.99,11.59 72.99,11.9 72.55,12.34 71.15,12.34 70.32,11.51 PD3.2 69.41,11.51 69.16,11.25 68.79,11.25 68.1,10.56 68.1,8.64 v2(68.01,8.55) 68.04,8.52 68.04,8.02 67.72,7.71 66.26,7.71 64.62,9.34 53.72,9.34 53.35,9.71 53.35,10.23 53.56,10.43 UT7.11 ; UE5.77 308.27,16.28 308.39,16.16 308.39,16.14 v2(308.45,16.08) 308.97,16.08 309.05,16.16 RE90.4 ; v2(212.37,139.72) 211.81,139.72 PR770.1
  IN1 w0.084: v2(43.14,39.64) 43.02,39.76 43.02,39.98 43.19,40.16 47.42,40.16 58.42,51.15 82.63,51.15 95.95,64.48 97.38,64.48 101.83,68.93 101.83,77.93 107.69,83.78 107.69,90.63 108.19,91.13 111.11,94.05 115.97,94.05 116.7,93.32 118.99,93.32 119.43,92.88 122.79,92.88 123.23,93.32 130.89,93.32 138.34,100.77 138.34,102.89 141.76,106.31 141.76,107.18 144.23,109.65 146.29,109.65 147.83,111.19 147.83,119.93 150.48,122.59 154.47,122.59 159.36,127.48 159.36,134.11 161.98,136.73 161.98,141.73 159.41,144.3 153.26,144.3 151.89,145.67 151.61,145.67 150.72,146.56 150.12,146.56 149.25,147.42 149.25,147.99 v2(149.31,148.05)
  IN4 w0.084: v2(127.19,150.41) 127.13,150.47 127.13,151.04 127.68,151.6 133.31,151.6 136,148.91 141.02,148.91 143.16,146.77 148.74,146.77 149.25,147.28 149.25,147.99 v2(149.31,148.05) ; v2(189.83,159.18) 189.78,159.24 189.78,159.77 190.26,160.26 191.85,160.26 192.56,160.97 204.84,160.97 206.57,159.24 206.57,149.44 209.12,146.89 209.12,143.97 210.88,142.21 212.29,142.21 213.04,141.47 213.04,139.97 212.79,139.72 v2(212.37,139.72) ; v2(289.2,5.82) 289.14,5.88 278.3,5.88 275.04,2.63 267.47,2.63 266.91,3.18 242.11,3.18 241.06,4.23 223.06,4.23 222.57,3.73 219.03,3.73 218.54,4.23 200.27,4.23 195.19,9.31 191.04,9.31 182.94,1.21 167.55,1.21 165.55,3.21 127.08,3.21 125.18,1.31 121.92,1.31 118.12,5.11 111.12,5.11 108.12,8.11 97.28,8.11 94.89,5.71 85.17,5.71 81.25,9.62 73.07,9.62 71.02,7.58 68.42,7.58 68.06,7.94 68.06,8.5 v2(68.01,8.55) 68.08,8.62 68.08,9.03 67.93,9.18 67.42,9.18 66.58,8.34 48.08,8.34 43.06,13.36 43.06,17.34 43.39,17.68 43.39,19.96 v2(43.91,20.47)
  BOTTOM w0.112: v2(189.83,159.18) 189.81,159.15 189.81,157.72 187.98,155.89 179.57,155.89 177.72,157.74 175.81,157.74 171.27,162.28 167.65,162.28 165.25,164.68 162.9,164.68 161.79,163.56 158.55,163.56 153.21,158.23 153.21,157.6 152.76,157.14 152.76,151 151.63,149.88 149.82,149.88 149.22,149.28 149.22,148.14 v2(149.31,148.05) 149.21,147.95 149.21,147.47 PRS32.1 ; RT60.1 43.05,39.73 v2(43.14,39.64) 43.07,39.57 43.07,39.06 42.16,38.16 42.16,31.62 43.24,30.54 43.24,28.51 45.52,26.24 45.52,23.32 44.58,22.38 44.58,20.9 RT709.2 44.1,20.66 v2(43.91,20.47) ; v2(289.2,5.82) 289.3,5.91 289.45,5.91 290.53,6.99 290.53,9.67 291.52,10.66 291.52,11.4 291.76,11.64 300.37,11.64 303.11,14.37 305.78,14.37 307.58,16.17 308.29,16.17 308.39,16.08 v2(308.45,16.08) ; v2(127.19,150.41) 127.19,149.76 PRS12.1
EC_SMB_CK2: length 607.9
  TOP w0.112: v2(278.76,75.99) 279.08,75.67 QH5.1 ; v2(299.05,20.9) 299.07,20.9 299.09,20.87 299.09,20.78 302.93,16.95 305.48,16.95 305.59,17.06 307.09,17.06 307.11,17.08 UE5.79 307.19,17.06 308.27,17.06 308.39,17.17 310.31,17.17 RE90.2
  IN1 w0.084: v2(299.05,20.9) 298.96,20.9 297.77,19.7 295.5,19.7 294.35,20.85 291.22,20.85 290.01,22.05 289.12,22.05 288.92,21.86 287.87,21.86 287.72,21.72 275.53,21.72 271.66,25.59 260.85,25.59 260.36,26.07 257.15,26.07 256.59,25.51 256.59,24.91 253.01,21.34 249.69,21.34 239.16,10.8 230.5,10.8 228.89,12.42 v2(228.19,12.42) 228.16,12.39 228.16,11.79 227.74,11.37 227.06,11.37 226.71,11.73 226.71,16.09 223.68,19.11 191.18,19.11 184.93,12.85 169.13,12.85 161.92,5.64 126.79,5.64 126.16,6.26 121.94,6.26 v2(121.3,6.91) ; v2(278.76,75.99) 278.67,75.89 278.67,75.02 278.96,74.73 279.08,74.73 279.28,74.93 279.28,75.05 279.19,75.14 279.19,79.36 278.23,80.32 278.23,83.32 273.26,88.29 270.78,88.29 264.23,94.84 262.54,94.84 254.05,103.33 251.03,103.33 250.09,104.27 234.46,104.27 234.24,104.5 224.01,104.5 223.23,103.72 218.7,103.72 217.83,104.59 214.84,104.59 213.94,105.49 205.07,105.49 197.09,113.47 197.09,113.84 189.55,121.38 181.65,121.38 179.65,123.39 179.65,124.73 179.03,125.35 179.03,129.28 179.32,129.57 179.32,133.57 180.07,134.31 180.07,136.02 180.67,136.63 180.67,139.19 181.68,140.2 181.68,141.11 180.8,141.99 180.8,142.34 179.4,143.74 179.4,148.47 v2(179,148.87) 178.81,149.06 178.81,149.82 179.4,150.41 179.4,152.89 176.61,155.69 176.61,156.84 175.56,157.88 173.76,157.88 170.67,160.98 166.63,160.98 165.95,160.3 159.39,160.3 158.39,161.3 157.89,161.8 157.89,166.73 160.85,169.7 163.9,169.7 165.76,171.56 168.21,171.56 168.52,171.87 171.79,171.87 172.08,172.16 174.42,172.16 176.22,173.95 176.22,175.11 175.45,175.88 175.45,178.39 177.04,179.98 177.04,180.77 176.92,180.89 176.8,180.89 v2(176.74,180.83)
  IN4 w0.084: v2(278.76,75.99) 278.69,76.06 278.69,76.94 279.58,77.83 282.52,77.83 283.65,76.7 285.22,76.7 289.7,72.22 289.7,69.01 291.26,67.45 291.26,64.45 292.29,63.42 292.29,59.11 291.97,58.8 291.97,57.42 293.1,56.29 293.1,52.8 293.75,52.15 294.37,52.15 296.04,50.48 296.04,46.04 295.85,45.85 295.85,45.85 295.29,45.29 295.29,38.19 295.68,37.81 295.68,35.01 294.6,33.93 294.6,26.65 294.98,26.27 295.5,26.27 297.54,24.23 297.54,23.63 299.17,21.99 299.17,21.19 299.05,21.06 v2(299.05,20.9)
  BOTTOM w0.112: v2(179,148.87) 179.1,148.77 179.1,147.53 178.85,147.28 178.53,147.28 178.26,147.55 178.21,147.6 178.21,147.85 177.9,148.16 JDGFF2.F1 ; UM8.50 176.54,180.8 176.56,180.82 176.73,180.82 v2(176.74,180.83) ; JPK.16 228.45,12.16 v2(228.19,12.42) 227.55,13.06 DK2.2 ; v2(278.76,75.99) 278.86,76.08 278.86,77.4 275.34,80.92 274.33,80.92 272.46,82.79 272.46,93.69 269.19,96.96 248.98,96.96 246.85,99.09 235.8,99.09 235.11,99.78 215.29,99.78 214.8,100.28 214.8,106.76 215.23,107.19 217.45,107.19 217.45,107.2 U2407.10 ; U2408.8 120.54,7.28 120.87,6.94 121.26,6.94 v2(121.3,6.91) 121.34,6.95 121.77,6.95 R408.1
EC_SMB_DA1: length 686.6
  TOP w0.112: UE5.78 308.37,16.68 308.39,16.67 v2(308.45,16.67) 308.7,16.67 308.71,16.68 310.31,16.68 RE90.3 ; UT7.10 52.74,10.43 52.86,10.32 52.86,9.5 53.51,8.85 v1(64.42,8.85) 66.05,7.21 67.93,7.21 68.58,7.87 68.58,8.54 v2(68.6,8.55) 68.59,8.55 68.59,10.36 69,10.76 69.16,10.76 69.41,10.51 PD3.3 70.01,10.51 71.35,11.85 72.34,11.85 72.5,11.69 72.5,11.59 PR12.2 ; RT710.2 43.97,17.47 43.86,17.36 v2(43.86,17.3) ; PR769.1 211.7,139.23 212.28,139.23 v2(212.37,139.14)
  IN1 w0.084: v2(148.73,148.05) 148.73,147.68 148.79,147.62 148.79,147.23 149.93,146.09 150.53,146.09 151.42,145.2 151.7,145.2 153.07,143.83 159.22,143.83 161.51,141.54 161.51,136.92 158.89,134.3 158.89,127.67 154.28,123.06 150.29,123.06 147.36,120.13 147.36,111.38 146.09,110.11 144.04,110.11 141.29,107.37 141.29,106.5 137.88,103.09 137.88,100.96 130.7,93.78 123.04,93.78 122.6,93.34 119.63,93.34 119.18,93.78 116.89,93.78 116.17,94.51 110.91,94.51 107.99,91.59 107.22,90.82 107.22,83.98 101.37,78.12 101.37,69.12 97.19,64.94 95.76,64.94 82.44,51.62 58.22,51.62 47.23,40.62 43,40.62 42.55,40.18 42.55,39.7 v2(42.49,39.63)
  IN4 w0.084: v2(43.21,20.47) 43.67,20.93 44.1,20.93 44.37,20.66 44.37,20.28 43.86,19.76 v2(43.86,17.3) 43.53,16.96 43.53,13.55 48.27,8.81 66.38,8.81 67.22,9.65 68.13,9.65 68.55,9.23 68.55,8.6 v2(68.6,8.55) 68.52,8.48 68.52,8.13 68.61,8.04 70.83,8.04 72.87,10.09 81.45,10.09 85.36,6.18 94.69,6.18 97.09,8.58 108.31,8.58 111.31,5.58 118.31,5.58 122.11,1.78 124.99,1.78 126.89,3.68 165.75,3.68 167.75,1.68 182.74,1.68 190.84,9.78 195.38,9.78 200.47,4.69 218.73,4.69 219.22,4.2 222.38,4.2 222.87,4.69 241.25,4.69 242.3,3.65 267.1,3.65 267.66,3.09 274.85,3.09 278.11,6.35 289.14,6.35 v2(289.2,6.41) ; v2(126.6,150.41) 126.66,150.47 126.66,151.24 127.49,152.06 133.5,152.06 136.19,149.38 141.21,149.38 143.35,147.24 148.55,147.24 148.79,147.47 148.79,147.99 v2(148.73,148.05) ; v2(189.25,159.18) 189.31,159.24 189.31,159.97 190.07,160.72 191.66,160.72 192.37,161.43 205.04,161.43 207.03,159.44 207.03,149.63 209.58,147.08 209.58,144.17 211.07,142.68 212.49,142.68 213.5,141.66 213.5,139.78 212.86,139.14 v2(212.37,139.14)
  BOTTOM w0.112: RT59.1 42.55,40.72 42.55,39.7 v2(42.49,39.63) 42.57,39.55 42.57,39.26 41.67,38.36 41.67,31.42 42.75,30.34 42.75,28.31 45.02,26.03 45.02,23.52 44.08,22.58 44.08,21.34 v2(43.21,20.47) ; v2(308.45,16.67) 307.38,16.67 305.58,14.87 302.9,14.87 300.17,12.13 291.55,12.13 291.02,11.61 291.02,10.87 290.03,9.88 290.03,7.2 289.24,6.41 v2(289.2,6.41) ; PRS10.1 126.7,149.85 126.7,150.21 126.7,150.32 v2(126.6,150.41) ; PRS30.1 148.64,147.96 v2(148.73,148.05) 148.73,149.49 149.61,150.37 151.43,150.37 152.26,151.21 152.26,157.35 152.72,157.8 152.72,158.44 158.34,164.06 161.58,164.06 162.7,165.17 165.46,165.17 167.85,162.77 171.47,162.77 176.01,158.23 177.92,158.23 179.77,156.38 187.77,156.38 189.31,157.92 189.31,159.11 v2(189.25,159.18)
EC_SMB_DA2: length 609
  TOP w0.112: QH5.4 280.8,74.02 280.36,74.46 v2(280.36,74.82) ; v2(298.63,21.31) 298.76,21.43 299.3,21.43 299.58,21.15 299.58,20.98 303.13,17.44 305.27,17.44 305.38,17.55 307.09,17.55 UE5.80 307.24,17.55 308.07,17.55 308.18,17.66 RE90.1
  IN1 w0.084: v2(298.63,21.31) 298.63,21.22 297.58,20.17 295.7,20.17 294.54,21.32 291.41,21.32 290.21,22.52 288.92,22.52 288.73,22.32 287.68,22.32 287.53,22.18 275.72,22.18 271.85,26.05 261.04,26.05 260.55,26.54 256.96,26.54 256.12,25.7 256.12,25.11 252.82,21.8 249.5,21.8 238.96,11.27 230.69,11.27 229.08,12.88 228,12.88 227.54,12.43 v2(227.54,12.25) 227.69,12.1 227.69,11.98 227.55,11.83 227.25,11.83 227.17,11.92 227.17,16.28 223.88,19.57 190.99,19.57 184.74,13.32 168.94,13.32 161.73,6.1 126.98,6.1 126.36,6.73 122.13,6.73 121.45,7.41 121.38,7.41 v2(121.3,7.49) ; v2(176.74,181.41) 176.8,181.35 177.11,181.35 177.5,180.97 177.5,179.78 175.92,178.2 175.92,176.07 176.68,175.31 176.68,173.76 174.62,171.69 172.27,171.69 171.99,171.41 168.72,171.41 168.4,171.09 165.95,171.09 164.09,169.23 161.05,169.23 158.35,166.53 158.35,162 158.58,161.77 159.58,160.76 165.76,160.76 166.44,161.44 170.86,161.44 173.95,158.35 175.75,158.35 177.07,157.03 177.07,155.88 179.87,153.08 179.87,150.22 179.27,149.62 v2(179.27,149.5) 179.27,149.25 179.86,148.66 179.86,143.94 181.27,142.53 181.27,142.18 182.14,141.3 182.14,140 181.13,138.99 181.13,136.43 180.53,135.83 180.53,134.12 179.78,133.37 179.78,129.38 179.5,129.09 179.5,125.54 180.12,124.92 180.12,123.58 181.85,121.85 189.74,121.85 197.56,114.03 197.56,113.67 205.27,105.96 214.13,105.96 215.04,105.05 218.02,105.05 218.89,104.18 223.03,104.18 223.81,104.96 234.43,104.96 234.66,104.73 250.28,104.73 251.22,103.8 254.24,103.8 262.73,95.31 264.42,95.31 270.97,88.75 273.45,88.75 278.69,83.51 278.69,80.51 279.65,79.55 279.65,75.33 280.16,74.82 v2(280.36,74.82)
  IN4 w0.084: v2(280.36,74.82) 280.16,74.82 279.55,75.43 279.55,75.97 279.15,76.37 279.15,76.75 279.77,77.37 282.33,77.37 283.46,76.24 285.03,76.24 289.24,72.03 289.24,68.81 290.79,67.26 290.79,64.26 291.82,63.23 291.82,59.31 291.51,58.99 291.51,57.22 292.63,56.1 292.63,52.6 293.55,51.68 294.18,51.68 295.58,50.28 295.58,46.23 295.39,46.04 295.39,46.04 294.93,45.58 294.92,45.58 294.83,45.49 294.83,38 295.22,37.61 295.22,35.2 294.14,34.13 294.14,26.46 294.79,25.8 295.3,25.8 297.08,24.03 297.08,23.43 298.71,21.8 298.71,21.39 v2(298.63,21.31)
  BOTTOM w0.112: UM8.49 175.87,181.29 176.34,181.29 176.36,181.31 176.64,181.31 v2(176.74,181.41) ; DK2.3 v2(227.54,12.25) 227.95,11.84 JPK.17 ; v2(179.27,149.5) 179.12,149.35 177.44,149.35 177.27,149.18 JDGFF2.F2 ; U2408.7 120.45,7.93 120.61,7.77 120.74,7.77 121.07,7.44 121.24,7.44 v2(121.3,7.49) 121.34,7.45 121.77,7.45 R409.1 ; U2407.9 217.45,106.7 217.45,106.7 215.44,106.7 215.29,106.55 215.29,100.48 215.5,100.27 235.31,100.27 236.01,99.58 247.05,99.58 249.18,97.45 269.39,97.45 272.95,93.89 272.95,83 274.45,81.49 275.46,81.49 279.35,77.61 279.35,75.63 280.16,74.82 v2(280.36,74.82)
EC_SRTCRST: length 12.8
  TOP w0.112: UE10.20 245.22,6.85 v2(244.71,6.33) ; v2(236.74,10.29) 236.75,10.3 RE693.1 237.16,10.97 237.21,10.92 QE5.5
  BOTTOM w0.112: v2(236.74,10.29) 236.74,10.09 239.25,7.58 v1(240.95,7.58) 243.46,7.58 v2(244.71,6.33)
EC_SSD: length 95.3
  IN3 w0.104: JSSD2.8 386.2,11.04 386.51,11.35 386.51,13.04 386.14,13.42 384.01,13.42 383.28,14.16 381.19,14.16 380.72,14.63 359.18,14.63 v2(354.23,9.68) 353.63,10.28 344.19,10.28 343.88,10.59 313.69,10.59 v2(313.35,10.92)
  BOTTOM w0.112: v2(354.23,9.68) 354.76,9.15 JSSD1.8 ; RE702.2 307.02,18.68 309.61,16.09 309.61,14.45 310.95,13.1 312.49,13.1 v1(313.04,12.55) 313.35,12.24 v2(313.35,10.92)
EC_TX: length 144.5
  TOP w0.112: v2(349.64,42.89) 348.5,41.74 343.56,41.74 343.36,41.95 RN30.1 342.54,42.47 RN118.2 ; UE5.30 292.51,12.28 292.67,12.12 294.73,12.12 296.1,13.49 297.71,13.49 v2(298.66,12.54)
  IN1 w0.084: v2(298.66,12.54) 298.81,12.7 299.9,12.7 303.38,9.22 305.46,9.22 305.64,9.04 338.46,9.04 340.79,11.37 352.94,11.37 357.34,15.77 364.54,15.77 365.8,17.04 372.85,17.04 374.66,18.84 v2(374.66,36.06)
  IN4 w0.084: v2(349.64,42.89) 350.27,42.89 354.63,38.52 357.53,38.52 360.14,35.91 362.38,35.91 363.48,37.01 368.26,37.01 368.69,36.58 371.39,36.58 372.32,35.66 374.26,35.66 v2(374.66,36.06)
ECAGND: length 238.4
  TOP w0.112: v2(308,3.44) 305.49,5.96 CE35.1 ; UE5.69 308.73,13.08 v2(309.33,12.47) 309.31,12.44 309.31,11.4 309.79,10.92 LE2.2 310.2,10.13 310.01,9.94 CE172.2
  TOP w0.254: PH1.2 156.32,55.9 157.71,54.51 157.71,53.83 157.89,53.65 157.89,53.34 158.28,52.96 158.58,52.96 158.81,52.73 158.81,46.03 159.16,45.67 164.11,45.67 165.6,47.16 166.99,47.16 167.47,46.69 167.47,46.56 167.8,46.22 167.95,46.22 v1(176.65,37.52) 179.88,34.29 v2(179.88,30.44)
  IN3 w0.104: v2(179.6,5.36) 180.03,5.78 185.97,5.78 190.59,10.4 195.63,10.4 196.78,9.25 223.32,9.25 224.12,8.46 240.88,8.46 244.04,11.61 249.28,11.61 249.73,11.16 252.97,11.16 253.71,11.9 256.61,11.9 258.21,10.3 260.95,10.3 263.83,13.18 263.83,14.29 267.62,18.08 269.13,18.08 269.44,18.4 269.44,19.54 269.85,19.94 275.8,19.94 277.87,17.87 277.87,14.92 279.39,13.4 283.21,13.4 284.95,15.14 286.66,15.14 287.47,14.33 292.53,14.33 292.76,14.1 307.64,14.1 309.27,12.47 v2(309.33,12.47)
  BOTTOM w0.112: v2(309.33,12.47) 309.33,6.31 308,4.98 v2(308,3.44)
  BOTTOM w0.254: v2(179.88,30.44) 176.3,26.86 176.3,16.97 182.02,11.26 182.02,7.77 v2(179.6,5.36)
EDICLK: length 34
  TOP w0.112: UE5.60 303.94,9.04 304.3,8.67 304.3,8.25 304.66,7.9 v2(304.76,7.9) 304.76,7.32 v1(304.45,7.01)
  IN1 w0.084: v2(304.76,7.9) 304.73,7.9 304.32,8.31 304.32,8.72 304.51,8.91 305.47,8.91 305.55,8.83 330.5,8.83 JDBG.2
EDICS: length 36.1
  TOP w0.112: UE5.59 303.54,9.04 303.75,8.83 303.75,8.65 v2(303.89,8.5)
  IN1 w0.084: JDBG.1 334.1,5.23 327.37,5.23 326.35,6.25 326.35,6.89 325.77,7.47 314.64,7.47 314.64,7.47 304.5,7.47 304.32,7.64 304.32,8.01 303.89,8.44 v2(303.89,8.5)
  BOTTOM w0.112: v2(303.89,8.5) v1(303.89,9.15)
EDIDI: length 28.8
  TOP w0.112: v2(304.71,8.48) 304.71,8.66 304.34,9.04 UE5.61
  IN1 w0.084: v2(304.71,8.48) 304.85,8.62 328.17,8.62 JDBG.3
  BOTTOM w0.112: v2(304.71,8.48) v1(305.45,8.48)
EDIDO: length 25.5
  TOP w0.112: v2(305.56,7.9) 305.56,7.92 305.21,8.27 v1(305.21,8.28) 305.21,8.56 304.74,9.04 UE5.62
  IN1 w0.084: JDBG.4 325.84,8.41 306.06,8.41 v2(305.56,7.9)
EDP_RCOMP: length 1.3
  TOP w0.102: RC10.2 140.92,74.95 v2(140.82,74.86)
  BOTTOM w0.127: UC1.M9 140.54,75.32 140.8,75.05 140.8,74.86 v2(140.82,74.86)
ELC_BOOT_MODE: length 158.9
  TOP w0.089: UH1.BD29 278.72,62.76 278.9,62.95 278.9,63.73 279.09,63.92 279.09,66.8 278.97,66.93 278.91,66.99 278.91,70.66 v2(278.5,71.07)
  TOP w0.112: RE657.2 365.7,37.45 v1(365.7,38.38) 365.7,38.88 v2(365.63,38.95)
  TOP w0.127: RE657.2 364.74,36.5 RE5.1 364.5,35.11 UE1.44
  IN3 w0.104: v2(278.5,71.07) 278.56,71.07 279.02,70.61 282.23,70.61 282.71,70.13 283.43,70.13 283.64,70.34 284.95,70.34 285.63,69.67 290.57,69.67 291.69,68.55 292.25,67.99 293.24,67.99 295.87,65.36 295.87,64.73 296.88,63.73 296.88,60.19 299.15,57.91 299.15,56.01 301.9,53.26 301.9,52.03 302.98,50.95 302.98,49.54 303.77,48.75 303.77,47 301.36,44.59 301.36,36.8 303.4,34.76 304.8,34.76 304.82,34.74 305.04,34.52 307,34.52 308.35,33.17 308.35,32.81 308.35,31.17 309.29,30.23 311.39,30.23 312.05,29.57 312.05,28.79 313.21,27.63 313.65,27.63 316.7,24.59 319.36,24.59 321.08,22.86 326.75,22.86 327.84,23.95 329.93,23.95 330.93,24.95 330.93,28.12 334.76,31.94 334.76,41.29 v2(334.05,42)
  IN4 w0.084: v2(365.63,38.95) 354.8,38.95 351.12,42.63 351.12,43.01 350.43,43.7 344.94,43.7 344.51,43.27 340,43.27 338.99,42.25 334.2,42.25 334.05,42.1 v2(334.05,42)
ELC_EC#: length 235.3
  TOP w0.112: UE10.6 248.59,10.62 v1(249.12,11.15) 249.45,11.48 249.45,12.72 v2(249.64,12.91) ; QE22.5 v2(155.73,171.73) ; QE13.5 156.37,169.29 156.3,169.23 QE21.5 155.27,169.23 v2(155.12,169.38)
  IN2 w0.104: v2(155.73,171.73) 155.12,171.12 v2(155.12,169.38) 157.89,166.61 157.89,159.73 160.23,157.38 160.23,147.61 168.02,139.82 168.02,125.76 179.77,114.01 179.77,112.71 184.07,108.41 184.07,104.48 189.04,99.51 v2(191.74,99.51)
  BOTTOM w0.112: v2(249.64,12.91) 249.01,13.55 248.68,13.55 248.56,13.66 248.56,17.28 242.3,23.54 218.7,23.54 217.27,24.97 213.06,24.97 211.28,23.19 194.96,23.19 192.25,25.9 192.25,98.99 v2(191.74,99.51)
ELC_RESET: length 133.2
  TOP w0.089: v2(277.58,65.55) 277.59,65.55 278.08,65.06 278.08,63.24 277.93,63.09 277.93,62.68 UH1.BD30
  TOP w0.112: QE59.3 352.41,45.35 RE690.2 351.48,44.98 v2(351.43,45.03) v1(350.93,45.03)
  IN3 w0.104: v2(277.58,65.55) 277.59,65.55 279.13,64.01 282.33,64.01 282.48,64.16 282.48,65.62 283.04,66.19 285.59,66.19 287.58,64.2 290.34,64.2 291.38,63.16 291.65,63.16 292.06,62.76 292.06,60.9 293.86,59.09 293.86,57.94 293.37,57.44 293.37,52.64 292.51,51.78 292.51,47.12 294.77,44.85 294.77,42.17 295.71,41.23 295.71,35.77 296.64,34.84 299.25,34.84 302.33,31.77 302.33,31.28 303.8,29.81 306.05,29.81 308.16,27.7 309.13,27.7 314.39,22.43 315.77,22.43 316.67,21.53 327.3,21.53 328.39,22.62 330.48,22.62 333.06,25.2 333.06,28.69 335.86,31.49 335.86,38.61 336.36,39.11 v2(339.69,39.11) ; v2(344.58,39.2) 345.04,39.67 345.04,41.85 348.21,45.03 v2(351.43,45.03)
  IN4 w0.084: v2(344.58,39.2) 344.48,39.11 v2(339.69,39.11)
EN_0.6VSP: length 4.9
  TOP w0.112: PR211.1 v1(214.25,113.79)
  TOP w0.254: PU201.7 218.02,114.69 217.63,114.3 217.14,114.3 216.89,114.04 216.89,113.8 PC214.1 216.87,113.78 PR209.1 215.28,113.78 PR211.1
EN_1.2V: length 2.4
  TOP w0.254: PU201.8 218.42,114.57 218.59,114.39 PR208.2 218.58,113.79 PC213.1
EN_+1VALWP: length 2.4
  TOP w0.254: PU101.3 261.27,9.34 261.07,9.14 PC108.1 260.59,8.85 260.62,8.82 PR104.2
EN_INVPWR: length 248.4
  TOP w0.112: v2(298.75,8.41) 298.74,8.41 UE5.47
  IN2 w0.104: v2(181.76,133.75) 181.76,133.75 180.75,132.75 180.75,129.3 181.54,128.51 182.61,128.51 186.52,124.6 186.52,119.33 190.74,115.1 190.74,108.96 196.59,103.12 211.92,103.12 212.9,102.13 237.43,102.13 237.93,101.63 254.27,101.63 254.86,101.05 259.18,101.05 260.12,100.1 262.98,100.1 264.51,98.58 v2(264.51,88.22)
  BOTTOM w0.112: v2(181.76,133.75) 181.58,133.94 176.18,133.94 176.07,133.83 JDGFF1.F4 ; v2(264.51,88.22) 264.51,87.96 259.81,83.26 259.81,75.08 260.11,74.78 260.11,74.11 259.96,73.97 259.96,71.59 258.67,70.3 258.67,64.63 257.75,63.71 257.75,58.01 257.16,57.43 257.16,53.97 259.17,51.97 259.17,49.66 258.55,49.04 258.55,38.28 261.14,35.69 261.14,33.51 266.25,28.41 266.25,25.32 267.77,23.8 271.89,23.8 276.01,19.68 276.01,15.59 276.82,13.65 279.53,10.93 279.53,8.17 281.02,6.68 281.02,5.79 283.69,3.11 292.17,3.11 294.64,5.58 v1(294.64,6.17) 295.14,6.67 295.14,8.94 295.68,9.48 297.81,9.48 298.74,8.54 298.74,8.41 v2(298.75,8.41)
EN_TPLED: length 1.4
  TOP w0.112: v1(85.75,18.06) 85.96,18.26 Q2410.1
EN_VCCIO: length 5.4
  BOTTOM w0.112: v1(158.08,118.07) 158.08,117.33 157.82,117.08 PRF01.2
  BOTTOM w0.254: PUF01.11 156.98,114.74 157.1,114.87 157.52,114.87 157.87,115.22 PCF12.1 157.87,116.22 PRF06.1 157.82,116.27 PRF01.2
EN_VCCSA: length 4.3
  TOP w0.112: v1(129.44,118.51) 130.28,117.68 PRA23.1
  TOP w0.254: PRA23.1 PCA26.1 131.66,117.05 v2(131.65,117.04)
  BOTTOM w0.254: PUA01.13 131.31,116.71 v2(131.65,117.04)
EN_WOL#: length 240.2
  TOP w0.112: v2(248.19,12.26) 248.04,12.42 247.75,12.42 247.22,11.89 UE10.7 ; UL14.4 163.43,170.25 CL119.1 162.99,171.44 v2(162.87,171.57)
  IN2 w0.104: v2(185.98,106.05) 185.8,106.23 185.8,108.97 181.39,113.37 181.39,114.75 169.64,126.5 169.64,140.49 162.55,147.58 162.55,150.06 161.85,150.76 161.85,160.48 163.95,162.58 163.95,167.46 162.78,168.63 162.78,171.48 v2(162.87,171.57)
  BOTTOM w0.112: v2(185.98,106.05) 186.57,106.05 v1(186.64,105.98) 187.48,105.15 187.48,104.04 188.22,103.31 188.22,22.19 206.39,4.02 244.13,4.02 245.85,5.74 245.85,8.19 246.61,8.95 246.61,9.58 246.31,9.87 246.31,10.63 247.94,12.26 v2(248.19,12.26)
ENVDD: length 117.3
  TOP w0.112: v1(115.6,119.15) 115.03,119.72 v2(115.03,119.85)
  TOP w0.254: RV4.2 105.91,127.4 106.95,128.45 v2(108.79,128.45)
  TOP w0.305: UV64.4 v2(115.03,119.85)
  IN3 w0.254: v2(180.36,145.35) 180.01,144.99 177.69,144.99 176.26,143.56 173.11,143.56 172.94,143.74 171.11,143.74 170.39,144.46 170.39,145.11 169.21,146.29 159.67,146.29 158.78,147.18 152.94,147.18 152.2,146.44 151.21,146.44 150.7,146.96 142.3,146.96 140.77,148.49 132.74,148.49 132.36,148.11 132.36,145.95 133.38,144.93 134.33,144.93 134.58,144.68 134.58,144.13 133.13,142.68 133.13,132.94 132.67,132.48 128.91,132.48 128.62,132.78 127.38,132.78 125.25,130.64 125.25,127.02 122.2,123.98 120.37,123.98 119.09,122.69 118.77,122.69 115.92,119.85 v2(115.03,119.85) 115.03,119.85 115.03,121.55 114.43,122.15 112.48,122.15 110.11,124.51 110.11,127.29 108.96,128.45 v2(108.79,128.45)
  BOTTOM w0.112: JDGFF2.E1 177.87,146.92 178.45,146.34 179.36,146.34 v2(180.36,145.35)
EQA0: length 2.8
  BOTTOM w0.112: RM84.2 164.72,179.27 164.74,179.3 UM8.20 ; RM84.2 RM81.2 ; RM84.2 164.44,179.96 v1(164.61,180.13)
EQA1: length 4.3
  BOTTOM w0.112: v1(162.88,179.09) 162.88,178.9 163.43,178.35 RM70.2 163.64,177.83 163.69,177.83 163.77,177.75 164.43,177.75 164.6,177.93 RM76.2 165.27,178.8 UM8.19
EQB0: length 4.7
  BOTTOM w0.112: v1(178.4,185.89) 177.48,184.97 RM85.2 RM82.2 177.23,184.21 176.94,183.91 176.94,183.16 176.57,182.8 UM8.46
EQB1: length 4.3
  BOTTOM w0.112: 177.48,183.63 RM23.2 ; 177.48,183.63 RM26.2 177.35,182.9 176.75,182.3 UM8.47 ; 177.48,183.63 177.69,183.42 177.69,183.4 177.81,183.28 178.4,183.28 178.53,183.41 v1(178.97,183.41)
ESPI_FRAME#: length 73.8
  TOP w0.089: v2(274.15,65.6) 273.65,65.1 273.65,63.78 274.24,63.18 UH1.BE38
  TOP w0.112: TC22.1 286.49,24.77 287.5,24.77 288.69,23.58 v2(289.33,23.58) 289.85,23.58 290.43,23.01 290.43,22.95 290.7,22.68 UE5.4
  BOTTOM w0.112: v2(289.33,23.58) 288.66,23.58 283.33,28.91 283.33,29.97 282.7,30.6 274.92,30.6 272.25,33.26 270.03,33.26 268.77,34.52 268.77,36.18 268.82,36.23 268.82,38.63 267.93,39.52 267.93,42.58 265.5,45 265.5,45.42 264.93,45.99 264.93,46.36 266.76,48.19 266.76,48.78 267.04,49.06 267.04,50.24 268.22,51.42 268.22,51.78 268.72,52.28 268.72,52.38 269.19,52.85 269.19,54.98 271.63,57.43 271.63,57.81 272.5,58.68 273.36,58.68 273.75,58.29 274.09,58.29 274.33,58.53 274.33,59.16 274.59,59.42 274.59,61.03 274.11,61.51 274.11,63.72 273.8,64.02 273.8,65.25 v2(274.15,65.6)
ESPI_IO0: length 65.6
  TOP w0.089: v2(273.22,61.1) 273.22,61.1 UH1.BB39
  TOP w0.112: v2(281.62,24.49) 281.62,23.43 281.94,23.11 282.25,23.11 282.98,22.38 TC23.1 283.42,22.38 285.45,20.35 285.77,20.35 286.1,20.02 287.35,20.02 287.54,20.21 289.38,20.21 289.69,20.52 290.19,20.52 290.43,20.28 UE5.10
  BOTTOM w0.112: v2(273.22,61.1) 273.22,61.07 272.8,60.65 272.46,60.65 272.32,60.79 271.83,60.79 271.29,60.25 271.29,60.05 268.95,57.71 268.95,56.47 267.99,55.52 267.99,53.99 267.62,53.62 267.18,53.62 266.79,53.23 266.68,53.23 266.36,52.91 266.36,51.76 264.35,49.75 264.35,47.46 263.74,46.85 263.74,45.5 264.31,44.92 264.31,42.86 265.77,41.4 265.77,35.3 269.01,32.07 271.76,32.07 275.28,28.55 278.07,28.55 281.62,25 v2(281.62,24.49)
ESPI_IO1: length 65.2
  TOP w0.089: UH1.AW37 274.19,60.58 v2(273.64,60.58)
  TOP w0.112: UE5.8 290.64,21.08 290.38,21.33 290.38,21.46 289.97,21.86 287.42,21.86 286.82,21.26 286.44,21.26 TC24.1 285.27,21.04 283.36,22.95 283.09,22.95 v2(282.03,24.01)
  BOTTOM w0.112: v2(273.64,60.58) 273.22,60.58 273.04,60.41 272.36,60.41 272.22,60.55 271.93,60.55 271.53,60.15 271.53,59.95 269.19,57.61 269.19,56.38 268.23,55.42 268.23,53.89 267.72,53.38 267.28,53.38 267.18,53.28 267.18,52.24 264.59,49.65 264.59,47.36 263.97,46.75 263.97,45.6 264.55,45.02 264.55,42.96 266.01,41.5 266.01,37.58 267.02,36.57 267.02,34.39 269.11,32.3 271.86,32.3 275.38,28.79 278.28,28.79 282.03,25.03 v2(282.03,24.01)

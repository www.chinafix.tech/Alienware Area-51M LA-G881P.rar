# Allegro board Alienware Area-51M LA-G881P.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CPU_DP2_N3_C: length 3
  BOTTOM w0.076: UT1.AC21 29.5,38.75 29.42,38.68 29.42,38.58 29.5,38.51 29.81,38.51 29.91,38.61 30.04,38.61 30.13,38.52 30.58,38.52 30.62,38.48 31.21,38.48 31.25,38.52 31.37,38.52 31.46,38.42 31.61,38.42 31.77,38.25
  BOTTOM w0.112: CT34.2 31.77,38.25
CPU_DP2_P0: length 135.6
  IN4 w0.084: v2(37.16,40.53) 37.03,40.4 37.03,40.24 37.11,40.16 38.23,40.16 38.86,40.79 41.44,40.79 41.76,41.11 48.56,41.11 50.43,42.97 54.22,42.97 60.99,49.75 83.71,49.75 101.88,67.91 101.88,77 107.78,82.9 123.5,82.9 127.46,78.93 127.46,76.28 128.61,75.14 128.61,71.03 128.81,70.83 129.42,70.83 v2(129.58,70.98)
  BOTTOM w0.102: 130.03,70.65 130.2,70.48 130.2,70.13 130.08,70.01 130.08,67.86 130.28,67.66 130.91,67.66 131.14,67.43 131.14,67.22 131.28,67.09 UC1.B18
  BOTTOM w0.112: 130.03,70.65 129.92,70.76 129.79,70.76 v2(129.58,70.98) ; CT27.1 32.55,41.87 34.14,41.87 34.2,41.81 36.05,41.81 36.97,40.89 36.97,40.71 v2(37.16,40.53)
CPU_DP2_P0_C: length 3.1
  BOTTOM w0.076: UT1.AB15 29.22,41.51 29.43,41.73 29.78,41.73 29.88,41.63 30.36,41.63 30.58,41.86 v4(30.95,41.86) 31.22,41.86 31.37,41.71 31.59,41.71 31.77,41.9
  BOTTOM w0.112: CT27.2 31.77,41.9
CPU_DP2_P1: length 136.3
  IN4 w0.084: v2(127.97,73.65) 127.97,73.6 127.8,73.43 127.69,73.43 127.6,73.51 127.6,75.25 126.06,76.79 126.06,78.93 124.93,80.06 120.13,80.06 118.72,81.47 107.24,81.47 102.51,76.73 102.51,67.62 83.76,48.87 72.46,48.87 64.77,41.18 50.3,41.18 49.6,40.48 42.03,40.48 41.71,40.16 39.12,40.16 38.49,39.53 36.35,39.53 35.78,40.09 35.78,40.33 35.92,40.46 v2(35.99,40.46)
  BOTTOM w0.102: 129.98,66.96 130,66.94 130,66.93 130.18,66.74 133.46,66.74 133.56,66.84 133.56,66.98 133.46,67.09 UC1.D18
  BOTTOM w0.112: v2(35.99,40.46) 35.97,40.46 35.76,40.68 35.76,40.85 35.51,41.1 34.7,41.1 34.39,40.79 34,40.79 33.71,41.08 CT29.1 ; 129.98,66.96 129.5,67.43 129.36,67.57 129.36,70.03 129.16,70.23 129.16,72.86 128.55,73.47 128.16,73.47 v2(127.97,73.65)
CPU_DP2_P1_C: length 4.4
  BOTTOM w0.076: 31.77,40.85 31.77,40.85 31.75,40.84 31.69,40.84 31.66,40.81 31.55,40.81 31.46,40.72 31.43,40.72 31.31,40.59 30.71,40.59 30.59,40.72 30.03,40.72 29.93,40.81 29.42,40.81 29.19,40.59 UT1.AB17
  BOTTOM w0.112: CT29.2 32.89,40.85 32.65,40.85 32.65,40.85 32.24,40.85 32.24,40.85 32.06,40.85 31.77,40.85
CPU_DP2_P2: length 136.9
  IN4 w0.084: v2(127.84,72.48) 127.67,72.31 127.56,72.31 127.47,72.4 127.47,72.74 126.97,73.24 126.97,74.98 125.42,76.53 125.42,78.67 124.67,79.43 119.78,79.43 118.37,80.84 107.51,80.84 103.14,76.47 103.14,67.36 84.02,48.24 72.73,48.24 64.92,40.44 50.45,40.44 48.81,38.8 46.87,38.8 45.92,37.84 42.46,37.84 41.41,38.89 36.08,38.89 35.02,39.96 34.73,39.96 v2(34.6,40.09)
  BOTTOM w0.102: UC1.C19 132.74,66.17 132.84,66.07 132.84,65.93 132.74,65.82 132.01,65.82 132,65.83 130.07,65.83 129.94,65.97 129.94,65.98 129.92,66
  BOTTOM w0.112: CT31.1 32.65,39.87 33.2,39.87 33.29,39.96 34.47,39.96 v2(34.6,40.09) ; v2(127.84,72.48) 128.06,72.27 128.21,72.27 128.45,72.03 128.45,69.93 128.65,69.73 128.65,67.27 129.12,66.8 129.92,66
CPU_DP2_P2_C: length 3.1
  BOTTOM w0.076: 31.77,39.99 31.6,39.82 31.4,39.82 31.25,39.96 v4(30.95,39.96) 30.7,39.96 30.55,39.82 29.96,39.82 29.89,39.89 29.43,39.89 29.21,39.67 UT1.AB19
  BOTTOM w0.112: CT31.2 31.77,39.99
CPU_DP2_P3: length 136.2
  IN4 w0.084: v2(127.82,70.47) 127.61,70.68 127.61,71.2 126.84,71.97 126.84,72.48 126.34,72.98 126.34,74.72 124.48,76.58 121.72,76.58 118.1,80.2 107.77,80.2 103.77,76.21 103.77,67.1 84.28,47.61 72.99,47.61 65.18,39.8 51.76,39.8 50.12,38.16 47.14,38.16 46.18,37.21 42.19,37.21 41.15,38.26 35.75,38.26 35.4,38.61 34.88,38.61 v2(34.57,38.92)
  BOTTOM w0.102: UC1.D20 133.46,65.26 133.56,65.16 133.56,65.01 133.46,64.91 131.82,64.91 131.77,64.87 131.42,64.87 131.41,64.88 129.92,64.88 129.82,64.98
  BOTTOM w0.112: v2(127.82,70.47) 127.5,70.16 127.5,67.3 129.82,64.98 ; CT33.1 32.75,38.5 33.16,38.5 33.26,38.6 34.24,38.6 v2(34.57,38.92)
CPU_DP2_P3_C: length 3
  BOTTOM w0.076: UT1.AB21 29.23,38.75 29.44,38.97 29.92,38.97 30.14,38.75 30.2,38.69 v4(30.91,38.69) 31.46,38.69 31.56,38.59 31.64,38.59 31.77,38.72
  BOTTOM w0.112: CT33.2 31.77,38.72
CPU_FAN_FB: length 298.1
  TOP w0.112: UE5.28 291.43,13.16 290.39,13.16 v2(289.8,12.56)
  IN1 w0.084: v2(289.8,12.56) 288.78,11.54 288.78,11.29 288.23,10.75 279.12,10.75 275.37,14.49 275.37,17.81 274.28,18.9 269.97,18.9 269.15,19.71 259.15,19.71 255.45,16.02 246.52,16.02 241.73,11.22 241.73,8.99 237.3,4.56 223.27,4.56 221.74,3.03 219.43,3.03 218.58,3.88 195.79,3.88 193.77,1.87 190.42,1.87 189.77,2.52 173.42,2.52 172.31,3.63 126.87,3.63 126.02,2.78 121.07,2.78 118.53,5.32 111.23,5.32 107.98,8.57 96.05,8.57 93.88,6.41 82.5,6.41 v2(81.74,7.17)
  IN3 w0.104: v2(92.35,49.68) 92.33,49.71 91.61,49.71 90.13,48.22 v2(90.13,47.46) 88.39,45.72 86.86,45.72 84.69,43.55 84.69,41.28 83.83,40.42 83.83,30.6 82.32,29.09 82.32,26.51 84.42,24.41 84.42,24.29 v2(84.46,24.25)
  BOTTOM w0.112: v2(81.74,7.17) 81.93,7.36 81.93,8.5 82.48,9.05 85.09,9.05 85.2,9.16 85.2,17.55 85.59,17.94 85.59,21.3 84.46,22.44 v2(84.46,24.25) ; v2(92.35,49.68) 94.07,49.68 95.38,50.99 v1(95.38,51.65) DF1.2 ; RF1.1 89.15,54.66 88.69,54.2 88.69,50.69 90.13,49.25 v2(90.13,47.46)
CPU_FAN_PWM: length 294.3
  TOP w0.112: UE5.26 290.7,13.88 290.31,13.49 v3(289.72,13.49) 289.38,13.15 v2(289.38,12.98)
  IN1 w0.084: v2(82.32,7.25) 82.32,7.18 82.89,6.62 93.57,6.62 95.76,8.8 108.08,8.8 111.35,5.53 118.67,5.53 121.21,2.99 125.88,2.99 126.73,3.84 173.85,3.84 174.94,2.75 189.87,2.75 190.52,2.1 193.68,2.1 195.7,4.11 218.65,4.11 219.52,3.24 221.66,3.24 223.18,4.77 237.21,4.77 241.52,9.08 241.52,11.31 246.43,16.23 255.37,16.23 259.07,19.93 269.24,19.93 270.05,19.11 274.37,19.11 275.58,17.9 275.58,14.58 279.2,10.96 286.15,10.96 286.65,11.45 287.61,11.45 289.14,12.98 v2(289.38,12.98)
  IN3 w0.104: v2(91.78,49.3) 90.54,48.06 90.54,47.29 88.74,45.49 86.96,45.49 84.92,43.46 84.92,41.19 84.06,40.32 84.06,30.5 82.55,28.99 82.55,27.07 84.98,24.64 86.41,24.64 86.64,24.41 v2(86.64,23.62)
  BOTTOM w0.112: v2(86.64,23.62) 86.64,23.22 85.83,22.42 85.83,17.84 85.44,17.45 85.44,8.98 85.27,8.81 82.57,8.81 82.32,8.56 v2(82.32,7.25) ; JFAN1.3 91.06,58.38 91.06,55.95 89.99,54.89 RF2.1 89.99,54.59 90.68,53.9 90.68,51.28 91.78,50.18 v2(91.78,49.3)
CPU_PECI: length 23.2
  TOP w0.102: 129.82,82.48 v2(130.01,82.67) ; v2(135.58,76.71) 135.18,76.71 134.63,77.25 v1(133.89,77.25) 132.12,77.25 132.11,77.24 131.25,77.24 131.08,77.07 130.7,77.07 129.82,77.95
  TOP w0.112: 129.82,77.95 129.62,78.15 129.62,82.28 129.82,82.48
  BOTTOM w0.102: v2(130.01,82.67) 129.82,82.67 ; UC1.G7 135.76,76.95 135.76,76.95 135.58,76.78 v2(135.58,76.71)
  BOTTOM w0.112: R394.2 RC11.1 121.84,86.79 CC2.1 124.36,86.79 125.7,85.44 125.7,84.71 127.75,82.67 129.82,82.67
CPU_PLTRST#: length 244.9
  TOP w0.089: UH1.AG5 290.42,54.33 290.91,54.33 291.05,54.19 291.93,54.19 292.14,53.99 296.7,53.99 v2(296.83,54.12)
  TOP w0.102: 129.82,77.61 130.57,76.86 131.16,76.86 131.33,77.04 132.19,77.04 132.2,77.05 133.19,77.05 133.64,76.61 v2(133.64,76.6)
  TOP w0.112: CC1.1 121.1,85.35 122.16,85.35 124.02,87.21 128.02,87.21 129.38,85.84 v3(129.38,84.99) 129.38,78.05 129.82,77.61
  IN4 w0.084: 132.23,84.99 132.23,88.76 135.07,91.6 151.75,91.6 157.3,97.15 162.67,97.15 164.65,99.13 179.43,99.13 180.98,100.69 192.93,100.69 193.6,100.02 203.16,100.02 203.82,100.69 210.44,100.69 211.12,100.01 228.77,100.01 229.35,100.59 247.37,100.59 247.84,100.12 259.2,100.12 261.11,98.22 268.88,98.22 274.55,92.55 274.55,88.88 278.89,84.54 280.3,84.54 281.22,83.62 281.89,82.95 282.02,82.82 284.3,82.82 292.99,74.14 292.99,71.63 293.36,71.26 296,68.62 296,63.8 296.61,63.19 296.61,56.39 296.43,56.21 296.43,54.52 v2(296.83,54.12)
  IN4 w0.102: v2(133.64,76.6) 133.64,77.87 133.15,78.36 133.15,81.83 132.23,82.74 132.23,84.99
  BOTTOM w0.102: v2(133.64,76.6) 133.69,76.66 133.69,76.72 UC1.E7
CPU_TRIGGER: length 228.7
  TOP w0.089: 297.89,56.25 296.67,56.25 296.64,56.22 295.58,56.22 295.49,56.31 295.02,56.31 294.89,56.17 293.95,56.17 293.84,56.07 293.22,55.44 291.78,55.44 291.74,55.48 UH1.AK2
  TOP w0.112: 297.89,56.25 298.19,56.25 298.86,55.59 v1(299.5,55.59) 299.95,55.59 v2(300.33,55.97)
  IN4 w0.084: v2(126.2,88.14) 126.36,88.14 132.42,94.19 150.7,94.19 156.25,99.75 161.62,99.75 164.46,102.59 169.45,102.59 174.68,107.82 180.01,107.82 184.55,103.28 211.49,103.28 212.18,102.58 227.7,102.58 228.38,103.26 267.5,103.26 295.57,75.2 295.57,72.7 299.84,68.42 299.84,56.75 300.33,56.26 v2(300.33,55.97)
  BOTTOM w0.112: RC36.1 121.92,89.65 122.58,90.32 124.02,90.32 v2(126.2,88.14)
CPU_VCCIO_PWR_GATE#: length 6.9
  TOP w0.089: RH180.2 295.55,62.77 295.55,62.09 295.46,61.99 295.38,61.99 295,61.61 294.75,61.61 294.6,61.47 294.6,61.12 293.8,60.32 291.37,60.32 291.22,60.46 UH1.AY3
CPU_XDP_TRST#: length 336.2
  TOP w0.089: UH1.AM4 291.02,56.6 291.71,56.6 291.74,56.57 292.02,56.57 292.2,56.39 292.82,56.39 294.06,57.64 294.94,57.64 295.03,57.73 v2(295.03,57.93)
  TOP w0.102: v2(135.49,72.21) v3(134.6,72.21)
  TOP w0.112: JPCMC.28 58.68,43.44 58.46,43.44 58.22,43.2 57.58,43.2 56.64,42.26 v2(56.48,42.26) RC687.1
  IN2 w0.102: 129.82,82.26 131.37,80.71 132.01,80.71 132.28,80.44 132.28,76.06 134.08,74.26 134.08,73.72 135.49,72.31 v2(135.49,72.21)
  IN2 w0.104: 129.82,82.26 128.52,83.56 124.37,83.56 122.42,85.51 118.59,85.51 117.47,84.39 107.09,84.39 100.9,78.2 100.9,68.79 96.71,64.6 96.19,64.6 94.07,62.48 93.01,62.48 81.45,50.91 74.9,50.91 73.85,51.96 62.41,51.96 61.5,51.05 59.91,51.05 55.55,46.69 55.55,43.19 v2(56.48,42.26)
  IN4 w0.084: 135.28,84.99 134.21,86.06 134.21,88.44 135.81,90.05 152.4,90.05 157.92,95.57 163.31,95.57 165.32,97.58 180.1,97.58 181.64,99.13 185.42,99.13 186.08,98.47 203.8,98.47 204.46,99.13 209.8,99.13 210.47,98.45 229.41,98.45 230,99.04 246.56,99.04 247.03,98.57 258.56,98.57 260.47,96.66 268.12,96.66 272.38,92.41 272.38,88.85 278.54,82.68 278.54,81.62 279.26,80.91 280.42,80.91 280.68,81.17 282.62,81.17 290.99,72.79 290.99,69.54 292.55,67.98 292.55,67.88 293.71,66.73 293.71,64.34 294.18,63.87 294.18,59.54 295.03,58.69 v2(295.03,57.93)
  IN4 w0.102: 135.28,84.99 135.28,82.57 135.17,82.46 135.17,75.99 135,75.82 135,74.65 135.18,74.47 135.18,73.58 135,73.4 135,72.74 135.49,72.25 v2(135.49,72.21)
  BOTTOM w0.102: v2(135.49,72.21) 135.12,72.57 UC1.F12
CS1: length 4.4
  TOP w0.112: v1(332.26,34.25) 331.54,34.97 PR306.2
  TOP w0.203: PU301.1 330.92,37.53 331.37,37.08 331.37,35.63 331.28,35.54 331.28,34.98 PR306.2
CS2: length 4
  TOP w0.112: v1(331.88,41.93) 331.88,41.76 332.12,41.52 PR305.2
  TOP w0.203: PR305.2 332.07,40.93 331.57,40.43 331.57,39.39 331.3,39.13 PU301.5
CS_1.2V: length 3.7
  TOP w0.203: PU201.13 220.65,116.88 220.92,117.14 221.1,117.14 221.45,117.5 221.45,118 v1(221.77,118.32) 221.92,118.17 PR201.2
CSIN_CHG: length 5.4
  TOP w0.112: PU703.31 208.03,137.33 208.12,137.25 208.12,136.99 208.56,136.55 208.56,136.37 PC747.1 208.57,135.7 208.57,134.51 PC793.1 208.18,134.02 PR740.2
CSIN_ISL95338_1: length 5.6
  TOP w0.112: PCS21.1 121.2,144.94 v1(120.93,144.68)
  TOP w0.254: PCS21.1 122.12,145.69 PCS19.2 122.2,145.64 v2(122.9,146.35)
  BOTTOM w0.203: v2(122.9,146.35) 123.14,146.35 123.55,145.95 123.66,145.95 123.72,145.88 PUS1.14
  BOTTOM w0.254: PRS03.2 122.35,145.79 v2(122.9,146.35)
CSIN_ISL95338_2: length 6.7
  TOP w0.112: PCS48.2 v3(142.79,142.7)
  TOP w0.203: PCS50.1 145.7,142.64 145.63,142.57 145.01,142.57 v2(144.74,142.83)
  TOP w0.254: PCS48.2 144.6,142.7 v2(144.74,142.83)
  BOTTOM w0.203: PUS2.14 145.74,143.37 145.63,143.48 145.25,143.48 144.74,142.98 v2(144.74,142.83)
  BOTTOM w0.254: PRS23.2 144.2,142.83 v2(144.74,142.83)
CSIP_CHG: length 5.3
  TOP w0.112: PU703.32 208.43,137.33 208.35,137.25 208.35,137.09 208.8,136.64 208.8,136.39 PC747.2 208.81,135.7 v4(208.81,135.06) 208.81,134.26 PC792.1 208.94,134.02 PR772.2
CSIP_ISL95338_1: length 4.6
  TOP w0.254: PCS20.1 121.29,146.56 PCS19.1 122.38,146.56 122.65,146.83 123.23,146.83 123.24,146.84 v2(123.27,146.8)
  BOTTOM w0.203: v2(123.27,146.8) 123.29,146.78 123.29,146.73 123.73,146.28 PUS1.15
  BOTTOM w0.254: PRS02.2 122.26,146.57 122.52,146.83 123.24,146.83 v2(123.27,146.8)
CSIP_ISL95338_2: length 6.3
  TOP w0.112: v3(145,146.2) 145,145.44 144.44,144.88 PCS49.1
  TOP w0.254: PCS49.1 143.97,144.21 PCS48.1 144.64,143.61 v2(144.76,143.73)
  BOTTOM w0.203: v2(144.76,143.73) 144.85,143.81 145.77,143.81 145.81,143.77 PUS2.15
  BOTTOM w0.254: PRS22.2 144.73,143.7 v2(144.76,143.73)
CSON_CHG: length 6.1
  TOP w0.112: PR776.1 206.1,145.03 206.21,145.14 206.21,146.64 v1(205.77,147.09)
  TOP w0.203: PU703.14 206.43,142.63 206.4,142.66 206.4,142.96 205.58,143.78 205.58,143.89 PC708.1
  TOP w0.254: PR776.1 205.75,144.1 PC708.1
CSOP_CHG: length 3.5
  TOP w0.203: PU703.15 206.03,142.63 206.05,142.65 206.05,142.77 v1(205.71,143.11) 205.15,143.67 205.15,143.78 PC708.2
  TOP w0.254: PC708.2 204.93,144.15 PR742.1
CSSN_1: length 24.4
  TOP w0.254: v2(112.04,158.1) 112.14,158.2 112.82,158.2 113.44,158.82 113.44,160.61 113.71,160.89 PRS01.3
  BOTTOM w0.254: PRS03.1 121.01,146.01 120.26,146.01 119.79,146.49 119.79,152.5 120.08,152.8 120.08,153.35 115.23,158.2 112.14,158.2 v2(112.04,158.1)
CSSN_2: length 12.5
  TOP w0.254: v2(137.1,143.27) 137,143.37 137,146.33 137.3,146.63 PRS21.3
  BOTTOM w0.254: PRS23.1 143.03,143.09 142.25,143.09 141.93,142.77 v1(140.35,142.77) 140.31,142.81 138.68,142.81 137.67,143.82 137.25,143.82 137,143.57 137,143.36 137.1,143.26 v2(137.1,143.27)
CSSP_1: length 23.8
  TOP w0.254: PRS01.2 112.78,160.89 113.05,160.61 113.05,158.98 112.66,158.58 112.24,158.58 112.14,158.58 v2(112.04,158.68)
  BOTTOM w0.254: v2(112.04,158.68) 112.12,158.61 v1(114.2,158.61) 115.37,158.61 120.46,153.51 120.46,152.64 120.17,152.34 120.17,146.64 120.42,146.39 121.05,146.39 PRS02.1
CSSP_2: length 13.3
  TOP w0.254: PRS21.2 136.36,146.63 136.62,146.38 136.62,143.36 v2(136.51,143.26)
  BOTTOM w0.254: PRS22.1 142.97,143.47 v1(142.09,143.47) 141.81,143.19 138.84,143.19 137.83,144.2 137.09,144.2 136.62,143.72 136.62,143.37 136.6,143.35 136.6,143.34 v2(136.51,143.26)
CTL1: length 291.9
  TOP w0.112: UU1.6 35.68,18.31 35.81,18.44 v1(38.19,18.44) 39.55,18.44 40.33,17.66 40.9,17.66 41.28,17.28 41.28,16.04 42,15.32 v2(42,13.66) ; v2(303.89,7.87) 303.48,8.28 303.48,8.69 303.14,9.04 UE5.58
  IN3 w0.104: v2(42,13.66) 42.08,13.74 42.9,13.74 46.72,9.92 49.7,9.92 50.52,10.74 57.12,10.74 58.35,9.5 61.59,9.5 64.82,6.28 93.37,6.28 96.37,9.28 108.6,9.28 111.6,6.28 111.98,6.28 119.41,6.28 120.53,5.16 125.19,5.16 125.5,4.84 165.74,4.84 166.87,3.71 172.81,3.71 173.55,2.97 186.23,2.97 186.77,3.51 188.92,3.51 189.59,2.84 194.16,2.84 196.16,4.84 218.46,4.84 219.55,5.93 242.15,5.93 243.49,4.6 246.03,4.6 247.55,3.07 274.97,3.07 278.38,6.49 284.86,6.49 286.5,4.85 289.4,4.85 292.6,8.05 292.6,9.33 293,9.73 302.74,9.73 303.48,8.99 303.48,8.27 v2(303.89,7.87)
CTL2: length 282.8
  TOP w0.112: UU1.7 35.18,18.14 36.06,19.02 v1(37.05,19.02) 39.3,19.02 40.43,17.9 41,17.9 41.52,17.38 41.52,16.13 42.29,15.36 42.29,14.4 42.64,14.06 v2(42.64,13.07) ; UE5.39 295.54,8.75 295.65,8.64 295.65,8.63 v2(295.66,8.63)
  IN3 w0.104: v2(42.64,13.07) 46.25,9.46 49.89,9.46 50.71,10.28 56.93,10.28 58.16,9.04 58.83,9.04 62.05,5.81 93.62,5.81 96.62,8.81 108.41,8.81 111.41,5.81 112.17,5.81 118.72,5.81 120.85,3.68 125.14,3.68 125.37,3.91 165.36,3.91 167.36,1.91 186.48,1.91 187.15,2.59 188.54,2.59 189.21,1.91 194.54,1.91 196.54,3.91 218.41,3.91 219.47,2.85 222.13,2.85 223.19,3.91 241.1,3.91 241.5,3.51 241.64,3.37 243.1,1.91 274.47,1.91 278.57,6.01 284.68,6.01 286.31,4.39 289.59,4.39 292.44,7.24 294.71,7.24 295.05,7.58 295.05,8.06 295.62,8.63 v2(295.66,8.63)
DAT_SMB: length 9.4
  TOP w0.112: v2(72.8,7.82) 72.66,7.96 72.35,7.96 71.93,8.38 71.93,9.21 72.58,9.86 72.58,10.12 PR12.1
  BOTTOM w0.112: v2(72.8,7.82) 73.02,8.04 73.03,8.04 73.47,8.48 73.47,9.44 73.58,9.55 73.86,9.55 74.1,9.79 PBATT1.6
DCIN_CHG: length 20.1
  TOP w0.127: v1(206.79,132.67) 206.44,133.02 v2(206.44,133.44)
  TOP w0.203: PC757.2 203.64,141.61 204.27,140.98 PU703.18
  TOP w0.508: v2(206.44,133.44) 206.32,133.56 PR743.1 ; v2(204.37,142.14) 204.12,142.14 PC757.2
  IN1 w0.508: v2(206.44,133.44) 206.24,133.44 205.73,133.94 205.73,134.87 209,138.14 209,141.37 207.56,142.82 204.95,142.82 204.37,142.24 v2(204.37,142.14)
DCIN_ISL95338_1: length 1.1
  TOP w0.112: v1(122.97,148.6) PCS23.1
  vias: v2(124.28,147.9)
DCIN_ISL95338_2: length 1.6
  TOP w0.112: PCS52.2 145.9,146.83 145,147.72 v3(145,147.85)
  vias: v2(146.07,145.69)
DDR_A_ACT#: length 105.3
  IN1 w0.102: v2(173.37,58.31) 173.86,58.8 174.14,58.8 175.62,57.33
  IN1 w0.173: 175.62,57.33 178.3,54.64 185.71,54.64 186.97,53.39 206.29,53.39 206.57,53.11 210.26,53.11 210.5,52.87 220.81,52.87 220.94,52.99 227.73,52.99 228.35,52.37 230.1,52.37 230.72,52.99 236.84,52.99 237.44,53.59 240.46,53.59 240.55,53.69 240.55,56.48 240.39,56.65 239.24,56.65 239.07,56.47 239.07,55.15 238.94,55.01 v2(238.57,55.01)
  IN3 w0.216: v2(238.57,55.01) 238.92,54.67 248.57,54.67 249.86,55.95 252.15,55.95 252.5,55.6 v2(252.5,55.05)
  BOTTOM w0.102: UC1.AU24 164.31,59.4 164.78,59.87 168.02,59.87 170.27,57.62 172.68,57.62 v2(173.37,58.31)
  BOTTOM w0.224: v2(238.57,55.01) 238.58,55.03 JDIMM3.114 ; JDIMM1.114 252.53,55.03 v2(252.5,55.05)
DDR_A_ALERT#: length 98.5
  IN1 w0.084: 175.62,58.4 178.62,55.4 186.03,55.4 187.28,54.15 206.61,54.15 206.89,53.87 210.58,53.87 210.82,53.63 220.5,53.63 220.65,53.78 236.17,53.78 v2(237.4,55.01)
  IN1 w0.102: v2(169.74,60.43) 170.57,59.59 174.43,59.59 175.62,58.4
  IN3 w0.104: v2(251.33,55.05) 250.1,55.05 248.92,53.87 238.23,53.87 237.4,54.7 v2(237.4,55.01)
  BOTTOM w0.102: UC1.AT23 163.74,60.31 164.08,60.65 164.92,60.65 165.06,60.8 165.53,60.8 165.63,60.89 166.3,60.89 166.53,61.12 169.16,61.12 169.47,60.81 169.47,60.69 v2(169.74,60.43)
  BOTTOM w0.112: v2(237.4,55.01) 238.03,55.65 238.86,55.65 238.98,55.53 JDIMM3.116 ; JDIMM1.116 251.8,55.53 v2(251.33,55.05)
DDR_A_BA0: length 102.7
  IN1 w0.102: 175.62,70.18 175.37,70.18 174.76,69.58 170.11,69.58 169.88,69.35 169,69.35 168.64,69.71 v2(168.64,69.94)
  IN1 w0.173: 175.62,70.18 187.14,70.18 190.21,67.11 201.5,67.11 202.51,66.09 205.6,66.09 206.04,65.66 208.49,65.66 208.95,65.2 209.57,65.2 210.03,65.66 213.55,65.66 214.2,66.31 232.96,66.31 233.74,65.53 240.64,65.53 240.74,65.63 240.74,66.65 240.56,66.83 237.81,66.83 237.65,66.98 237.65,67.37 v2(237.57,67.45)
  IN3 w0.216: v2(252.53,66.19) 252.53,66.42 252.25,66.7 249.76,66.7 249.43,66.37 247.04,66.37 246.79,66.62 239.5,66.62 239.19,66.93 237.92,66.93 237.65,67.2 237.65,67.37 v2(237.57,67.45)
  BOTTOM w0.102: UC1.AY13 168.16,69.46 v2(168.64,69.94)
  BOTTOM w0.224: v2(237.57,67.45) 237.65,67.37 237.65,66.79 238.42,66.03 JDIMM3.150 ; v2(252.53,66.19) 252.69,66.03 JDIMM1.150
DDR_A_BA1: length 105.8
  IN1 w0.102: v2(169.69,68.97) 169.79,68.97 170.19,69.38 175.02,69.38 175.39,69.75
  IN1 w0.173: v2(233.68,65.09) 233.68,65.13 232.83,65.98 231.4,65.98 231.23,65.81 231.23,65.1 231.06,64.93 230.71,64.93 230.54,65.1 230.54,65.81 230.36,65.98 214.34,65.98 213.61,65.25 212.37,65.25 211.69,64.58 206.41,64.58 205.22,65.77 201.52,65.77 201.35,65.94 201.35,66.61 201.18,66.78 200.83,66.78 200.66,66.61 200.66,65.94 200.49,65.77 200.14,65.77 199.97,65.94 199.97,66.61 199.8,66.78 199.45,66.78 199.28,66.61 199.28,65.94 199.1,65.77 198.76,65.77 198.59,65.94 198.59,66.61 198.41,66.78 198.07,66.78 197.9,66.61 197.9,65.94 197.72,65.77 197.38,65.77 197.2,65.94 197.2,66.61 197.03,66.78 196.69,66.78 196.51,66.61 196.51,65.94 196.34,65.77 196,65.77 195.82,65.94 195.82,66.61 195.65,66.78 195.3,66.78 195.13,66.61 195.13,65.94 194.96,65.77 194.61,65.77 194.44,65.94 194.44,66.61 194.27,66.78 193.92,66.78 193.75,66.61 193.75,65.94 193.58,65.77 193.23,65.77 193.06,65.94 193.06,66.61 192.89,66.78 192.54,66.78 192.37,66.61 192.37,65.94 192.2,65.77 191.66,65.77 191.49,65.94 191.49,66.62 191.37,66.75 190.12,66.75 187.12,69.75 175.39,69.75
  IN3 w0.216: v2(233.68,65.09) 233.68,65.45 233.48,65.66 233.48,66.5 233.86,66.88 234.92,66.88 236.19,65.61 238.3,65.61 239.27,64.64 246.73,64.64 v2(246.92,64.82)
  BOTTOM w0.102: v2(169.69,68.97) 167.99,68.97 167.23,68.21 166.58,68.21 166.43,68.06 165.64,68.06 UC1.AV15
  BOTTOM w0.224: JDIMM3.145 232.61,64.78 232.76,64.62 233.3,64.62 233.68,65 v2(233.68,65.09) ; v2(246.92,64.82) 246.87,64.78 JDIMM1.145
DDR_A_BG0: length 107.6
  IN1 w0.102: v2(171.95,58.31) 172.12,58.31 175.62,54.81
  IN1 w0.173: v2(235.89,52) 235.35,52.54 230.72,52.54 230.12,51.93 226.93,51.93 226.76,52.1 226.76,52.49 226.58,52.66 226.24,52.66 226.06,52.49 226.06,52.1 225.89,51.93 218.67,51.93 218.5,52.1 218.5,52.37 218.32,52.54 217.98,52.54 217.81,52.37 217.81,52.1 217.63,51.93 212.91,51.93 212.73,52.1 212.73,52.37 212.56,52.54 212.22,52.54 212.04,52.37 212.04,52.1 211.87,51.93 206.31,51.93 206.2,52.04 206.2,52.91 206.04,53.06 205.63,53.06 205.46,52.89 205.46,52.32 205.28,52.14 204.94,52.14 204.77,52.32 204.77,52.89 204.59,53.06 204.25,53.06 204.07,52.89 204.07,52.29 203.9,52.12 203.56,52.12 203.38,52.29 203.38,52.89 203.21,53.06 202.87,53.06 202.69,52.89 202.69,52.24 202.52,52.07 202.17,52.07 202,52.24 202,52.89 201.83,53.06 186.83,53.06 185.58,54.32 176.11,54.32 175.62,54.81
  IN3 w0.216: v2(249.78,53.39) 249.78,53.11 248.67,52 v2(235.89,52)
  BOTTOM w0.102: v2(171.95,58.31) 171.56,57.92 170.4,57.92 170.08,58.23 170.08,58.7 168.13,60.65 166.85,60.65 166.51,60.31 UC1.AW23
  BOTTOM w0.224: JDIMM1.115 248,55.28 249.78,53.49 v2(249.78,53.39) ; v2(235.89,52) 232.61,55.28 JDIMM3.115
DDR_A_BG1: length 106.4
  IN1 w0.173: v2(170.63,58.34) 171.7,57.27 172.53,57.27 175.81,53.99 179.99,53.99 180.16,53.82 180.16,52.91 180.33,52.74 180.68,52.74 180.85,52.91 180.85,53.82 181.02,53.99 181.37,53.99 181.54,53.82 181.54,52.91 181.72,52.74 182.06,52.74 182.23,52.91 182.23,53.82 182.41,53.99 182.75,53.99 182.92,53.82 182.92,52.91 183.1,52.74 183.44,52.74 183.62,52.91 183.62,53.82 183.79,53.99 184.13,53.99 184.31,53.82 184.31,52.91 184.48,52.74 184.82,52.74 185,52.91 185,53.82 185.17,53.99 185.44,53.99 186.7,52.74 200.91,52.74 201.9,51.74 206.04,51.74 206.17,51.6 230.61,51.6 230.78,51.78 230.78,52.04 230.95,52.21 231.3,52.21 231.47,52.04 231.47,51.67 231.58,51.56 234.05,51.56 v2(234.49,52)
  IN3 w0.216: v2(248.5,53.39) 247.71,52.6 237.64,52.6 236.82,53.43 235.67,53.43 234.49,52.25 v2(234.49,52)
  BOTTOM w0.102: v2(170.63,58.34) 170.63,58.77 169.9,59.5 169.79,59.5 168.44,60.85 166.64,60.85 166.44,60.65 165.85,60.65 165.51,60.31 UC1.AV23
  BOTTOM w0.224: v2(234.49,52) 234.49,52.68 232.39,54.78 JDIMM3.113 ; v2(248.5,53.39) 247.12,54.78 JDIMM1.113
DDR_A_CAS#: length 101
  IN1 w0.102: 175.62,74.33 172.68,74.33 172.47,74.55 167.74,74.55 166.66,73.46 v2(166.66,71.85)
  IN1 w0.173: v2(242.79,68.4) 242.79,68.47 241.98,69.28 241.68,69.28 239.81,71.15 233.63,71.15 233.13,71.65 203.71,71.65 203.04,72.32 191.79,72.32 189.78,74.33 175.62,74.33
  IN3 w0.216: v2(242.79,68.4) 242.79,67.85 242.95,67.69 246.04,67.69 246.62,68.27 248.01,68.27 248.54,67.74 249.33,67.74 249.91,68.32 250.83,68.32 250.99,68.17 252.02,68.17 252.2,67.99 252.2,67.45 252,67.25 v2(250.85,67.25)
  BOTTOM w0.102: UC1.AY11 167.04,71.44 166.66,71.82 v2(166.66,71.85)
  BOTTOM w0.224: v2(242.79,68.4) 242.79,67.91 242.41,67.53 JDIMM3.156 ; JDIMM1.156 251.13,67.53 v2(250.85,67.25)
DDR_A_CKE0: length 82.7
  IN1 w0.102: v2(169.12,58.19) 169.12,56.89 170.43,55.57 172.62,55.57 175.62,52.58
  IN1 w0.135: v2(234.35,50.06) 234.39,50.06 234.63,50.3 234.63,50.63 234.58,50.69 219.69,50.69 219.56,50.55 219.56,50.09 219.42,49.96 219.15,49.96 219.02,50.09 219.02,50.55 218.88,50.69 218.61,50.69 218.48,50.55 218.48,50.09 218.34,49.96 218.07,49.96 217.94,50.09 217.94,50.55 217.81,50.69 215.86,50.69 215.72,50.55 215.72,50.09 215.59,49.96 215.32,49.96 215.18,50.09 215.18,50.55 215.05,50.69 213.84,50.69 213.71,50.55 213.71,50.09 213.57,49.96 213.3,49.96 213.17,50.09 213.17,50.55 212.91,50.81 205.84,50.81 205.71,50.95 201.57,50.95 200.58,51.94 176.25,51.94 175.62,52.58
  BOTTOM w0.102: v2(169.12,58.19) 167.91,59.4 UC1.AY24
  BOTTOM w0.175: JDIMM3.109 232.53,53.78 232.87,53.44 232.87,51.54 v2(234.35,50.06)
DDR_A_CKE1: length 83.1
  IN1 w0.102: v2(167.73,59.02) 168.12,58.63 168.12,55.29 169.15,54.27 173.35,54.27 175.41,52.21
  IN1 w0.135: v2(238.01,51.24) 236.4,49.63 232.41,49.63 231.98,50.06 222.07,50.06 221.63,49.62 213.16,49.62 212.31,50.47 205.7,50.47 205.57,50.61 201.43,50.61 200.44,51.6 176.01,51.6 175.41,52.21
  BOTTOM w0.102: v2(167.73,59.02) 166.9,59.02 166.51,59.4 UC1.AW24
  BOTTOM w0.175: v2(238.01,51.24) 238.01,53.42 238.61,54.03 JDIMM3.110
DDR_A_CKE2: length 96.2
  IN1 w0.102: 175.62,53.53 175.6,53.53 172.42,56.71 171.5,56.71 168.52,59.69 166.37,59.69 v2(165.67,58.98)
  IN1 w0.135: v2(247.19,53.39) 247.19,52.81 246.91,52.53 237.46,52.53 236.04,51.1 214.93,51.1 214.89,51.15 205.98,51.15 205.85,51.28 201.71,51.28 200.72,52.28 179.85,52.28 179.7,52.43 179.7,53.44 179.61,53.53 179.11,53.53 178.97,53.4 178.97,52.41 178.84,52.28 178.57,52.28 178.43,52.41 178.43,53.4 178.3,53.53 178.03,53.53 177.89,53.4 177.89,52.41 177.76,52.28 177.49,52.28 177.36,52.41 177.36,53.4 177.22,53.53 176.95,53.53 176.82,53.4 176.82,52.41 176.68,52.28 176.41,52.28 176.28,52.41 176.28,53.4 176.14,53.53 175.62,53.53
  BOTTOM w0.102: UC1.AV24 165.25,59.4 v2(165.67,58.98)
  BOTTOM w0.175: v2(247.19,53.39) 246.81,53.78 JDIMM1.109
DDR_A_CKE3: length 97.1
  IN1 w0.102: 174.44,52.21 173.54,53.1 169.94,53.1 166.78,56.26 166.78,57.58 165.79,58.57 165.16,58.57 v2(164.75,58.98)
  IN1 w0.135: 174.44,52.21 175.38,51.27 199.11,51.27 200.76,49.62 212.68,49.62 213.02,49.28 221.9,49.28 222.34,49.72 231.84,49.72 232.27,49.29 237.27,49.29 240.16,52.19 250.24,52.19 v2(251.38,53.33)
  BOTTOM w0.102: UC1.AV25 165.21,58.52 v2(164.75,58.98)
  BOTTOM w0.175: JDIMM1.110 251.56,54.03 251.38,53.84 v2(251.38,53.33)
DDR_A_CLK0: length 79.5
  IN1 w0.102: v2(170.34,66.97) 170.4,67.02 170.4,67.62 170.64,67.87 171.7,67.87 172.54,67.03 175.56,67.03 175.59,67.06 175.62,67.06
  IN1 w0.157: v2(234.29,62.13) 234.29,62.87 234.07,63.1 232.61,63.1 231.99,62.48 231.3,62.48 230.69,63.1 213.35,63.1 212.69,62.44 201.97,62.44 201.97,62.43 190.89,62.43 186.26,67.06 175.62,67.06
  BOTTOM w0.102: v2(170.34,66.97) 170.52,66.97 170.68,66.81 170.68,66.81 170.85,66.63 170.85,66.34 170.75,66.24 169.79,66.24 167.84,64.29 167,64.29 166.63,64.67 166.63,64.97 166.45,65.15 166.24,65.15 166.12,65.03 UC1.AW18
  BOTTOM w0.183: JDIMM3.137 233.62,60.78 234.2,61.35 234.2,61.77 234.28,61.84 234.28,61.88 234.29,61.9 v2(234.29,62.13)
DDR_A_CLK1: length 80.6
  IN1 w0.102: 175.62,67.82 175.59,67.82 175.56,67.85 172.22,67.85 171.87,68.2 169.48,68.2 168.93,67.65 168.93,67.01 v2(169.15,66.8)
  IN1 w0.157: v2(235.66,62.13) 235.83,62.3 235.83,62.89 235.06,63.67 213.02,63.67 212.34,62.99 191.11,62.99 186.28,67.82 175.62,67.82
  BOTTOM w0.102: v2(169.15,66.8) 168.83,66.48 168.83,66.14 167.93,65.24 166.69,65.24 UC1.AW17
  BOTTOM w0.183: v2(235.66,62.13) 235.81,61.97 235.81,61.47 236.15,61.13 238.6,61.13 238.71,61.03 JDIMM3.138
DDR_A_CLK2: length 97.2
  IN1 w0.102: 175.62,66.17 175.59,66.17 175.56,66.14 175.05,66.14 174.69,65.78 166.43,65.78 166.29,65.92 166.29,66.06 166.46,66.23 v2(166.58,66.23)
  IN1 w0.157: 175.62,66.17 185.96,66.17 190.56,61.57 213,61.57 213.6,62.17 230.28,62.17 230.78,61.67 237.14,61.67 237.3,61.83 237.3,63.27 237.61,63.58 238.3,63.58 238.61,63.27 238.61,61.83 238.76,61.67 239.08,61.67 241.22,63.81 245.43,63.81 245.74,63.5 245.74,62.48 245.9,62.33 246.37,62.33 246.53,62.48 246.53,63.5 246.83,63.81 247.72,63.81 248.11,63.42 v2(248.11,61.56)
  BOTTOM w0.102: v2(166.58,66.23) 166.12,66.69 UC1.AW16
  BOTTOM w0.183: v2(248.11,61.56) 247.98,61.43 247.98,61.08 247.67,60.78 JDIMM1.137
DDR_A_CLK3: length 99.1
  IN1 w0.102: 175.62,65 175.59,65 175.56,64.97 169.72,64.97 169.2,64.45 166.05,64.45 165.33,65.17 165.33,66.6 165.07,66.85 164.34,66.85 164.13,66.65 164.13,66.42 163.95,66.23 v2(163.84,66.23)
  IN1 w0.157: 175.62,65 177.42,65 177.52,64.89 186.01,64.89 190.53,60.37 217.18,60.37 217.76,60.95 230.37,60.95 230.47,60.86 239.39,60.86 241.51,62.97 244.12,62.97 246.36,60.73 250.03,60.73 250.34,61.05 v2(250.34,62)
  BOTTOM w0.102: UC1.AT16 163.38,66.69 v2(163.84,66.23)
  BOTTOM w0.183: v2(250.34,62) 250.49,61.85 250.49,61.27 250.96,60.8 252.31,60.8 252.64,61.13 252.79,61.13 252.89,61.03 JDIMM1.138
DDR_A_CLK#0: length 79.5
  IN1 w0.102: v2(171.06,66.97) 170.96,66.87 170.82,66.87 170.72,66.97 170.72,67.12 170.6,67.25 170.6,67.54 170.73,67.66 171.62,67.66 172.45,66.83 175.56,66.83 175.59,66.8 175.62,66.8
  IN1 w0.157: v2(233.7,62.13) 233.7,62.21 234.03,62.54 234.03,62.77 233.96,62.84 232.71,62.84 232.1,62.22 231.2,62.22 230.58,62.84 213.46,62.84 212.8,62.18 202.08,62.18 202.08,62.17 190.78,62.17 186.15,66.8 175.62,66.8
  BOTTOM w0.102: v2(171.06,66.97) 171.06,66.26 170.84,66.04 169.87,66.04 167.93,64.09 166.92,64.09 166.48,64.53 165.96,64.53 165.6,64.89 UC1.AV18
  BOTTOM w0.183: JDIMM3.139 232.52,61.28 232.74,61.06 233.5,61.06 233.91,61.47 233.91,61.69 233.7,61.9 v2(233.7,62.13)
DDR_A_CLK#1: length 80.5
  IN1 w0.102: v2(168.35,66.8) 168.73,67.18 168.73,67.74 169.4,68.4 171.96,68.4 172.31,68.05 175.56,68.05 175.59,68.08 175.62,68.08
  IN1 w0.157: v2(236.24,62.13) 236.09,62.28 236.09,63 235.16,63.93 212.92,63.93 212.24,63.25 191.21,63.25 186.39,68.08 175.62,68.08
  BOTTOM w0.102: v2(168.35,66.8) 168.63,66.51 168.63,66.22 167.85,65.44 166.77,65.44 166.64,65.57 166.64,65.72 166.72,65.8 UC1.AY17
  BOTTOM w0.183: JDIMM3.140 238.71,61.53 238.6,61.42 236.27,61.42 236.1,61.59 236.1,61.98 v2(236.24,62.13)
DDR_A_CLK#2: length 97.1
  IN1 w0.102: v2(165.79,66.23) 166,66.23 166.09,66.14 166.09,65.83 166.34,65.58 174.78,65.58 175.14,65.94 175.56,65.94 175.59,65.91 175.62,65.91
  IN1 w0.157: 175.62,65.91 185.85,65.91 190.45,61.31 213.11,61.31 213.71,61.91 230.17,61.91 230.67,61.42 237.25,61.42 237.56,61.72 237.56,63.16 237.72,63.32 238.19,63.32 238.35,63.16 238.35,61.72 238.66,61.42 239.19,61.42 241.32,63.55 245.32,63.55 245.48,63.39 245.48,62.38 245.79,62.07 246.48,62.07 246.78,62.38 246.78,63.39 246.94,63.55 247.61,63.55 247.85,63.32 247.85,61.91 247.67,61.74 247.67,61.72 v2(247.51,61.56)
  BOTTOM w0.102: UC1.AV16 165.21,66.69 165.67,66.23 v2(165.79,66.23)
  BOTTOM w0.183: JDIMM1.139 246.52,61.28 246.74,61.06 247.55,61.06 247.7,61.2 247.7,61.37 v2(247.51,61.56)
DDR_A_CLK#3: length 99
  IN1 w0.102: 175.62,64.74 175.59,64.74 175.56,64.77 169.8,64.77 169.29,64.25 165.97,64.25 165.12,65.09 165.12,66.51 164.99,66.65 164.42,66.65 164.34,66.56 164.34,66.29 164.4,66.23 v2(164.69,66.23)
  IN1 w0.157: v2(250.93,62) 250.78,61.85 250.78,61.82 250.6,61.64 250.6,60.94 250.14,60.48 246.25,60.48 244.02,62.71 241.61,62.71 239.5,60.6 230.36,60.6 230.26,60.7 217.87,60.7 217.29,60.11 190.42,60.11 185.9,64.63 177.42,64.63 177.31,64.74 175.62,64.74
  BOTTOM w0.102: v2(164.69,66.23) 164.69,66.29 164.29,66.69 UC1.AU16
  BOTTOM w0.183: v2(250.93,62) 250.78,61.85 250.78,61.38 251.08,61.08 252.2,61.08 252.53,61.42 252.83,61.42 252.94,61.53 JDIMM1.140
DDR_A_CS#0: length 82.5
  IN1 w0.102: 175.62,72.19 175.35,72.19 174.79,71.64 168.6,71.64 167.84,70.88 167.55,70.88 167.1,70.42 166.76,70.42 166.63,70.56 v2(166.63,70.88)
  IN1 w0.135: 175.62,72.19 187.76,72.19 190.44,69.52 191.75,69.52 191.89,69.65 191.89,70.05 192.02,70.19 192.29,70.19 192.43,70.05 192.43,69.65 192.56,69.52 192.83,69.52 192.96,69.65 192.96,70.05 193.1,70.19 193.37,70.19 193.5,70.05 193.5,69.65 193.64,69.52 193.91,69.52 194.04,69.65 194.04,70.05 194.18,70.19 194.44,70.19 194.58,70.05 194.58,69.65 194.71,69.52 194.98,69.52 195.12,69.65 195.12,70.05 195.25,70.19 195.52,70.19 195.66,70.05 195.66,69.65 195.79,69.52 196.06,69.52 196.19,69.65 196.19,70.05 196.33,70.19 196.6,70.19 196.73,70.05 196.73,69.65 196.87,69.52 197.14,69.52 197.27,69.65 197.27,70.05 197.41,70.19 197.68,70.19 197.81,70.05 197.81,69.65 197.94,69.52 198.21,69.52 198.35,69.65 198.35,70.05 198.48,70.19 198.75,70.19 198.89,70.05 198.89,69.65 199.02,69.52 213.28,69.52 213.92,68.88 217.98,68.88 218.12,68.75 218.12,68.21 218.25,68.08 218.52,68.08 218.65,68.21 218.65,68.75 218.79,68.88 219.06,68.88 219.19,68.75 219.19,68.21 219.33,68.08 219.6,68.08 219.73,68.21 219.73,68.75 219.87,68.88 226.17,68.88 226.31,68.75 226.31,68.21 226.44,68.08 226.71,68.08 226.85,68.21 226.85,68.75 226.98,68.88 227.25,68.88 227.38,68.75 227.38,68.21 227.52,68.08 227.79,68.08 227.92,68.21 227.92,68.75 228.06,68.88 228.6,68.88 228.72,68.77 v2(228.72,68.46)
  BOTTOM w0.102: UC1.AW12 v2(166.63,70.88)
  BOTTOM w0.175: v2(228.72,68.46) 228.8,68.37 228.8,67.38 230.15,66.04 230.5,66.04 230.77,65.78 JDIMM3.149
DDR_A_CS#1: length 84.9
  IN1 w0.102: v2(169.92,73.39) 170.32,73.8 171.61,73.8 172.2,73.21 175.62,73.21
  IN1 w0.135: 175.62,73.21 188.18,73.21 190.19,71.2 199.41,71.2 200.08,70.53 218.16,70.53 218.29,70.4 218.29,70.03 218.43,69.89 218.69,69.89 218.83,70.03 218.83,70.4 218.96,70.53 219.23,70.53 219.37,70.4 219.37,70.03 219.5,69.89 219.77,69.89 219.91,70.03 219.91,70.4 220.04,70.53 225.87,70.53 226,70.4 226,70.03 226.14,69.89 226.4,69.89 226.54,70.03 226.54,70.4 226.67,70.53 226.94,70.53 227.08,70.4 227.08,70.03 227.21,69.89 227.48,69.89 227.62,70.03 227.62,70.4 227.75,70.53 228.02,70.53 228.15,70.4 228.15,70.03 228.29,69.89 228.56,69.89 228.69,70.03 228.69,70.4 228.83,70.53 232.67,70.53 233.17,70.03 235.61,70.03 235.71,69.92 v2(235.71,69.26)
  BOTTOM w0.102: UC1.AU11 164.29,71.38 167,74.08 169.23,74.08 v2(169.92,73.39)
  BOTTOM w0.175: JDIMM3.157 232.28,67.78 233.16,68.65 235.18,68.65 235.71,69.19 v2(235.71,69.26)
DDR_A_CS#2: length 95.9
  IN1 w0.102: v2(164.71,69.96) 167.72,69.96 168.38,70.62 168.38,70.88 168.93,71.44 174.89,71.44 175.31,71.86 175.62,71.86
  IN1 w0.135: 175.62,71.86 187.62,71.86 190.3,69.18 204.75,69.18 205.05,68.88 213.16,68.88 214.3,67.74 230.69,67.74 231.49,68.54 233.06,68.54 233.28,68.33 237.94,68.33 238.98,67.28 240.77,67.28 241.23,66.82 241.63,66.82 241.76,66.69 241.76,66.32 241.89,66.19 242.16,66.19 242.3,66.32 242.3,66.69 242.43,66.82 242.7,66.82 242.84,66.69 242.84,66.32 242.97,66.19 243.24,66.19 243.38,66.32 243.38,66.69 243.51,66.82 249.03,66.82 v2(249.45,67.25)
  BOTTOM w0.102: UC1.AV13 v2(164.71,69.96)
  BOTTOM w0.175: JDIMM1.149 246.41,65.78 246.51,65.68 248.11,65.68 249.45,67.03 v2(249.45,67.25)
DDR_A_CS#3: length 93.9
  IN1 w0.102: 175.62,75.13 175.59,75.13 175.57,75.11 166.73,75.11 166.09,74.47 165.25,74.47 v2(164.75,73.97)
  IN1 w0.135: 175.62,75.13 190.12,75.13 191.99,73.25 229.12,73.25 229.92,72.45 233.46,72.45 233.96,71.95 240.14,71.95 242.01,70.08 242.46,70.08 242.6,70.22 242.6,70.96 242.73,71.09 243,71.09 243.13,70.96 243.13,70.22 243.27,70.08 243.54,70.08 243.67,70.22 243.67,70.55 243.81,70.69 244.08,70.69 244.21,70.55 244.21,70.22 244.35,70.08 247.93,70.08 248.68,69.33 v2(248.68,69.32)
  BOTTOM w0.102: v2(164.75,73.97) 164.32,74.4 UC1.AV10
  BOTTOM w0.175: v2(248.68,69.32) 248.68,69.12 247.7,68.15 246.84,68.15 246.47,67.78 JDIMM1.157
DDR_A_D0: length 120.2
  IN2 w0.102: v2(152.75,41.79) 153,41.54 153.14,41.21 153.14,41.02 153.49,40.17 155.09,38.5
  IN2 w0.15: v2(237.78,26.09) 237.78,26.2 237.58,26.4 236.32,26.92 229.67,26.92 225.52,28.64 219.03,28.64 218.88,28.79 218.88,28.91 218.73,29.06 218.43,29.06 218.28,28.91 218.28,28.79 218.13,28.64 217.72,28.64 211.04,31.41 204.46,31.41 191.62,33.24 165.73,33.24 165.72,33.25 165.66,33.31 157.55,36.67 155.5,38.13 155.27,38.32 155.09,38.5
  IN4 w0.122: v2(250.93,27.53) 250.76,27.36 249.11,27.36 248.34,26.6 247.79,26.6 247.67,26.47 247.67,26.05 247.55,25.93 247.3,25.93 247.18,26.05 247.18,26.47 247.06,26.6 246.84,26.6 246.71,26.47 246.71,25.8 246.59,25.68 246.35,25.68 246.23,25.8 246.23,26.47 246.11,26.6 245.86,26.6 245.74,26.47 245.74,25.59 245.62,25.47 245.37,25.47 245.25,25.59 245.25,26.47 245.13,26.6 238.29,26.6 v2(237.78,26.09)
  BOTTOM w0.102: v2(152.75,41.79) 152.57,41.97 152.37,42.46 152.37,43.28 152.84,44.09 152.84,44.35 152.79,44.4 152.79,45.15 152.99,45.35 152.99,45.88 153.32,46.21 UC1.AE38
  BOTTOM w0.157: JDIMM3.8 239.08,28.53 238.79,28.23 238.03,26.97 v2(237.78,26.09) ; JDIMM1.8 252.72,28.53 251.35,27.96 v2(250.93,27.53)
DDR_A_D1: length 121.7
  IN2 w0.102: v2(152.75,39.2) 152.93,39.2 153.63,38.5
  IN2 w0.15: 153.63,38.5 155.73,36.4 165.55,32.33 191.56,32.33 204.4,30.5 204.7,30.5 204.85,30.35 204.85,29.19 205,29.04 205.3,29.04 205.45,29.19 205.45,30.35 205.6,30.5 205.9,30.5 206.05,30.35 206.05,29.14 206.21,28.97 208.75,28.97 209.27,28.46 215.5,28.46 219.03,27 225.65,27 229.34,25.47 232.96,25.47 233.37,25.88 v2(233.37,25.9)
  IN4 w0.122: v2(242.93,25.5) 241.96,24.53 239.64,24.53 239.52,24.66 239.52,25.55 239.39,25.67 239.15,25.67 239.03,25.55 239.03,24.66 238.91,24.53 238.66,24.53 238.54,24.66 238.54,25.55 238.42,25.67 238.18,25.67 238.05,25.55 238.05,24.66 237.93,24.53 237.69,24.53 237.57,24.66 237.57,25.2 237.44,25.32 237.2,25.32 237.08,25.2 237.08,24.76 236.96,24.64 234.64,24.64 234.06,25.21 234.06,26.44 233.94,26.57 233.49,26.57 233.37,26.44 v2(233.37,25.9)
  BOTTOM w0.102: v2(152.75,39.2) 153.36,39.82 153.36,43.05 153.56,43.24 153.56,44.31 153.66,44.41 153.66,46.28 153.77,46.39 153.77,46.88 153.66,46.99 153.66,47.17 UC1.AE37
  BOTTOM w0.157: JDIMM3.7 232.33,28.28 233.37,27.23 v2(233.37,25.9) ; v2(242.93,25.5) 242.93,26.52 244.68,28.28 JDIMM1.7
DDR_A_D2: length 120.9
  IN2 w0.102: v2(155.22,40.32) 155.28,40.26 159.36,40.26
  IN2 w0.15: v2(236.63,28.58) 234.21,29.54 233.62,29.54 230.5,30.58 228.46,30.58 224.97,32.03 219.08,32.03 211.56,35.14 209.42,35.14 209.07,35.49 205.42,35.49 205.27,35.34 205.27,34.97 205.12,34.82 204.82,34.82 204.67,34.97 204.67,35.34 204.52,35.49 204.22,35.49 204.07,35.34 204.07,34.59 203.92,34.44 203.62,34.44 203.47,34.59 203.47,35.34 203.32,35.49 187.41,35.49 174.9,40.51 170.84,40.51 169.37,41.15 164.17,41.15 160.81,40.26 159.36,40.26
  IN4 w0.122: v2(250.47,30.57) 250.47,30.25 250.34,30.12 249.96,30.12 249.77,29.93 249.77,29.55 250.34,28.98 251.17,28.98 251.29,28.85 251.29,28.52 251.17,28.39 250.08,28.39 249.34,29.14 237.19,29.14 v2(236.63,28.58)
  BOTTOM w0.102: UC1.AG38 155.28,46.6 155.73,46.15 155.73,44.33 155.68,44.29 155.68,44.01 155.76,43.93 155.76,41.09 155.59,40.52 v2(155.22,40.32)
  BOTTOM w0.157: JDIMM3.20 239.08,31.53 236.63,29.07 v2(236.63,28.58) ; v2(250.47,30.57) 250.47,30.6 250.83,30.96 252.51,31.53 JDIMM1.20
DDR_A_D3: length 119.3
  IN2 w0.102: v2(155.19,42.56) 155.43,42.56 156.33,43.46 161.31,43.46 164.54,41.86 173.84,41.86 174.27,41.43
  IN2 w0.15: 174.27,41.43 176.68,41.43 186.85,37.21 191.21,37.21 191.36,37.06 191.36,36.56 191.51,36.41 191.81,36.41 191.96,36.56 191.96,37.06 192.11,37.21 192.41,37.21 192.56,37.06 192.56,36.56 192.71,36.41 193.01,36.41 193.16,36.56 193.16,37.06 193.31,37.21 193.61,37.21 193.76,37.06 193.76,36.56 193.91,36.41 194.21,36.41 194.36,36.56 194.36,37.06 194.51,37.21 194.81,37.21 194.96,37.06 194.96,36.56 195.11,36.41 195.41,36.41 195.56,36.56 195.56,37.06 195.71,37.21 196.08,37.21 196.23,37.06 196.23,36.55 196.38,36.4 205.14,36.4 205.29,36.55 205.29,37.06 205.44,37.21 205.74,37.21 205.89,37.06 205.89,36.69 206.04,36.54 206.34,36.54 206.49,36.69 206.49,37.06 206.64,37.21 213.61,37.21 216.25,34.57 218.58,34.57 218.79,34.37 222.42,34.37 222.85,33.94 226.77,33.94 227.88,32.84 231.71,32.84 233.53,31.02 v2(233.53,30.63)
  IN4 w0.122: v2(248.8,30.18) 248.8,30.18 248.19,29.57 234.32,29.57 233.53,30.36 v2(233.53,30.63)
  BOTTOM w0.102: v2(155.19,42.56) 155.43,42.56 155.56,42.68 155.56,43.85 155.39,44.01 155.39,44.38 155.49,44.47 155.49,45.96 155.27,46.18 155.04,46.18 154.74,46.48 154.74,46.73 155.15,47.15 UC1.AG37
  BOTTOM w0.157: JDIMM1.21 248.08,31.78 248.8,31.06 v2(248.8,30.18) ; v2(233.53,30.63) 233.48,30.68 233.43,30.68 232.34,31.78 JDIMM3.21
DDR_A_D4: length 117.2
  IN2 w0.102: 155.76,38.5 155.49,38.69 153.49,40.7 153.37,40.98 153.37,42.59 152.83,43.13 v2(152.76,43.13)
  IN2 w0.15: 155.76,38.5 157.77,37.07 165.91,33.7 191.66,33.7 204.49,31.86 211.26,31.86 216.93,29.51 220.79,29.51 221.69,29.14 226.45,29.14 228.02,28.49 228.48,28.49 230.44,27.51 236.53,27.51 238.77,26.41 v2(239,26.09)
  IN4 w0.122: v2(239,26.09) 239.08,26.17 239.82,26.17 239.94,26.05 239.94,25.08 240.06,24.96 240.34,24.96 240.47,25.08 240.47,26.05 240.59,26.17 240.83,26.17 240.95,26.05 240.95,25.72 241.19,25.49 242.31,25.49 242.99,26.17 244.52,26.17 244.7,25.98 244.7,25.16 244.83,25.04 248.44,25.04 248.56,25.17 248.56,26.21 249.28,26.93 251.75,26.93 v2(252.34,27.53)
  BOTTOM w0.102: UC1.AE39 153.32,45.32 152.99,44.99 152.99,44.53 153.08,44.45 153.08,43.6 152.76,43.28 v2(152.76,43.13)
  BOTTOM w0.157: v2(239,26.09) 238.72,26.79 238.72,27.16 239.08,27.53 JDIMM3.4 ; JDIMM1.4 v2(252.34,27.53)
DDR_A_D5: length 116.7
  IN2 w0.102: v2(152.75,40.47) 152.84,40.47 153.29,40.03 153.29,39.62 154.4,38.5
  IN2 w0.15: v2(232.2,25.9) 232.2,26.16 232,26.36 229.63,26.36 225.34,28.14 217.61,28.14 210.82,30.95 209.87,30.95 209.72,30.8 209.72,29.99 209.57,29.84 209.27,29.84 209.12,29.99 209.12,30.8 208.97,30.95 208.6,30.95 208.45,30.8 208.45,29.99 208.3,29.84 208,29.84 207.85,29.99 207.85,30.8 207.7,30.95 207.4,30.95 207.25,30.8 207.25,29.99 207.1,29.84 206.8,29.84 206.65,29.99 206.65,30.8 206.5,30.95 204.43,30.95 191.59,32.79 165.64,32.79 156.22,36.69 154.4,38.5
  IN4 w0.122: v2(232.2,25.9) 232.2,25.9 233.99,24.11 234.5,24.11 234.62,23.99 234.62,23.77 234.74,23.65 234.98,23.65 235.11,23.77 235.11,23.84 235.23,23.96 235.47,23.96 235.59,23.84 235.59,23.69 235.72,23.57 235.96,23.57 236.08,23.69 236.08,23.99 236.2,24.11 236.45,24.11 236.57,23.99 236.57,23.69 236.69,23.57 236.94,23.57 237.06,23.69 237.06,23.99 237.18,24.11 237.42,24.11 237.55,23.99 237.55,23.69 237.67,23.57 237.91,23.57 238.03,23.69 238.03,23.99 238.15,24.11 238.4,24.11 238.52,23.99 238.52,23.69 238.64,23.57 238.89,23.57 239.01,23.69 239.01,23.99 239.13,24.11 239.37,24.11 239.5,23.99 239.5,23.69 239.62,23.57 239.86,23.57 239.98,23.69 239.98,23.99 240.11,24.11 242.14,24.11 243.11,25.08 244.05,25.08 244.17,25.2 v2(244.17,25.5)
  BOTTOM w0.102: v2(152.75,40.47) 153.16,40.89 153.16,43.13 153.32,43.29 UC1.AE40
  BOTTOM w0.157: JDIMM1.3 244.78,27.28 244.17,26.67 v2(244.17,25.5) ; JDIMM3.3 232.35,27.28 232.68,26.95 232.68,26.53 232.2,26.05 v2(232.2,25.9)
DDR_A_D6: length 117.7
  IN2 w0.15: v2(237.86,28.55) 237.86,28.81 236.55,30.12 233.43,30.12 231.17,32.38 227.36,32.38 226.77,32.97 218.24,32.97 211.76,35.66 209.7,35.66 209.41,35.94 190.96,35.94 190.81,36.09 190.81,36.2 190.66,36.35 190.36,36.35 190.21,36.2 190.21,36.09 190.06,35.94 189.76,35.94 189.61,36.09 189.61,36.61 189.46,36.76 189.16,36.76 189.01,36.61 189.01,36.09 188.86,35.94 188.27,35.94 176.07,40.97 170.42,40.97 169.42,41.4 164.13,41.4 160.78,40.51 156.46,40.51 155.53,41.44 v2(155.19,41.44)
  IN4 w0.122: v2(237.86,28.55) 238.03,28.72 249.16,28.72 249.91,27.97 252,27.97 252.14,28.11 252.14,29.38 252.02,29.5 251.42,29.5 251.29,29.62 251.29,29.87 251.42,29.99 252.02,29.99 252.14,30.11 252.14,30.35 251.97,30.53 v2(251.7,30.53)
  BOTTOM w0.102: v2(155.19,41.44) 154.78,41.44 154.68,41.54 154.68,43.72 154.91,43.95 154.91,44.4 154.81,44.49 154.81,44.96 155.15,45.3 UC1.AG39
  BOTTOM w0.157: JDIMM3.16 239.08,30.53 237.86,29.31 v2(237.86,28.55) ; JDIMM1.16 253.77,30.53 v2(251.7,30.53)
DDR_A_D7: length 116.7
  IN2 w0.102: 174.27,41.91 174.12,42.06 164.59,42.06 161.36,43.66 155.19,43.66 v2(155.18,43.68)
  IN2 w0.15: 174.27,41.91 177.22,41.91 187.34,37.72 196.69,37.72 196.84,37.57 196.84,37 196.99,36.85 197.29,36.85 197.44,37 197.44,37.57 197.59,37.72 197.89,37.72 198.04,37.57 198.04,37 198.19,36.85 198.49,36.85 198.64,37 198.64,37.57 198.79,37.72 199.09,37.72 199.24,37.57 199.24,37 199.39,36.85 199.69,36.85 199.84,37 199.84,37.57 199.99,37.72 200.29,37.72 200.44,37.57 200.44,37 200.59,36.85 200.89,36.85 201.03,37 201.03,37.57 201.18,37.72 201.48,37.72 201.63,37.57 201.63,37.13 201.78,36.98 202.08,36.98 202.23,37.13 202.23,37.57 202.38,37.72 216.84,37.72 219.42,35.14 222.47,35.14 223.17,34.44 226.95,34.44 228.07,33.31 231.91,33.31 233.78,31.44 234.16,31.44 234.77,30.83 v2(234.77,30.58)
  IN4 w0.122: v2(247.63,30.18) 247.44,30 243.78,30 243.66,30.12 243.66,30.74 243.53,30.87 243.29,30.87 243.17,30.74 243.17,30.12 243.05,30 240.47,30 240.35,30.12 240.35,30.76 240.23,30.88 239.99,30.88 239.86,30.76 239.86,30.12 239.74,30 239.5,30 239.38,30.12 239.38,30.76 239.25,30.88 239.01,30.88 238.89,30.76 238.89,30.12 238.77,30 238.52,30 238.4,30.12 238.4,30.76 238.28,30.88 238.04,30.88 237.91,30.76 237.91,30.12 237.79,30 235.36,30 v2(234.77,30.58)
  BOTTOM w0.102: v2(155.18,43.68) 155.15,43.7 UC1.AG40
  BOTTOM w0.157: JDIMM3.17 232.62,30.78 233.22,30.17 234.37,30.17 v2(234.77,30.58) ; v2(247.63,30.18) 247.03,30.78 JDIMM1.17
DDR_A_D8: length 117.7
  IN1 w0.122: v2(156.46,42.2) 156.28,41.7 156.28,41.01 156.4,40.74 157.68,38.5 157.81,38.28 164,32.1 165.86,31.14 202.66,31.14 202.78,31.02 202.78,30.69 202.9,30.57 203.15,30.57 203.27,30.69 203.27,31.02 203.39,31.14 204.29,31.14 205.98,30.47 218.67,30.47 218.77,30.57 221.17,30.57 226.51,30.01 230.75,30.01 231.58,30.16 235.34,30.16 235.83,30.36 235.97,30.5 v2(235.97,30.58)
  IN3 w0.15: v2(251.34,32.88) 251.34,32.45 250.48,31.59 250.15,31.59 250,31.74 250,32.05 249.83,32.22 249.55,32.22 249.4,32.07 249.4,31.74 249.25,31.59 248.35,31.59 247.88,31.12 245.65,31.12 244.66,30.13 238.38,30.13 237.42,31.09 236.04,31.09 235.89,30.94 235.89,30.66 v2(235.97,30.58)
  BOTTOM w0.102: v2(156.46,42.2) 156.68,43.35 156.68,44.5 156.65,44.53 156.65,44.96 156.94,45.25 157.16,45.34 157.31,45.49 157.31,45.8 UC1.AJ38
  BOTTOM w0.157: v2(251.34,32.88) 251.34,32.94 251.92,33.53 JDIMM1.28 ; JDIMM3.28 238.91,33.53 v2(235.97,30.58)
DDR_A_D9: length 117.1
  IN1 w0.102: v2(158.75,39.29) 158.75,39.15 159.4,38.5
  IN1 w0.122: v2(233.96,32.34) 233.75,32.13 232.94,32.13 232.58,31.77 226.4,31.77 226.05,32.13 219.25,32.13 218.65,32.73 212.27,32.73 211.91,32.36 211.35,32.36 210.86,31.88 205.9,31.88 203.12,32.98 190.83,32.98 190.68,33.13 174.69,33.13 174.57,33.01 174.57,32.7 174.45,32.57 174.2,32.57 174.08,32.7 174.08,33.01 173.96,33.13 173.72,33.13 173.59,33.01 173.59,32.7 173.47,32.57 173.23,32.57 173.11,32.7 173.11,33.01 172.99,33.13 172.74,33.13 172.62,33.01 172.62,32.7 172.5,32.57 172.25,32.57 172.13,32.7 172.13,33.01 172.01,33.13 171.77,33.13 171.64,33.01 171.64,32.7 171.52,32.57 171.28,32.57 171.16,32.7 171.16,33.01 171.03,33.13 170.79,33.13 170.67,33.01 170.67,32.7 170.55,32.57 170.3,32.57 170.18,32.7 170.18,33.01 170.06,33.13 169.82,33.13 169.69,33.01 169.69,32.7 169.57,32.57 169.33,32.57 169.21,32.7 169.21,33.01 169.08,33.13 168.84,33.13 168.72,33.01 168.72,32.7 168.6,32.57 168.35,32.57 168.23,32.7 168.23,33.01 168.11,33.13 167.86,33.13 167.74,33.01 167.74,32.7 167.62,32.57 167.38,32.57 167.25,32.7 167.25,33.01 167.13,33.13 166.02,33.13 166.01,33.13 165.59,33.13 163.9,34 159.4,38.5
  IN3 w0.15: v2(248.32,32.36) 248.32,32.2 247.8,31.68 245.49,31.68 244.85,31.04 240.56,31.04 240.23,30.71 238.5,30.71 237.61,31.6 234.52,31.6 233.96,32.15 v2(233.96,32.34)
  BOTTOM w0.102: v2(158.75,39.29) 158.75,39.75 157.27,41.23 157.27,44.47 157.32,44.52 157.32,45.13 157.54,45.34 157.54,46.14 157.39,46.28 157.39,46.77 156.98,47.19 UC1.AJ37
  BOTTOM w0.157: v2(248.32,32.36) 248.32,32.66 247.2,33.78 JDIMM1.29 ; v2(233.96,32.34) 232.52,33.78 JDIMM3.29
DDR_A_D10: length 117.5
  IN1 w0.102: 172.68,38.5 171.82,39.37 171.09,39.37 170.22,40.24 169.07,40.24 168.08,41.22 163.69,41.22 162.64,40.18 161.09,40.18 161.09,40.19 160.33,40.94 160.04,40.94 v2(159.99,40.99)
  IN1 w0.122: v2(235.33,34.4) 235.33,34.57 234.31,35.59 232.61,35.59 231.45,34.43 230.12,34.43 229.47,33.77 227.71,33.77 227.05,34.43 219.72,34.43 219.46,34.69 213.09,34.69 212.84,34.94 206.48,34.94 205.58,35.84 196.02,35.84 195.9,35.72 195.9,35.21 195.78,35.09 195.54,35.09 195.41,35.21 195.41,35.72 195.29,35.84 195.05,35.84 194.93,35.72 194.93,35.21 194.81,35.09 194.56,35.09 194.44,35.21 194.44,35.72 194.32,35.84 194.07,35.84 193.95,35.72 193.95,35.21 193.83,35.09 193.59,35.09 193.46,35.21 193.46,35.72 193.34,35.84 175.34,35.84 172.68,38.5
  IN3 w0.15: v2(235.33,34.4) 235.33,34.29 235.22,34.19 234.95,34.19 234.86,34.28 234.86,35.02 235.05,35.22 237.56,35.22 237.75,35.02 237.75,34.97 237.94,34.78 238.32,34.78 238.51,34.97 238.51,35.02 238.7,35.22 239.08,35.22 239.27,35.02 239.27,34.94 239.4,34.81 239.74,34.81 239.9,34.97 239.9,35.06 240.05,35.22 240.52,35.22 240.62,35.12 240.62,34.63 240.88,34.37 241.82,34.37 242.34,34.9 245.33,34.9 245.52,35.09 245.52,35.68 245.71,35.87 246.1,35.87 246.29,35.68 246.29,35.09 246.48,34.9 247.93,34.9 248.12,35.09 248.12,35.42 v2(247.95,35.58)
  BOTTOM w0.102: UC1.AL38 159.14,46.26 159.14,43.75 159.99,42.9 v2(159.99,40.99)
  BOTTOM w0.157: v2(235.33,34.4) 235.33,35.66 234.21,36.78 JDIMM3.41 ; JDIMM1.41 246.56,36.78 246.94,36.4 247.64,36.4 247.95,36.09 v2(247.95,35.58)
DDR_A_D11: length 118.1
  IN1 w0.102: 173.44,38.5 172.16,39.79 171.38,39.79 170.73,40.44 169.15,40.44 168.17,41.43 163.34,41.43 162.91,40.99 161.06,40.99 v2(160.94,41.11)
  IN1 w0.122: v2(235.88,34.76) 234.62,36.01 232.43,36.01 231.27,34.85 219.9,34.85 219.63,35.12 218.42,35.12 217.31,36.22 214.14,36.22 214.02,36.1 214.02,35.93 213.9,35.81 213.65,35.81 213.53,35.93 213.53,36.1 213.41,36.22 213.17,36.22 213.04,36.1 213.04,35.61 212.92,35.49 212.68,35.49 212.56,35.61 212.56,36.1 212.43,36.22 212.21,36.22 211.35,35.36 206.66,35.36 205.76,36.27 178.82,36.27 178.69,36.39 178.69,36.67 178.51,36.85 178.26,36.85 178.14,36.73 178.14,36.39 178.02,36.27 177.84,36.27 177.65,36.45 177.65,36.92 177.46,37.12 177.29,37.12 177.17,36.99 177.17,36.39 177.05,36.27 176.86,36.27 176.68,36.45 176.68,36.8 176.56,36.92 176.31,36.92 176.19,36.8 176.19,36.39 176.07,36.27 175.68,36.27 173.44,38.5
  IN3 w0.15: v2(252.58,37.16) 252.58,36.29 252.1,35.82 250.14,35.82 249.83,35.51 249.83,34.64 249.1,33.91 242.75,33.91 242.23,33.38 240.47,33.38 240.06,33.79 237.53,33.79 237.16,34.16 236.93,34.16 236.83,34.26 236.37,34.26 v2(235.88,34.76)
  BOTTOM w0.102: UC1.AL37 159.27,47.05 159.27,46.46 159.36,46.37 159.36,43.82 160.27,42.9 160.27,42.12 160.94,41.45 v2(160.94,41.11)
  BOTTOM w0.157: JDIMM1.42 252.76,37.03 252.63,37.16 v2(252.58,37.16) ; JDIMM3.42 238.91,37.03 238.73,36.85 237.26,36.85 235.88,35.47 v2(235.88,34.76)

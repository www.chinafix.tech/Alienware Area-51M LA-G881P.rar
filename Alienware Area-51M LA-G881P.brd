# Allegro board Alienware Area-51M LA-G881P.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PD100_3/5V: length 2.2
  TOP w0.112: PR314.1 324.87,16.31 v1(324.7,16.47)
  TOP w0.254: PR314.1 324.46,15.34 324.43,15.31 PD301.1
VBAT_CHG: length 2.4
  TOP w0.203: PR745.1 204.75,136.36 205.32,136.93 205.51,136.93 206.03,137.45 PU703.26
VCC_CORE_PH1: length 1.2
  TOP w0.508: v2(109.82,34.19) 109.31,34.69 PRI17.1
  vias: v1(110.14,35.71)
VCC_CORE_PH2: length 3.7
  TOP w0.508: PRI35.1 109.24,22.38 109.97,23.1 v2(109.97,24.36)
  vias: v1(110.65,22.76)
VCC_CORE_PH3:
  vias: v1(114.2,58.13)
VCC_CORE_PH4: length 2.3
  TOP w0.508: PRI73.1 v2(116.88,73.57)
  BOTTOM w0.112: 118.14,75.72 v1(118.14,76.6)
VCC_CORE_PH5: length 1.3
  TOP w0.508: PRI98.1 109.13,43.77 109.64,44.28 v2(109.82,44.28)
  vias: v1(110.27,41.36)
VCC_CORE_PH6:
  vias: v1(112.17,49.87)
VCC_GT_PH1: length 1.7
  BOTTOM w0.112: PRG07.1 v1(133.95,12.6)
VCC_GT_PH2:
  vias: v1(156.94,15.07)
VCC_VCCIO:
  vias: v1(156.68,109.88)
VCC_VCCSA: length 12.5
  BOTTOM w0.254: PRA14.1 133.27,118.51 133.53,118.26 133.53,117.36 v1(133.91,116.97) 134.8,116.09 134.8,113.45 134.09,112.75 PCA09.1 131.52,112.77 PRA01.1 130.17,113.28 130.17,113.92 129.92,114.17 PUA01.17
VCC_VCORE: length 3.7
  TOP w0.203: PRZ03.2 60.44,31.89 60.52,31.89 60.56,31.86 v2(61.04,31.86) 61.08,31.82 PUZ01.42
  BOTTOM w0.203: PCZ03.1 61.76,30.95 v1(61.37,31.33) 61.04,31.67 v2(61.04,31.86)
VCCGT_VCC_SEN: length 114.3
  TOP w0.254: v2(136.4,45.23) 136.68,44.96 v1(136.68,36.92) RC691.2 ; v2(64.71,23.26) 64.71,23.33 64.7,23.34 PCZ10.1
  GND3 w0.203: v2(136.4,45.23) 135.48,44.31 135.48,43.76 134.36,42.64 134.36,36.41 131.88,33.93 131.88,32.59 131.18,31.89 131.18,26.63 131.18,26.35 130.35,25.53 127.17,25.53 126.06,24.42 114.76,24.42 111.7,21.36 110.2,21.36 107.79,18.95 101.3,18.95 97.21,23.04 89.09,23.04 86.52,25.6 80.31,25.6 77.31,28.6 76.5,28.6 76.07,29.03 70.07,29.03 69.07,28.03 68.36,28.03 64.71,24.38 v2(64.71,23.26)
  BOTTOM w0.203: v2(136.4,45.23) UC1.F39
  BOTTOM w0.254: PRZ28.2 v2(64.71,23.26)
VCCGT_VSS_SEN: length 114.6
  TOP w0.203: PUZ01.6 64.76,28.31 64.73,28.28 64.73,28.03 64.62,27.91 v2(64.62,27.61)
  TOP w0.254: v2(135.51,46.11) 135.47,46.07 135.47,43.71 135.91,43.27 v1(135.91,33.61) RC690.1
  GND3 w0.203: v2(135.51,46.11) 135.51,44.77 135.03,44.28 135.03,43.77 134.03,42.77 134.03,36.54 131.55,34.06 131.55,32.73 130.85,32.03 130.85,26.49 130.22,25.86 127.03,25.86 125.92,24.75 114.62,24.75 111.56,21.69 110.06,21.69 107.68,19.3 101.41,19.3 97.35,23.37 89.22,23.37 86.66,25.93 80.45,25.93 77.45,28.93 76.63,28.93 76.21,29.36 68.17,29.36 67.66,28.85 65.86,28.85 v2(64.62,27.61)
  BOTTOM w0.203: v2(135.51,46.11) 135.95,46.54 UC1.F38
  BOTTOM w0.254: v2(64.62,27.61) 65.08,28.07 65.08,28.48 PCZ11.1
VCCIO_PGOOD: length 2.2
  BOTTOM w0.254: PRF02.2 156.36,115.4 v1(156.08,115.12) 155.88,114.92 PUF01.9
VCCIO_SENSE: length 36.3
  BOTTOM w0.102: 153.74,84.99 153.74,82.44 153.89,82.08 153.89,80.46 153.32,79.89 UC1.AF4
  BOTTOM w0.381: 158.07,93.91 157.55,93.91 153.74,90.1 153.74,84.99
  BOTTOM w0.508: 158.07,93.91 165.38,101.22 v1(165.38,108.61) 165.38,109.91 PRF08.2
VCCPLL_OC: length 4.9
  TOP w0.102: v2(155.64,75.76) v1(156.06,75.34)
  TOP w0.254: RC25.1 154.34,74.28 CC46.2 154.34,75.55 RC21.1 155.28,76.12 v2(155.64,75.76)
  BOTTOM w0.254: v2(155.64,75.76) 156.06,75.33 UC1.AJ9
VCCSA_SENSE: length 51.1
  TOP w0.102: 150.9,84.99 v2(150.9,78.51)
  TOP w0.381: v2(143.64,95.88) 143.47,95.72 143.47,94.83 v1(145.57,92.73) 150.9,87.4 150.9,84.99
  BOTTOM w0.102: v2(150.9,78.51) 150.92,78.51 151.39,78.97 UC1.AD5
  BOTTOM w0.381: v2(143.64,95.88) 143.6,95.88 142.98,96.51 142.98,97.46 143.53,98.02 143.53,106.23 140.87,108.89 140.51,108.89 140.49,108.91 128.89,108.91 127.44,110.36 PRA19.2
VCCSA_SENSEN: length 5.2
  IN4 w0.254: v2(125.2,112.39) 125.2,114.6 124.92,114.88 v2(124.54,114.88)
  BOTTOM w0.254: v2(125.2,112.39) 125.89,112.39 PRA22.1 PRA21.1 ; PRA10.2 v2(124.54,114.88)
VCCSA_SENSEP: length 14.8
  BOTTOM w0.254: PRA18.1 127.01,112.9 124.32,112.9 123.52,113.71 123.52,120.05 v1(123.74,120.28) 124.1,120.64 PRA07.2
VCCST_PWEGD_R: length 25.4
  TOP w0.112: v2(140.54,101.69) v3(140.54,101.12)
  BOTTOM w0.102: UC1.U2 144.63,82.18 144.63,82.99 144.74,83.11 144.74,83.58 145.47,84.31 145.47,84.99
  BOTTOM w0.112: RC13.2 v2(140.54,101.69) 140.54,94.62 145.47,89.69 145.47,84.99
VDD_1.2V: length 17.2
  TOP w0.203: PR203.2 222.21,112.75 PC212.1 221.07,115.62 220.61,116.08 PU201.11
  TOP w0.254: PR203.2 222.21,111.72 222.53,111.4 225.45,111.4 226.28,112.23 226.28,115.57 v1(226.07,115.77) PR201.1
VDD_CHG: length 27.3
  TOP w0.203: PU703.19 203.96,140.58 v2(203.8,140.74) 202.62,140.74 PR760.1 201.63,140.58 PC768.2 201.33,140.88 201.33,141.54 201.07,141.81 v1(201.07,141.95) 201.07,143.22 201.27,143.42 PR749.2
  TOP w0.254: PR750.2 v2(210.77,145.62)
  BOTTOM w0.254: PR741.1 211.43,138.64 211.56,138.77 211.56,142.59 212.43,143.47 212.43,143.95 v2(210.77,145.62) 208.36,145.62 206.34,143.6 206.34,142.26 205.45,141.37 204.18,141.37 203.8,140.99 v2(203.8,140.74)
VDD_ISL95338_1: length 25
  TOP w0.112: v2(124.04,139.91) v1(124.04,140.6)
  TOP w0.254: PRS54.1 v2(128.83,147.32)
  TOP w0.381: v2(125.7,153.44) 125.7,153.6 126.12,154.02 PRS94.1
  TOP w0.508: PCS25.2 125.21,148.13 v2(125.19,148.11)
  IN1 w0.508: v2(124.04,139.91) 126.01,139.91 128.07,141.97 128.07,146.56 v2(128.83,147.32) ; v2(125.19,148.11) 125.19,151.79 125.7,152.3 v2(125.7,153.44)
  IN2 w0.508: v2(125.19,148.11) 125.19,147.86 125.73,147.32 v2(128.83,147.32)
  BOTTOM w0.203: PUS1.18 v2(125.19,148.11)
  BOTTOM w0.508: PRS09.2 124.05,139.93 v2(124.04,139.91)
VDD_ISL95338_2: length 27.8
  TOP w0.112: v1(154.13,145.49) 154.11,145.47 PRS95.1
  TOP w0.508: PRS95.1 152.2,143.99 v2(151.51,144.68) 150.83,144.68 PRS56.1 ; PCS54.2 147.03,146.11 v2(147.03,145.69)
  IN2 w0.508: v2(151.51,144.68) 147.79,144.68 147.03,145.44 v2(147.03,145.69) 146.33,144.99 144.87,144.99 143.5,143.63 143.5,140.47 145.5,138.48 145.5,138 144.99,137.49 v2(144.4,137.49)
  BOTTOM w0.203: v2(147.03,145.69) 147.15,145.69 147.57,145.28 PUS2.18 ; PUS2.25 151,144.17 v2(151.51,144.68)
  BOTTOM w0.508: v2(144.4,137.49) 145.72,137.49 145.73,137.5 145.8,137.5 146.03,137.72 146.03,137.79 146.23,138 PRS29.2
VDDP_1.2V:
  vias: v1(221.3,116.8)
VDDP_ISL95338_1:
  vias: v1(123.09,142.45)
VDDP_ISL95338_2:
  vias: v1(144.36,139.04)
VDDSPD1: length 7
  TOP w0.112: v2(243.59,93.28) v1(243.17,92.86)
  TOP w0.305: CD23.2 243.66,93.93 243.66,93.36 v2(243.59,93.28)
  TOP w0.381: RD58.1 244.33,96 243.61,95.27 CD22.1 CD23.2
  BOTTOM w0.305: JDIMM1.255 244.85,92.28 244.76,92.37 243.89,92.37 243.59,92.67 v2(243.59,93.28)
VDDSPD2: length 7.7
  TOP w0.112: RD59.1 v1(229.96,98.7)
  TOP w0.508: v2(229.92,94.56) 229.92,95.37 CD54.1 CD55.2 230,97.42 RD59.1
  BOTTOM w0.305: JDIMM3.255 230.73,92.28 229.84,93.17 229.84,94.49 v2(229.92,94.56)
VDDSPD3: length 7.2
  TOP w0.112: v1(218.85,97.24) 218.34,97.24 217.86,96.76 RD60.1
  TOP w0.254: RD60.1 217.86,96.56 CD85.1 CD86.2 217.86,94.46 217.58,94.18 217.58,94.1 v2(217.46,93.99)
  BOTTOM w0.305: v2(217.46,93.99) 217.46,93.95 217.42,93.91 217.42,92.58 217.73,92.28 JDIMM2.255
VDDSPD4: length 2.9
  BOTTOM w0.305: v2(202.84,91.07) 202.84,92.03 203.08,92.28 JDIMM4.255
  vias: v1(201.64,91.21)
VSSSAIO_SENSE: length 51.4
  TOP w0.508: v2(144.46,95.24) v3(148.78,90.92) 151.85,87.84 151.85,84.29 152.23,83.91 152.23,83.08 152.86,82.45 v2(152.86,80.35)
  BOTTOM w0.102: UC1.AE4 v2(152.86,80.35)
  BOTTOM w0.381: PRA21.2 126.67,110.06 128.06,108.66 128.06,108.63 128.57,108.13 140.55,108.13 142.77,105.91 142.77,100.59 142.53,100.35 142.53,98.09 142.21,97.77 142.21,95.96 143.41,94.77 143.98,94.77 v2(144.46,95.24)
+EC_VCCA: length 7
  TOP w0.254: CE172.1 309.17,8.79 308.92,9.04 308.92,9.14 v3(308.83,9.23) 308.83,11.53 308.1,12.26 308.01,12.26 307.99,12.28 UE5.67
  TOP w0.508: LE1.2 310.7,8.79 CE172.1
+EVDD09: length 2.7
  TOP w0.203: UL1.63 178.22,166.31 178.21,166.33 v2(177.94,166.33) ; UL1.55 v2(177.89,169.51) 177.89,169.53 178.27,169.91 UL1.54
  vias: v1(174.02,165.57)
+EVDD18: length 2.4
  TOP w0.203: 177.13,170.39 177.44,170.08 v1(177.64,170.08) 177.96,170.08 178.2,170.31 UL1.53
  TOP w0.508: CL62.1 177.08,170.44 177.13,170.39
+LCDVDD: length 9.2
  TOP w0.254: 108.73,123.34 108.73,122.25 108.46,121.98 105.82,121.98 105.2,121.36 105.2,117.94 RV2.1
  vias: v2(117.19,125.44) v2(117.19,124.85) v2(117.82,125.44) v3(117.99,124.76)
+PWR_SRC: length 155.2
  TOP w2.032: 275.61,24.05 275.61,25.73 277.65,27.76 283.35,27.76 288.07,32.47 293.9,32.47 296.38,34.95 303.68,34.95 303.87,34.76
  TOP w3.81: 163.35,134.52 163.35,130.52 172.07,121.79 175.45,121.79
  IN2 w7.62: 115.37,114.37 109.32,108.33 109.32,101.17
  IN2 w8.128: 295.6,74.66 290.06,88.03 282.52,106.22 281.46,107.29
  IN3 w8.128: 282.52,106.22 295.6,74.66 296.57,73.69
  BOTTOM w7.62: 110.9,101.47 110.9,110.33 115.05,114.49
  vias: v2(55.21,21.3) v2(55.47,21.87) v2(55.85,21.3) v2(56.03,21.87) v2(56.42,21.3) v2(111.58,97.18) v2(111.58,96.54) v2(111.58,95.91) v2(111.58,95.27) v2(112.22,97.18) v2(112.22,96.54) v2(112.22,95.91) v2(112.22,95.27) v2(112.85,97.18) v2(112.85,96.54) v2(112.85,95.91) v2(112.85,95.27) v2(113.49,97.18) v2(113.49,96.54) v2(113.49,95.91) v2(113.49,95.27) v2(118.5,118.79) v2(118.5,118.16) v2(118.5,117.52) v2(119.14,118.79) v2(119.14,118.16) v2(119.14,117.52) v2(119.77,118.79) v2(119.77,118.16) v2(119.77,117.52) v2(120.41,118.79) v2(120.41,118.16) v2(120.41,117.52) v2(121.04,118.79) v2(121.04,118.16) v2(121.04,117.52) v2(121.69,118.74) v2(121.69,118.11) v2(121.69,117.47) v2(122.33,118.74) v2(122.33,118.11) v2(122.33,117.47) v2(132.68,121.05) v2(133.27,121.05) v2(152.49,119.42) v2(152.49,118.83) v2(153.08,119.42) v2(153.08,118.83) v2(153.66,119.42) v2(153.66,118.83) v2(155.3,141.04) v2(155.3,140.28) v2(155.3,139.52) v2(155.3,138.76) v2(155.3,138) v2(155.3,137.23) v2(155.3,136.47) v2(155.57,141.76) v2(156.06,141.04) v2(156.06,140.28) v2(156.06,139.52) v2(156.06,138.76) v2(156.06,138) v2(156.06,137.23) v2(156.06,136.47) v2(156.34,141.76) v2(156.82,141.04) v2(156.82,140.28) v2(156.82,139.52) v2(156.82,138.76) v2(156.82,138) v2(156.82,137.23) v2(156.82,136.47) v2(157.1,141.76) v2(157.58,141.04) v2(157.58,140.28) v2(157.58,139.52) v2(157.58,138.76) v2(157.58,138) v2(157.58,137.23) v2(157.58,136.47) v2(158.34,141.04) v2(158.34,140.28) v2(158.34,139.52) v2(158.34,138.76) v2(158.34,138) v2(158.34,137.23) v2(158.34,136.47) v2(159.03,139.98) v2(159.03,139.22) v2(159.03,138.45) v2(159.03,137.69) v2(159.03,136.93) v2(159.03,136.17) v2(159.03,135.41) v2(160.68,123.96) v2(186.21,142.9) v2(186.21,142.01) v2(186.21,141.12) v2(186.21,140.23) v2(186.21,139.34) v2(187.19,132.69) v2(187.18,132.13) v2(187.75,132.67) v2(187.74,132.12) v2(187.73,131.56) v2(187.68,130.99) v2(188.31,132.66) v2(188.3,132.1) v2(188.29,131.54) v2(188.3,130.99) v2(188.85,131.57) v2(188.87,132.68) v2(188.86,132.12) v2(188.86,131.01) v2(188.86,130.45) v2(189.42,132.7) v2(189.42,132.14) v2(189.41,131.58) v2(189.42,131.02) v2(189.42,130.46) v2(206.27,123.47) v2(206.27,122.58) v2(206.27,121.69) v2(206.27,120.8) v2(207.16,123.47) v2(207.16,122.58) v2(207.16,121.69) v2(207.16,120.8) v2(208.05,123.47) v2(208.05,122.58) v2(208.05,121.69) v2(208.05,120.8) v2(208.94,123.47) v2(208.94,122.58) v2(208.94,121.69) v2(208.94,120.8) v2(222.22,122.26) v2(222.22,121.68) v2(222.81,122.26) v2(222.81,121.68) v2(223.39,122.26) v2(223.39,121.68) v2(223.98,122.26) v2(223.98,121.68) v2(275.68,121.31) v2(275.68,120.29) v2(275.68,119.28) v2(275.68,118.26) v2(275.68,117.24) v2(275.68,116.23) v2(275.68,115.21) v2(277.21,121.31) v2(277.21,120.29) v2(277.21,119.28) v2(277.21,118.26) v2(277.21,117.24) v2(277.21,116.23) v2(277.21,115.21) v2(278.73,121.31) v2(278.73,120.29) v2(278.73,119.28) v2(278.73,118.26) v2(278.73,117.24) v2(278.73,116.23) v2(278.73,115.21) v2(280.25,121.31) v2(280.25,120.29) v2(280.25,119.28) v2(280.25,118.26) v2(280.25,117.24) v2(280.25,116.23) v2(280.25,115.21) v2(281.65,121.31) v2(281.65,120.29) v2(281.65,119.28) v2(281.65,118.26) v2(281.65,117.24) v2(281.65,116.23) v2(281.65,115.21) v2(283.05,121.31) v2(283.05,120.29) v2(283.05,119.28) v2(283.05,118.26) v2(283.05,117.24) v2(283.05,116.23) v2(283.05,115.21) v2(284.06,119.78) v2(284.06,116.74) v2(305.05,37.46) v2(305.05,36.88) v2(305.05,36.29) v2(305.05,35.71) v2(305.32,35.19) v2(305.64,37.46) v2(305.64,36.88) v2(305.64,36.29) v2(305.64,35.71) v2(305.9,35.19) v2(306.22,36.29) v2(306.22,35.71) v3(162.46,139.6)
+RTC_CELL: length 230.4
  TOP w0.508: QE58.1 240.55,5.84 241.08,5.31 241.84,4.54 244.17,4.54 v3(245.33,3.39) 245.44,3.27 v2(245.44,2.72) ; v2(259.1,62.16) 258.95,62.31 RH531.2 258.97,62.91 258.97,63.63 RH83.1 ; PD5.1 v2(350.09,9.61)
  IN1 w0.508: v2(245.44,2.72) 246.16,2.72 246.86,2.02 277.66,2.02 279.38,3.74 282.51,3.74 283.62,2.63 284.05,2.63 285.05,1.63 297.28,1.63 299.22,3.57 302.93,3.57 305.08,1.42 334,1.42 339.15,6.57 347.05,6.57 v2(350.09,9.61)
  IN2 w0.508: v2(259.1,62.16) 258.8,62.16 257.96,61.32 257.96,48.87 256.85,47.76 v2(255.85,47.76)
  IN3 w0.508: v2(280.28,81.71) 280.28,81.17 279.78,80.66 277.08,80.66 275.32,78.9 272.45,78.9 v2(272.25,78.7)
  IN4 w0.508: v2(265.96,68.41) 265.9,68.35 262.34,68.35 261.45,67.46 260.14,67.46 258.91,66.23 258.91,62.35 v2(259.1,62.16)
  BOTTOM w0.508: v2(255.85,47.76) 255.95,47.65 255.95,36.74 256.84,35.85 256.84,27.63 254.44,25.23 254.44,15.19 251.61,12.37 251.61,11.9 250.49,10.78 248.78,10.78 248.31,10.3 248.31,5.69 245.44,2.82 v2(245.44,2.72) ; v2(272.25,78.7) 269.52,81.43 267.81,81.43 267.05,80.67 267.05,69.5 v2(265.96,68.41) ; RH84.1 v2(280.28,81.71)
+SDC: length 3.7
  BOTTOM w0.112: 128.24,133.83 128.46,133.83 128.73,133.56 128.73,132.45 128.95,132.23 130.43,132.23 v1(130.55,132.12)
+SDC_IN: length 89.2
  TOP w0.508: 127.78,138.56 127.78,141.05 128.68,141.95 v2(128.68,142.64) 128.68,142.71 128.13,143.25 PRS13.2 ; v2(158.91,147.79) 160.35,149.23 PQS24.1 ; 153.36,129.44 153.36,130.8 152.86,131.3 152.86,139.82 152.32,140.36 v2(151.21,140.36) 150.87,140.69 PRS33.2
  IN1 w0.508: 132.04,130.33 132.04,130.71 133.34,132.01 133.34,141.89 134.07,142.62 137.62,142.62 138.08,143.08 142.46,143.08 142.97,143.58 142.97,145.59 145.76,148.39 v2(145.76,148.49) 145.76,148.55 148.21,151 148.21,152.2 149.35,153.34 149.35,154.1 148.17,155.28 148.17,160.99 v2(150,162.82)
  IN2 w0.508: v2(158.91,147.79) 156.87,149.82 150.25,149.82 149.67,149.25 146.27,149.25 145.76,148.74 v2(145.76,148.49)
  BOTTOM w0.508: v2(150,162.82) 148.04,160.86 148.04,158.71 147.8,158.47 PQS22.1
  vias: v2(127.69,129.97) v2(127.69,129.21) v2(127.69,128.45) v2(128.32,129.94) v2(128.32,129.18) v2(128.32,128.42) v2(128.5,138.29) v2(128.5,137.68) v2(128.5,137.09) v2(128.52,136.54) v2(129.06,129.98) v2(129.06,129.37) v2(129.06,128.79) v2(129.08,128.23) v2(129.72,129.96) v2(129.72,129.35) v2(129.72,128.76) v2(129.74,128.2) v2(137.45,124.71) v2(138.01,124.74) v2(138.62,124.74) v2(139.23,124.74) v2(145.9,122.65) v2(146.48,122.65) v2(147.07,122.65) v2(147.65,122.65) v2(151.59,128.5) v2(151.59,127.73) v2(151.59,126.97) v2(151.59,126.21) v2(151.59,125.45) v2(151.59,124.69) v2(152.35,128.5) v2(152.35,127.73) v2(152.35,126.97) v2(152.35,126.21) v2(152.35,125.45) v2(152.35,124.69) v3(129.12,125.75) v3(141.19,121.82) v3(156.37,123.09)
+SDC_PWR: length 41.6
  TOP w0.112: v2(129.07,143.29) 129.77,143.99 v1(129.89,143.99)
  IN2 w0.254: v2(128.93,135.84) 129.25,136.15 129.25,138.94 128.86,139.33 128.86,141.72 129.16,142.02 129.16,143.2 v2(129.07,143.29)
  IN4 w0.254: v2(129.07,143.29) 129.65,143.29 130.52,144.17 131.86,144.17 132.77,145.08 145.95,145.08 146.63,144.41 150.09,144.41 150.46,144.04 151.81,144.04 152.21,143.63 v2(152.21,138.96)
  BOTTOM w0.254: PRS19.2 129.43,142.94 v2(129.07,143.29) ; v2(152.21,138.96) 152.28,139.03 PRS39.2 ; v2(128.93,135.84) 128.82,135.72 PRS97.2
+TBTA_VBUS: length 2.9
  TOP w0.254: v2(6.73,47.27) 6.71,47.27 6.68,47.24 6.58,47.24 6.31,46.98 JUSBC.B9
  TOP w0.279: JUSBC.A4 8.25,46.73 v2(8.41,46.89)
  BOTTOM w0.254: UT4.B10 UT4.A10 45.79,44.4 v2(46.1,44.09)
  vias: v2(6.73,44.35) v2(8.47,44.1) v2(8.98,46.82) v2(9.11,44.07) v2(9.3,43.52) v2(9.62,46.82) v2(9.87,43.52) v2(11.46,51.65) v2(11.59,51.08) v2(12.01,52.17) v2(12.03,51.59) v2(14.09,53.52) v2(47.22,49.65) v2(47.36,49.02) v2(47.57,50.13) v2(47.81,49.4) v2(48.18,50.2) v2(48.35,50.83) v2(48.75,50.4) v3(46.13,49.55)
AC_PRESENT: length 8.5
  TOP w0.089: UH1.BG42 272.24,65.32 271.75,65.82 RH1025.1 271.75,67.65 271.6,67.79 271.6,68.32
  TOP w0.127: 271.6,68.32 v1(271.6,68.6) RH533.1 272.19,70.28 DH1.2
ACC1_INT1: length 3.2
  TOP w0.112: v1(109.43,168.93) 109.43,169.21 109.97,169.76 110.01,169.76 110.41,170.15 RH619.1 111.14,171 US2.4
ACC_ADDRESS: length 2.8
  TOP w0.112: v1(274.48,79.08) 274.86,78.7 275.87,78.7 276.03,78.86 RS16.1 276.11,79.15 US3.3
ACC_INT1: length 1.3
  TOP w0.112: US3.12 277.3,81.1 RH622.1
ACC_INT2: length 3.2
  TOP w0.112: v1(279.37,82.66) 279.37,82.53 278.85,82 278.85,81.84 RH623.1 277.8,80.79 US3.11
ACIN#: length 13.3
  TOP w0.112: RE17.2 349.98,40.66 v2(349.91,40.73) 349.56,40.37 v1(349.56,40.08)
  TOP w0.127: v2(352.96,34.18) 353.11,34.18 353.55,34.61 UE1.18 ; QE3.3 350.68,40.63 RE17.2
  IN1 w0.084: v2(352.96,34.18) 353.37,34.58 353.37,37.27 353.7,37.6 353.7,38.3 351.27,40.73 v2(349.91,40.73)
ACIN_CHG: length 5.2
  TOP w0.112: PR732.1 211.73,136.5 v1(211.93,136.29)
  TOP w0.203: PC711.2 209.96,137.31 209.08,138.18 PU703.1
  TOP w0.254: PC711.2 210.97,136.98 PR732.1 PR729.2
ACIN_ISL95338_1: length 2.4
  TOP w0.112: v2(125.92,148.19) 125.92,148.01 v1(125.57,147.66)
  TOP w0.254: v2(125.92,148.19) 125.92,148.74 PRS73.2
  BOTTOM w0.203: v2(125.92,148.19) 125.59,147.87 PUS1.19
ACIN_ISL95338_2: length 2.7
  TOP w0.112: v3(148.05,144.99) 147.73,145.31 v2(147.73,145.76)
  TOP w0.254: v2(147.73,145.76) 147.73,145.89 148.16,146.32 PRS74.2
  BOTTOM w0.203: v2(147.73,145.76) 147.73,145.76 147.73,145.76 147.97,145.51 PUS2.19
ACIN_R_1: length 15.2
  TOP w0.254: v2(123.37,153.54) 123.37,153.03 122.76,152.42 PQS29.6 121.68,152.42 121.43,152.17 PCS84.2 ; PQS18.1 v2(128.32,151.19) 128.16,151.03 PRS76.1 PRS75.2 126.38,151.34 125.7,151.34 v3(125.57,151.22) 125.57,150.84 126.06,150.34 PRS73.1
  IN3 w0.254: v2(123.37,153.54) 125.72,151.19 v2(128.32,151.19)
ACLIM_CHG: length 4.5
  TOP w0.112: v1(203.93,144.36) 203.53,143.96 PR749.1
  TOP w0.203: PR749.1 203.52,143.41 PR751.2 203.98,142.65 204.01,142.67 205.36,142.67 205.63,142.39 PU703.16
ACOK_ISL95338_1: length 347.4
  TOP w0.112: UE5.71 v2(308.44,13.88)
  TOP w0.254: v2(117.88,170.58) 118.01,170.71 PR35.1 PR36.2
  IN2 w0.104: v2(262.04,74.81) 259.39,77.47 259.39,94.78 257.49,96.68 244.4,96.68 244.2,96.88 241.75,96.88 241.62,96.76 238.47,96.76 237.76,97.47 234.83,97.47 234.33,97.97 210.96,97.97 210.01,98.92 199.41,98.92 198.1,97.61 188.97,97.61 182.68,103.9 182.68,107.84 178.39,112.13 178.39,113.44 166.64,125.19 166.64,139.24 159.68,146.2 150.91,146.2 150.57,146.54 146.06,146.54 145.73,146.87 130.82,146.87 127.89,149.81 127.89,152.58 127.38,153.08 126.47,153.08 126.2,152.82 124.58,152.82 124.31,153.08 120.25,153.08 119.4,153.93 119.4,163.23 v2(118.96,163.66)
  BOTTOM w0.112: v2(118.96,163.66) 118.96,167.79 117.88,168.87 v2(117.88,170.58) ; v2(308.44,13.88) v1(307.05,13.88) 306.31,13.88 303.34,10.91 293.73,10.91 291.26,8.44 291.26,6.69 289.35,4.78 284.38,4.78 283.78,5.39 283.78,7.31 284.25,7.78 284.25,9.87 286.15,11.77 286.15,13.69 286.94,14.48 286.94,16.76 286.98,16.8 286.98,19.46 286.81,19.63 286.28,19.63 283.78,22.14 276.73,22.14 269.76,29.11 267.91,29.11 262.81,34.21 262.81,36.39 260.23,38.97 260.23,48.35 260.85,48.97 260.85,52.66 260.44,53.06 260.44,54.19 261.53,55.28 261.53,60.73 263.71,62.9 263.71,67.01 262.44,68.28 262.44,73.54 262.04,73.94 v2(262.04,74.81)
  BOTTOM w0.254: v2(117.88,170.58) 118.39,171.09 118.39,172.56 116.52,174.43 113.54,174.43 PC23.1
ACOK_ISL95338_2: length 295.1
  TOP w0.112: PC24.1 149.43,150.8 PR38.2 151.13,152.5 PR37.1 151.59,152.5 v2(151.82,152.27) ; UE5.72 308.24,14.28 308.27,14.31 308.7,14.31 v2(309.08,13.93)
  IN2 w0.104: v2(151.82,152.27) 158.44,152.27 159.54,151.17 159.54,147.32 167.33,139.53 167.33,125.47 179.08,113.73 179.08,112.42 183.38,108.12 183.38,104.19 189.26,98.3 197.81,98.3 199.12,99.62 210.29,99.62 211.24,98.66 234.62,98.66 235.12,98.17 243.89,98.17 244.69,97.37 257.79,97.37 260.17,94.99 260.17,84.75 261.55,83.37 261.55,77.16 262.44,76.26 262.44,75.81 v2(262.03,75.4)
  BOTTOM w0.112: v2(309.08,13.93) 309.08,13.93 308.59,13.43 306.2,13.43 303.44,10.67 293.83,10.67 291.62,8.46 v1(291.62,7.58) 291.62,6.72 289.45,4.54 284.29,4.54 283.86,4.97 283.54,5.29 283.54,7.41 284.01,7.88 284.01,9.97 285.91,11.87 285.91,13.79 286.7,14.58 286.7,18.27 286.09,18.88 286.09,19.49 283.68,21.9 276.63,21.9 269.66,28.87 267.81,28.87 262.57,34.11 262.57,36.29 259.99,38.87 259.99,48.45 260.61,49.07 260.61,52.56 260.2,52.96 260.2,56.69 260.68,57.17 261.14,57.17 261.29,57.33 261.29,60.83 261.85,61.39 261.85,62.19 261.43,62.61 260.98,62.61 260.18,63.4 260.18,66.9 260.83,67.55 261.71,67.55 261.95,67.79 261.95,70.77 261.54,71.19 261.54,73.43 261.63,73.52 261.63,74.99 v2(262.03,75.4)
AD0_0: length 2.7
  TOP w0.112: UE3.31 154.15,180.74 v1(153.83,181.06) 153.83,181.43 RE43.2
AD1_0: length 4.1
  TOP w0.112: UE3.32 153.65,180.42 153.54,180.52 152.6,180.52 152.49,180.63 v1(152.49,181) 153.13,181.63 153.58,181.63 153.69,181.74 RE40.2
AD2_0: length 4.3
  TOP w0.112: UE3.1 152.32,179.01 151.79,179.54 v1(151.79,179.73) 151.79,181 RE42.1
AD3_0: length 5.2
  TOP w0.112: RE44.1 150.91,180.93 v1(150.91,180.81) 150.91,179.85 152.24,178.51 UE3.2
AD_BID: length 8.7
  TOP w0.112: UE5.66 308.04,11.88 308.44,11.47 308.44,8.95 309.47,7.92 CE28.1 309.96,7.06 RE66.2 RE64.1 v1(309.93,5.12)
ADP_I: length 256.2
  TOP w0.112: v2(305.94,11.7) 306.16,11.48 UE5.65 307.85,11.48 308.21,11.12 308.21,7.47 PR23.1
  TOP w0.254: PR774.1 v2(212.24,141.25) PC748.1
  IN1 w0.084: v2(293.65,16.58) 294.05,16.98 295.84,16.98 296.09,16.73 298.85,16.73 299.04,16.54 299.04,15.81 303.67,11.19 305.43,11.19 v2(305.94,11.7)
  IN3 w0.104: v2(263.24,77.63) 269.83,77.63 271.99,79.79 274.95,79.79 276.71,81.56 277.52,81.56 278.4,82.44 278.4,85.6 276.39,87.61 276.39,97.16 275.75,97.79 275.75,102.65 269.94,108.47 263.44,108.47 259.64,112.27 237.62,112.27 236.7,111.34 233.42,111.34 232.62,110.54 220.1,110.54 219.64,111 215.86,111 214.88,111.98 209.62,111.98 207.72,110.08 205.57,110.08 204.42,111.23 204.42,114.7 205.15,115.43 205.15,125.55 208.46,128.86 208.46,132.13 209.14,132.81 209.14,135.64 211.61,138.11 211.61,140.62 v2(212.24,141.25)
  BOTTOM w0.112: v2(293.65,16.58) 293.31,16.91 292.21,16.91 v1(292.01,17.12) 290.28,18.85 289.84,18.85 287.11,21.58 286.29,21.58 284.55,23.33 277.23,23.33 270.25,30.3 268.41,30.3 264,34.7 264,36.88 261.42,39.47 261.42,47.85 262.04,48.48 262.04,52.54 262.24,52.73 262.24,53.66 262.73,54.15 262.73,57.09 264.84,59.21 264.84,61.76 265.14,62.05 265.14,67.61 264.03,68.72 264.03,76.84 v2(263.24,77.63)
ADPS_ISL95338_1: length 6.4
  TOP w0.112: PCS67.1 v1(124.41,143.68)
  TOP w0.254: PCS67.1 123.92,144.85 v2(123.02,145.76)
  IN2 w0.254: v2(123.02,145.76) 123.79,146.53 123.79,147.25 123.52,147.52 v2(123.47,147.52)
  BOTTOM w0.203: PUS1.13 123.66,145.48 123.53,145.62 123.15,145.62 v2(123.02,145.76)
ADPS_ISL95338_2: length 3.3
  TOP w0.112: v2(145.69,144.36) 145.69,144.54 v3(146.02,144.87)
  TOP w0.254: v2(145.44,143.03) 145.87,143.46 PCS68.2 145.87,144.18 v2(145.69,144.36)
  BOTTOM w0.203: PUS2.13 145.5,142.97 v2(145.44,143.03)
AMON_CHG: length 1.8
  TOP w0.203: PU703.6 209.59,140.58 210.26,141.25 PR774.2
AMP_SPI_CS_L1: length 277.8
  TOP w0.112: UE5.128 293.14,25.88 293.03,25.99 v2(292.13,25.99)
  IN3 w0.104: v2(36.66,17.32) 36.66,17.38 36.78,17.5 37.64,18.36 38.43,18.36 38.86,18.79 41.1,18.79 41.33,19.02 47.75,19.02 48.97,17.8 48.97,17.14 50.39,15.72 55.07,15.72 55.47,16.13 65.51,16.13 68.2,13.43 80.19,13.43 82.66,15.9 87.84,15.9 89.02,17.08 93.77,17.08 95.74,15.11 106.14,15.11 106.94,14.31 109.23,14.31 110.38,14.31 112.05,12.64 118.65,12.64 119.27,12.02 123.53,12.02 123.8,11.75 126.05,11.75 126.72,11.08 132.42,11.08 132.85,11.52 141.73,11.52 142.18,11.07 154.31,11.07 157.7,14.46 180.14,14.46 180.99,13.6 186.6,13.6 188.43,15.43 225.97,15.43 227.17,16.62 230.81,16.62 231.47,17.28 236.05,17.28 238.15,19.38 258.07,19.38 266.97,28.28 284.47,28.28 284.83,28.64 286.76,28.64 288.36,27.04 290.22,27.04 290.4,26.86 290.99,26.86 291.86,25.99 v2(292.13,25.99)
  BOTTOM w0.112: v2(292.13,25.99) v1(293.01,25.99) ; JAUDIO.14 36.06,16.71 v2(36.66,17.32)
AMP_SPI_CS_L2: length 303.3
  TOP w0.112: UE5.68 308.36,12.68 v2(308.63,12.41) 308.96,12.08 v1(308.96,11.97)
  IN3 w0.104: v2(37.7,13.02) 38.08,13.02 39.18,14.12 43.01,14.12 46.97,10.15 49.6,10.15 50.42,10.97 57.21,10.97 58.45,9.74 63.19,9.74 66.18,6.74 76.5,6.74 77.37,7.61 77.98,7.61 78.62,6.97 80.14,6.97 81.45,8.28 81.64,8.28 87.94,8.28 88.7,7.52 93.56,7.52 96.01,9.97 108.89,9.97 111.89,6.97 119.7,6.97 120.64,6.04 123.96,6.04 124.28,6.35 126.72,6.35 127.03,6.04 138.13,6.04 138.33,6.24 139.68,6.24 139.83,6.08 166.32,6.08 167.01,5.4 178.45,5.4 179.28,4.57 182.12,4.57 182.72,5.17 186.22,5.17 190.84,9.78 195.38,9.78 196.52,8.64 223.07,8.64 223.86,7.84 241.13,7.84 244.29,11 249.03,11 251.46,8.57 258.15,8.57 258.55,8.96 259.26,8.96 259.69,9.39 260.91,9.39 264.45,12.93 264.45,14.04 267.88,17.47 269.38,17.47 270.06,18.14 270.06,19.28 270.1,19.33 275.55,19.33 277.24,17.64 277.24,14.69 279.14,12.79 283.46,12.79 285.2,14.52 286.41,14.52 287.21,13.72 292.13,13.72 292.39,13.47 301.69,13.47 301.87,13.28 308.13,13.28 308.63,12.78 v2(308.63,12.41)
  BOTTOM w0.112: JAUDIO.15 35.56,13.64 36.18,13.02 37.7,13.02 v2(37.7,13.02)
AMP_SPI_CS_R1: length 293.7
  TOP w0.112: v1(293.91,7.58) 293.91,7.98 293.4,8.48 v2(293.4,8.62) 293.42,8.62 293.54,8.74 UE5.34
  IN1 w0.084: v2(34.14,17.82) 34.14,15.6 35.23,14.5 36.52,14.5 37.05,13.98 37.05,12.68 38.27,11.47 46.36,11.47 46.64,11.75 47.42,11.75 47.7,11.47 62.21,11.47 63.61,12.86 65.28,12.86 71.95,6.2 93.97,6.2 96.12,8.34 107.88,8.34 111.12,5.11 118.44,5.11 120.98,2.57 126.2,2.57 127.05,3.42 172.22,3.42 173.34,2.31 189.68,2.31 190.33,1.66 193.86,1.66 195.86,3.65 218.51,3.65 219.35,2.82 221.83,2.82 223.36,4.35 237.38,4.35 241.94,8.9 241.94,11.13 246.61,15.8 255.54,15.8 259.24,19.5 269.07,19.5 269.88,18.69 274.19,18.69 275.16,17.73 275.16,14.41 279.03,10.53 288.75,10.53 290.66,8.62 v2(293.4,8.62)
  BOTTOM w0.112: JAUDIO.16 35.06,15.31 34.7,15.67 34.7,17.26 v2(34.14,17.82)
AMP_SPI_CS_R2: length 286
  TOP w0.112: v2(292.81,20.3) 295.24,20.3 295.55,19.99 295.55,18.94 294.89,18.28 UE5.15
  IN3 w0.104: v2(34.95,13.32) 37.18,15.55 44.77,15.55 46.81,13.51 47.54,13.51 48.25,12.8 50.01,12.8 50.41,12.41 62.84,12.41 64.29,10.95 80.89,10.95 81.9,9.94 89.05,9.94 90.04,8.95 92.96,8.95 96.21,12.19 105.19,12.19 105.81,11.57 109.31,11.57 111.71,9.17 115.48,9.17 116.25,9.95 117.54,9.95 118.15,9.33 122.42,9.33 122.69,9.06 124.61,9.06 125.28,8.39 133.53,8.39 133.97,8.83 140.61,8.83 141.06,8.38 156.13,8.38 156.85,9.1 180.89,9.1 181.26,9.46 186.6,9.46 189.62,12.48 196.23,12.48 197.56,11.14 223.43,11.14 223.9,11.61 228.29,11.61 228.85,12.17 235.73,12.17 239.49,15.93 260.23,15.93 268.07,23.77 270.3,23.77 271.66,25.13 283.28,25.13 286.62,21.79 287.05,21.79 288.2,20.64 289.58,20.64 289.75,20.81 290.86,20.81 291.37,20.3 v2(292.81,20.3)
  BOTTOM w0.112: v2(292.81,20.3) v1(292.28,20.3) ; JAUDIO.17 34.56,14.37 34.95,13.97 v2(34.95,13.32)
AMP_SPI_MISO: length 287
  TOP w0.112: v2(296.71,26.82) 296.74,26.79 UE5.119
  IN3 w0.104: v2(296.71,26.82) 296.37,26.48 295.65,26.48 294.5,25.32 291.28,25.32 290.02,26.58 287.8,26.58 287.04,27.34 285.59,27.34 285.1,27.82 267.16,27.82 258.26,18.92 238.34,18.92 236.24,16.82 231.66,16.82 231,16.16 227.36,16.16 226.17,14.97 188.62,14.97 186.75,13.1 180.84,13.1 179.95,13.99 158.59,13.99 155.2,10.61 141.98,10.61 141.53,11.06 133.05,11.06 132.61,10.62 126.53,10.62 125.86,11.29 123.61,11.29 123.34,11.56 119.08,11.56 118.46,12.18 111.86,12.18 110.19,13.85 109.42,13.85 106.69,13.85 105.89,14.64 95.55,14.64 93.58,16.61 89.24,16.61 88.04,15.42 82.86,15.42 80.37,12.93 68,12.93 65.3,15.62 55.65,15.62 55.26,15.24 51.3,15.24 50.48,14.42 48.95,14.42 48.46,14.91 48.46,17.6 47.55,18.51 41.53,18.51 41.3,18.29 39.06,18.29 38.63,17.85 37.84,17.85 37.57,17.58 37.57,16.85 35.37,14.64 34.46,13.74 v2(33.95,13.74)
  BOTTOM w0.112: JAUDIO.19 33.56,14.14 v2(33.95,13.74) ; v2(296.71,26.82) v1(297.21,26.82)
AMP_SPI_MOSI: length 287
  TOP w0.112: v2(296.13,26.88) 296.13,26.69 296.34,26.48 UE5.120 ; v2(33.95,13.16) v1(33.95,12.6)
  IN3 w0.104: v2(296.13,26.88) 295.95,26.71 295.56,26.71 294.4,25.55 291.97,25.55 290.89,26.63 290.31,26.63 290.13,26.81 288.27,26.81 286.67,28.41 284.92,28.41 284.56,28.05 267.07,28.05 258.16,19.15 238.25,19.15 236.15,17.05 231.56,17.05 230.91,16.39 227.26,16.39 226.07,15.2 188.53,15.2 186.66,13.33 180.94,13.33 180.04,14.23 158.49,14.23 155.11,10.84 142.08,10.84 141.63,11.29 132.95,11.29 132.51,10.85 126.62,10.85 125.95,11.52 123.71,11.52 123.44,11.79 119.17,11.79 118.56,12.41 111.96,12.41 110.28,14.08 109.33,14.08 109.33,14.08 106.79,14.08 105.99,14.88 95.64,14.88 93.67,16.84 89.11,16.84 87.94,15.67 82.76,15.67 80.26,13.18 68.1,13.18 65.4,15.87 55.57,15.87 55.17,15.47 50.29,15.47 48.72,17.04 48.72,17.7 47.65,18.77 41.43,18.77 41.2,18.54 38.96,18.54 38.53,18.11 37.77,18.11 37.34,17.68 37.34,17.08 34.41,14.15 33.78,14.15 33.54,13.91 33.54,13.56 v2(33.95,13.16)
  BOTTOM w0.112: v2(33.95,13.16) 34.36,13.57 34.36,14.04 34.06,14.35 JAUDIO.18
AMP_SPI_SCLK: length 287
  TOP w0.112: v2(293.9,24.03) 293.94,24.06 UE5.126
  IN3 w0.104: v2(33,13.2) 33.45,12.75 34.12,12.75 34.52,13.15 34.52,13.47 37.72,16.68 39.19,16.68 39.93,17.42 41.19,17.42 41.78,18.01 47.22,18.01 47.95,17.27 47.95,14.77 48.76,13.96 50.49,13.96 50.74,13.71 54.73,13.71 55.83,14.82 58.51,14.82 59.09,14.24 60.5,14.24 60.94,14.68 62.28,14.68 63.16,13.79 65.45,13.79 66.83,12.42 81.46,12.42 83.97,14.93 88.24,14.93 89.44,16.13 93.41,16.13 95.35,14.18 105.7,14.18 106.5,13.39 109.61,13.39 110,13.39 112.44,10.94 114.74,10.94 115.51,11.71 118.27,11.71 118.89,11.1 123.15,11.1 123.42,10.83 125.62,10.83 126.29,10.16 132.8,10.16 133.24,10.59 141.34,10.59 141.79,10.14 155.39,10.14 158.78,13.53 179.75,13.53 181.41,11.87 186.18,11.87 188.79,14.48 226.33,14.48 227.55,15.7 231.19,15.7 231.85,16.36 236.44,16.36 238.47,18.39 258.39,18.39 267.35,27.36 284.91,27.36 285.4,26.87 286.85,26.87 287.61,26.12 289.83,26.12 291.09,24.86 293.07,24.86 v2(293.9,24.03)
  BOTTOM w0.112: v2(293.9,24.03) v1(293.4,24.03) ; v2(33,13.2) 33.06,13.25 JAUDIO.20
ASGATE_CHG: length 3
  TOP w0.203: PC791.2 207.7,135.74 207.7,136.64 207.63,136.71 PU703.30
B+_BIAS: length 38.8
  TOP w0.508: R179.2 85.5,19.15 85.23,19.42 v1(83.85,19.42) 76.2,19.42 v2(75.27,20.34)
  IN1 w0.508: v2(50.85,19.66) 50.85,19.33 51.63,18.55 53.71,18.55 55.93,16.33 57.63,16.33 58.05,16.75 60,16.75 61.22,17.97 72.9,17.97 v2(75.27,20.34)
B+_VCCIO: length 2.6
  TOP w0.254: PCF02.1 155.38,117.13 PCF01.1 154.52,117.09 PCF05.1 154.52,115.78 154.38,115.64 v2(154.38,115.54)
  vias: v1(151.73,115.02)
BA: length 6.1
  TOP w0.112: v1(199.61,128.29) 201.79,128.29 201.9,128.18 PQ709.1
  TOP w0.508: PQ709.1 201.9,126.86 PRB66.1 203.53,127.44 PR793.2
BA_PWR: length 3
  TOP w0.112: v1(203.82,124.82) PRB66.2
  TOP w0.508: PRB66.2 204.86,126.34 PDS705.2
BATGONE_CHG: length 2
  TOP w0.203: PR764.2 206.83,143.85 PU703.13
BATLOW#: length 5.1
  TOP w0.076: RT31.2 RT14.1 22.8,49.79 22.8,49.03 v2(22.83,48.99) 22.83,47.96 v1(23.21,47.58)
  BOTTOM w0.089: UT1.F2 22.02,47.72 22.02,48.13 22.07,48.18 22.07,48.31 22.53,48.77 22.75,48.77 22.83,48.85 v2(22.83,48.99)
BATT+: length 216.9
  TOP w0.254: PR745.2 203.06,133.59 203.06,132.76 202.48,132.18 201.32,132.18 201.07,131.93 201.07,131.02 200.4,130.35 198.93,130.35 198.91,130.33
  TOP w0.508: 198.91,129.56 199.22,129.25 200.44,129.25 200.74,129.55 PQ709.3 202.08,128.72 203.59,128.72 PR793.1
  TOP w6.096: 77.56,32.54 77.56,44.9 93.27,60.61 98.77,60.61 99.97,61.81 ; 104.42,69.43 104.42,77.37 108.04,80.99 108.04,103.82 111.94,107.72
  IN3 w6.096: 170.59,110.16 184,110.16 195.16,121.33 195.16,123.44 ; 113.34,109.13 108.1,103.89 108.1,82.6 102.11,76.6 102.11,67.18 96.8,61.87 94.39,61.87 77.44,44.93 77.44,37.36
  vias: v2(71.91,27.07) v2(71.91,26.31) v2(71.91,25.55) v2(72.67,27.07) v2(72.67,26.31) v2(72.67,25.55) v2(73.43,27.07) v2(73.43,26.31) v2(73.43,25.55) v2(74.19,27.07) v2(74.19,26.31) v2(74.19,25.55) v2(74.95,27.07) v2(74.95,26.31) v2(74.95,25.55) v2(75.72,27.07) v2(75.72,26.31) v2(75.72,25.55) v2(76.48,27.07) v2(76.48,26.31) v2(76.48,25.55) v2(77.24,27.07) v2(77.24,26.31) v2(77.24,25.55) v2(78,27.07) v2(78,26.31) v2(78,25.55) v2(116.69,107.85) v2(116.69,107.26) v2(117.28,109.01) v2(117.28,108.43) v2(117.28,107.85) v2(117.28,107.26) v2(117.86,109.01) v2(117.86,108.43) v2(117.86,107.85) v2(117.86,107.26) v2(118.44,109.01) v2(118.44,108.43) v2(118.44,107.85) v2(118.44,107.26) v2(119.03,109.01) v2(119.03,108.43) v2(119.03,107.85) v2(119.03,107.26) v2(119.61,109.01) v2(119.61,108.43) v2(119.61,107.85) v2(119.61,107.26) v2(120.2,109.01) v2(120.2,108.43) v2(120.2,107.85) v2(120.2,107.26) v2(120.78,109.01) v2(120.78,108.43) v2(120.78,107.85) v2(120.78,107.26) v2(194.65,133.63) v2(194.65,132.74) v2(194.65,131.85) v2(194.65,130.96) v2(194.65,130.07) v2(195.54,133.63) v2(195.54,132.74) v2(195.54,131.85) v2(195.54,130.96) v2(195.54,130.07) v2(196.34,131.44) v2(196.3,130.78) v2(196.29,130.06) v2(196.43,133.63) v2(196.43,132.74) v2(196.35,132.07) v2(196.93,130.02) v2(196.99,132.03) v2(197,131.38) v2(196.96,130.72) v2(197.3,133.58) v2(197.32,132.74) v2(197.54,130.02) v2(197.6,132.03) v2(197.61,131.38) v2(197.57,130.72) v2(198.23,130.66) v2(198.2,129.96) v2(198.26,131.96) v2(198.27,131.32) v3(79.09,26.44)
BATT++: length 3.2
  TOP w0.112: v3(69.63,16.72) 70.07,17.17 v2(70.58,17.17) ; v2(70.58,17.17) v3(70.58,18.12) ; v2(70.58,17.17) 71.09,17.17 v3(71.53,16.72)
BATT_CHG_LED: length 19.1
  TOP w0.127: v2(354.66,43.97) RE23.2 355.29,43.13 355.51,42.91 QE1.6 ; UE1.19 355.45,34.11 355.69,33.87 v2(355.69,33.44)
  BOTTOM w0.112: v2(355.69,33.44) 355.79,33.34 357.78,33.34 358.15,33.72 358.15,34.58 358.5,34.93 358.5,38.74 358.24,39 358.24,40.38 v1(356.22,42.4) v2(354.66,43.97)
BATT_CHG_LED#: length 148.2
  TOP w0.112: v2(249,8.41) 248.79,8.62 UE10.2 ; v2(342.52,9.58) 342.58,9.58 343.81,10.81 345.02,10.81 350.62,16.4 350.62,25.16 350.98,25.52 350.98,28.32 351.23,28.57 353.08,28.57 355.7,31.19 355.98,31.19 357.98,33.19 357.98,35.35 352.92,40.41 352.14,40.41 351.64,40.91 351.64,42.33 v1(351.91,42.6) 352.22,42.92 352.87,42.92 353.52,42.26
  TOP w0.127: QE1.2 353.52,42.26
  IN3 w0.104: v2(342.52,9.58) 342.15,9.95 305.72,9.95 304,11.67 290.19,11.67 288.95,10.43 280.77,10.43 278.35,8.01 277.24,8.01 275.06,10.19 270.01,10.19 265.66,5.84 253.12,5.84 250.55,8.41 v2(249,8.41)
BATT_LOW_LED: length 4.6
  TOP w0.112: v1(353,37.71) QE3.6
  TOP w0.127: QE3.6 351.98,37.33 351.84,37.18 RE21.2 352.26,36.73 352.65,37.11 UE1.13
BATT_LOW_LED#: length 142.8
  TOP w0.112: v2(248.95,10.06) 248.89,10.12 UE10.5 ; QE3.2 351.33,40.05 351.45,40.17 352.82,40.17 357.74,35.25 357.74,33.29 355.88,31.43 355.6,31.43 352.99,28.81 351.13,28.81 350.61,28.29 350.61,25.49 350.38,25.26 350.38,16.5 345.02,11.14 v1(344.52,11.14) 343.81,11.14 342.84,10.18 v2(342.52,10.18)
  IN3 w0.104: v2(248.95,10.06) 249.32,10.06 251.27,8.11 258.63,8.11 258.84,7.89 260.06,7.89 260.87,8.7 261.2,8.7 261.41,8.91 265.08,8.91 266.02,7.97 267.46,7.97 269.91,10.42 275.16,10.42 277.33,8.24 278.26,8.24 280.68,10.66 288.86,10.66 290.1,11.91 304.09,11.91 305.82,10.18 v2(342.52,10.18)
BATT_PRS: length 7.4
  TOP w0.112: PR13.1 75.75,11.36 75.29,10.89 75.29,10.45 v3(74.57,9.73) v2(74.57,9.04)
  BOTTOM w0.112: v2(74.57,9.04) 74.57,9.11 75.6,10.13 PBATT1.7
BBS_BIT0: length 18.1
  TOP w0.089: v2(279.62,61.21) UH1.BA26
  TOP w0.127: RH130.2 v1(275.05,72.77) 274.64,72.77 274.47,72.6 v2(274.47,72.57)
  BOTTOM w0.127: v2(279.62,61.21) 279.67,61.15 280,61.15 280.19,61.34 280.19,66.34 278.95,67.58 278.95,69.14 278.08,70.01 278.08,71.85 277.36,72.57 v2(274.47,72.57)
BEEP#: length 276.8
  TOP w0.112: UE5.23 289.26,15.08 288.31,14.12 v1(288.31,14.12) v2(288.31,13.2)
  IN1 w0.084: v2(288.31,13.2) 288.31,12.97 287.46,12.13 278.63,12.13 276,14.76 276,18.07 274.54,19.53 270.23,19.53 269.42,20.35 258.89,20.35 255.19,16.65 246.26,16.65 241.09,11.48 241.09,9.25 237.03,5.19 223.01,5.19 221.48,3.66 219.69,3.66 218.78,4.58 195.5,4.58 193.49,2.56 190.71,2.56 190.06,3.21 175.13,3.21 174.08,4.26 126.44,4.26 125.59,3.41 121.45,3.41 118.91,5.95 111.55,5.95 108.26,9.25 95.61,9.25 93.4,7.04 87.88,7.04 84.83,10.08 68.75,10.08 65.77,13.07 63.43,13.07 62.35,12 48.35,12 47.19,13.16 v2(45.52,13.16)
  BOTTOM w0.112: JAUDIO.5 40.56,14.36 41.02,13.89 41.15,13.89 41.79,13.25 42.17,13.25 42.66,13.74 43.53,13.74 43.53,13.73 44.81,13.73 44.81,13.74 44.93,13.74 v2(45.52,13.16)
BGATE_CHG:
  vias: v1(203.36,134.96)
BKOFF#: length 213.7
  TOP w0.112: v2(303.37,31.78) v1(302.77,31.78) 302.49,31.49 302.49,26.54 302.34,26.39 UE5.105
  IN2 w0.104: v2(174.69,124.95) 174.69,124.57 188.08,111.19 188.08,108.68 190.89,105.87 190.89,105.5 193.97,102.42 211.63,102.42 212.61,101.44 237.14,101.44 237.64,100.94 253.98,100.94 254.57,100.35 258.89,100.35 263.82,95.42 263.82,86.68 266.15,84.35 266.15,82.07 264.63,80.54 v2(263.11,80.54)
  IN3 w0.104: v2(263.11,80.54) 263.11,80.35 259.24,76.48 259.24,72.8 260.87,71.17 262.13,71.17 262.33,70.97 269.75,70.97 270.33,70.39 276.25,70.39 276.78,69.85 279.4,69.85 279.7,70.15 282.04,70.15 282.57,69.62 283.56,69.62 284.2,68.98 284.62,68.98 285.51,68.09 285.53,68.09 287.23,66.39 289.52,66.39 291.78,64.13 292.05,64.13 293.03,63.16 293.03,61.3 295.57,58.75 295.57,56.43 295.77,56.23 295.77,54.54 295.23,54 295.23,52.79 295.88,52.14 295.88,42.44 297.71,40.6 298.16,40.6 298.33,40.42 298.33,36.42 302.98,31.78 v2(303.37,31.78)
  BOTTOM w0.112: JDGFF1.A5 175.47,125.11 175.31,124.95 v2(174.69,124.95)
BMON_CHG: length 2.3
  TOP w0.203: PR775.2 210.29,142.14 210.08,141.93 210.08,141.54 209.52,140.98 PU703.7
BOARD_ID: length 17.4
  TOP w0.089: UH1.BA20 282.52,60.91 v2(282.4,61.04)
  TOP w0.112: v2(285.58,73.98) 285.04,73.98 284.46,74.56 RH21.1
  IN2 w0.104: v2(282.4,61.04) 282.4,61.57 285.51,64.68 285.51,65.11 285.77,65.37 285.77,66.69 285.62,66.85 285.62,68.31 285.27,68.66 285.27,73.67 v2(285.58,73.98)
  BOTTOM w0.112: v2(282.4,61.04) v1(282.4,61.54)
BOOT_1.2V: length 1.4
  TOP w0.112: 217.71,120.36 216.88,120.36 v1(216.5,120.74)
BST1_ISL95338_1:
  vias: v1(123.03,145.22)
BST1_ISL95338_2:
  vias: v1(145.19,142.58)
BST1_R_ISL95338_1: length 1.1
  BOTTOM w0.112: v1(119.98,143.79) 120.07,143.88 PRS04.2
BST1_R_ISL95338_2: length 1.2
  BOTTOM w0.112: PCS51.1 v1(142.02,142.07)
BST2_3V: length 1.1
  TOP w0.112: PC310.2 v1(330.55,42.68)
BST2_5V: length 1.6
  TOP w0.112: PR308.2 327.51,33.75 v1(326.99,33.23)
BST2_+1VALWP: length 1.3
  TOP w0.112: PR102.2 v1(269.76,10.51)
BST2_ISL95338_1: length 1.2
  BOTTOM w0.112: PCS26.1 v1(127.72,141.2)
BST2_R_ISL95338_1: length 1.1
  BOTTOM w0.112: 126.58,139.72 v1(127.66,139.72)
BST2_R_ISL95338_2:
  vias: v1(150.27,137.88)
BST2_VCCIO: length 1.1
  BOTTOM w0.112: PRF03.2 v1(149.95,111.91)
BST_1.2V: length 1.6
  TOP w0.112: v1(216.63,122.26) 217.49,121.4 PR200.1
BST_3V: length 1.5
  TOP w0.112: PR309.2 327.37,41.36 v1(327.05,41.68)
BST_5V: length 1.6
  TOP w0.112: v1(327.05,34.63) 327.58,35.15 PR308.1
BST_+1VALWP: length 2.1
  TOP w0.112: PR102.1 267.07,10.97 v1(268.25,12.15)
BST_CHG:
  vias: v1(203.97,137.63)
BST_CHG_R: length 2.6
  TOP w0.112: PC721.1 201.29,138.81 200.84,139.25 199.79,139.25 v1(199.33,139.71)
BST_VCCIO: length 2.8
  BOTTOM w0.112: PRF03.1 152.5,112.1 151.98,112.61 151.03,112.61 v1(150.4,113.24)
BST_VCCSA: length 1.3
  BOTTOM w0.112: PRA03.2 v1(132.52,113.21)
BST_VCCSA_R: length 1.3
  BOTTOM w0.112: PRA03.1 v1(133.92,113.21)
BT_OFF#: length 158.6
  TOP w0.089: UH1.BA24 v2(280.74,61.24)
  TOP w0.112: RH706.2 v2(350.75,50.18) 350.89,50.32 DN2.1
  IN3 w0.104: v2(342.22,30.21) 342.88,30.87 342.88,40.67 347.93,45.72 350.13,45.72 350.75,46.35 v2(350.75,50.18) ; v2(280.74,61.24) 281.08,61.24 282.43,62.58 285.07,62.58 285.67,61.98 286.22,61.98 286.43,62.19 286.97,62.19 287.36,61.79 287.36,61.26 287.16,61.06 287.16,60.1 288.7,58.57 288.7,57.87 289,57.57 289.74,57.57 291.07,56.23 291.07,53.68 289.58,52.19 289.58,51.33 289.89,51.01 289.89,49.8 288.95,48.85 288.95,47.59 289.33,47.2 289.8,47.2 290.3,46.71 290.3,46.37 290.03,46.1 288.89,46.1 288.27,45.49 288.27,44.44 289.43,43.28 289.43,36.25 291.58,34.11 293.31,34.11 295.08,32.34 295.46,32.34 295.46,32.34 297.17,32.34 300.04,29.47 300.5,29.47 301.34,28.63 302.37,28.63 303.76,27.25 304.79,27.25 307.15,24.88 309.98,24.88 311.75,23.11 311.75,22.89 314.5,20.15 327.87,20.15 328.96,21.24 330.67,21.24 331.06,21.24 333.73,23.9 337.08,23.9 338.85,22.13 343.08,22.13 344.71,20.5 346.36,20.5 346.57,20.71 347.1,21.24 347.1,24.31 346.89,24.52 346.89,25.13 v2(347.88,26.12)
  IN4 w0.084: v2(347.88,26.12) 345.34,28.66 344.83,28.66 343.28,30.21 v2(342.22,30.21)
  BOTTOM w0.127: RH517.2 286.49,70.57 284.7,68.78 284.7,66.79 282.39,64.48 282.39,63.71 v1(282.09,63.41) 281.24,62.56 281.24,61.73 v2(280.74,61.24)
BT_OFF#_R: length 17.7
  TOP w0.112: DN2.2 349.41,50.32 348.96,50.76 347.31,50.76 v1(345.41,48.85) 342.36,48.85 v2(341.66,48.16)
  BOTTOM w0.112: JWLAN.54 341,46.1 341.66,46.76 v2(341.66,48.16)
BUSPOWER#: length 6.4
  BOTTOM w0.076: UT4.F10 45.89,47.07 46.13,47.31 47.36,47.31
  BOTTOM w0.112: 47.36,47.31 47.76,47.71 48.23,47.71 48.57,47.37 RT131.2 RT130.2 48.98,48.09 49.31,48.41 50.58,48.41 v1(50.83,48.16)
CALDERA_ON: length 328.6
  TOP w0.112: UE5.49 299.54,9.04 299.73,8.84 299.73,8.39 299.3,7.96 v2(299.3,7.83) ; JCDRA.1 180.5,191.02 v2(181.19,190.33) 182.27,189.25 RM41.2 182.92,188.3 183.73,188.3 183.93,188.5 UM7.2
  IN2 w0.104: v2(261.75,89.13) 262.31,89.68 262.31,94.97 258.32,98.97 253.99,98.97 253.41,99.55 237.06,99.55 236.56,100.05 212.04,100.05 211.06,101.04 198.28,101.04 197.55,100.31 195.67,100.31 195.17,100.8 189.05,100.8 184.99,104.86 184.99,108.79 180.7,113.09 180.7,114.46 168.95,126.21 168.95,140.2 161.16,147.99 161.16,160.77 163.26,162.87 163.26,167.17 162,168.43 162,173.09 167.72,178.81 167.72,185.16 170.84,188.28 178.82,188.28 180.88,190.33 v2(181.19,190.33)
  BOTTOM w0.112: v2(299.3,7.83) 299.3,7.14 298.64,6.48 296.56,6.48 292.29,2.2 283.59,2.2 280.2,5.59 v1(280.2,6.31) 280.2,6.48 278.15,8.53 278.15,9.79 277.05,10.88 276.79,10.88 276.09,11.59 276.09,12.9 275.05,15.4 275.05,19.04 272.25,21.84 267.53,21.84 265.29,24.08 265.29,28.01 260.07,33.23 260.07,35.37 257.6,37.84 257.6,49.47 258.2,50.07 258.2,51.58 256.21,53.58 256.21,81.49 259.63,84.91 259.63,87 v2(261.75,89.13)
CALDERA_PRSNT#: length 436.9
  TOP w0.112: JCDRA.21 171.75,193.15 171.79,193.19 171.79,194.02 172.54,194.77 v2(172.54,195.22) ; v2(303.07,7.89) 302.66,8.3 302.66,8.72 302.34,9.04 UE5.56
  TOP w0.127: UE1.22 v2(355.55,32.61)
  IN1 w0.084: v2(355.55,32.61) 355.13,32.19 355.13,22.19 354.58,21.65 354.58,20.91 v2(352.27,18.6) ; v2(172.54,195.22) 177.7,195.22 180.56,192.36 180.56,188.23 179.12,186.79 179.12,185.77 179.95,184.94 179.95,183 180.94,182.01 v2(180.94,179.92)
  IN2 w0.104: v2(262.78,84.8) 262.78,95.16 258.51,99.43 254.19,99.43 253.6,100.02 237.26,100.02 236.76,100.51 212.23,100.51 211.25,101.5 198.09,101.5 197.36,100.77 195.86,100.77 195.36,101.27 189.24,101.27 185.57,104.94 185.57,108.87 181.16,113.28 181.16,114.65 169.41,126.4 169.41,140.39 162.32,147.48 162.32,149.97 161.62,150.67 161.62,160.58 163.72,162.68 163.72,167.36 162.46,168.62 162.46,172.87 168.18,178.6 168.18,184.96 170.74,187.52 176.89,187.52 180.94,183.48 v2(180.94,179.92)
  IN3 w0.104: v2(303.07,7.89) 303.57,7.39 306.86,7.39 308.96,9.49 340.27,9.49 340.99,8.76 343.82,8.76 v2(344.48,9.42)
  BOTTOM w0.112: v2(344.48,9.42) 344.65,9.59 344.65,11.66 349.87,16.88 351.38,16.88 352.27,17.77 v2(352.27,18.6) ; v2(180.94,179.92) 180.25,179.92 179.92,179.59 RM61.1 ; RM5.2 v2(172.54,195.22) ; v2(262.78,84.8) 262.78,83.09 261.15,81.46 261.15,73.72 261.06,73.63 261.06,71.32 260.5,70.76 260.5,67.89 259.7,67.1 259.7,63.2 260.72,62.19 260.72,61.05 260.82,60.95 260.82,58.83 260.04,58.05 260.04,57.21 259.06,56.23 259.06,53.43 260.13,52.36 260.13,49.27 259.51,48.65 259.51,38.67 262.09,36.09 262.09,33.91 267.61,28.39 269.46,28.39 276.43,21.42 283.48,21.42 285.51,19.39 285.51,18.79 286.23,18.07 286.23,14.78 285.43,13.98 285.43,12.06 283.53,10.17 283.53,9.05 282.08,7.6 282.08,6.07 284.09,4.07 289.65,4.07 291.1,5.52 v1(291.24,5.52) 292.59,6.87 292.59,8.75 294.03,10.19 301.71,10.19 302.66,9.24 302.66,8.3 v2(303.07,7.89)
CALDERA_PWRGD: length 343.8
  TOP w0.112: v2(298.1,8.34) 298.34,8.58 UE5.46 ; JCDRA.2 179.7,193.35 179.92,193.57 181.38,193.57 v2(183.06,191.89) 184.81,190.14 185.38,190.14 185.62,189.9 RM42.1
  IN2 w0.104: v2(183.06,191.89) 184.14,191.89 188.05,187.98 188.05,181.59 190.95,178.69 190.95,178.33 191.38,177.9 191.38,177.42 192.31,176.49 192.31,173.31 191.61,172.62 191.61,167.41 192.97,166.04 193.54,166.04 193.64,165.94 193.64,162.89 195.82,160.71 205.79,160.71 205.9,160.6 205.9,147.66 v2(205.99,147.56)
  IN3 w0.104: v2(259.7,74.38) 259.7,75.92 260.76,76.99 269.51,76.99 272.09,79.56 275.04,79.56 276.81,81.33 277.62,81.33 278.63,82.34 278.63,85.69 276.62,87.71 276.62,97.26 275.99,97.89 275.99,102.75 270.04,108.7 263.53,108.7 259.73,112.5 237.53,112.5 236.6,111.57 233.32,111.57 232.52,110.78 220.2,110.78 219.74,111.23 215.95,111.23 214.98,112.21 209.53,112.21 207.63,110.31 205.67,110.31 204.65,111.33 204.65,114.6 205.38,115.33 205.38,125.45 209.37,129.44 209.37,133.81 210.07,134.5 210.07,136.24 212.79,138.96 212.79,141.59 212.14,142.24 209.98,142.24 207.54,144.68 207.54,146.01 v2(205.99,147.56)
  BOTTOM w0.112: v2(298.1,8.34) 298.1,8.47 297.51,9.06 296.67,9.06 296.45,8.84 296.45,8.3 295.88,7.73 295.88,6.48 292.17,2.78 v1(289.43,2.78) 283.69,2.78 280.77,5.69 280.77,6.59 279.29,8.07 279.29,10.84 276.61,13.51 275.77,15.55 275.77,19.58 272.21,23.14 267.49,23.14 266.01,24.63 266.01,28.31 260.9,33.41 260.9,35.59 258.32,38.18 258.32,49.14 258.93,49.76 258.93,51.87 256.93,53.87 256.93,63.48 258.43,64.98 258.43,70.4 259.73,71.69 259.73,74.1 259.7,74.13 v2(259.7,74.38)
CALDERA_RST#: length 322.9
  TOP w0.112: v2(296.64,12.6) 297.94,11.3 UE5.45
  IN4 w0.084: v2(169.28,195.83) 169.28,191.3 169.05,191.07 169.05,186.95 171.73,184.27 171.73,175.97 170.89,175.14 169.94,175.14 168.99,174.19 168.99,171.63 166.72,169.36 166.72,168.43 166.01,167.73 165.65,167.73 165.07,167.14 165.07,156.13 168.8,152.39 170.32,152.39 172.49,154.56 179.64,154.56 182.56,151.64 182.56,144.39 183.62,143.33 183.62,126.59 182.16,125.14 182.16,113.12 185.34,109.95 213.12,109.95 213.72,110.55 214.69,110.55 214.97,110.26 226.15,110.26 228.24,108.17 239.91,108.17 240.81,109.07 247.51,109.07 248.46,108.12 249.68,108.12 250.24,107.56 268.34,107.56 299.18,76.71 299.18,74.8 302.99,70.99 302.99,70.75 304,69.74 304,60.95 306.74,58.21 306.74,44.55 301.98,39.79 301.98,31.89 303.43,30.44 303.43,26.38 305.27,24.53 305.27,22.44 305.1,22.27 304.25,22.27 v2(303.74,21.75)
  BOTTOM w0.112: RM6.2 169.03,196.8 UM3.1 v2(169.28,195.83) ; v2(303.74,21.75) 303.36,21.38 303.36,20.37 305.65,18.07 305.65,17.06 304.92,16.32 303.77,16.32 300.74,13.29 v1(299.69,13.29) 297.34,13.29 v2(296.64,12.6)
CCLIM_CHG: length 6.2
  TOP w0.112: PR752.2 v1(209.03,147.53)
  TOP w0.203: PU703.11 207.63,142.99 208.43,143.79 208.43,145.18 208.86,145.62 PR750.1
  TOP w0.254: PR750.1 PR752.2
CDR_BTN#: length 306.8
  TOP w0.112: UE5.125 294.34,21.79 296.19,19.94 296.19,18.41 295.29,17.51 295.29,17.03 294.84,16.58 v2(294.24,16.58) ; JCDRA.26 v2(169.75,193.57)
  IN2 w0.104: v2(264.57,82.07) 264.06,82.57 264.06,84.28 263.01,85.32 263.01,95.25 258.6,99.66 254.28,99.66 253.7,100.25 237.35,100.25 236.85,100.75 212.33,100.75 211.34,101.73 198,101.73 197.27,101 195.96,101 195.46,101.5 191.85,101.5 186.52,106.83 186.52,109.63 v2(182.59,113.56)
  IN4 w0.084: v2(169.75,193.57) 169.75,191.16 169.84,191.07 169.84,190.36 169.43,189.95 169.43,187.11 172.11,184.43 172.11,175.47 169.38,172.73 169.38,170.54 166.17,167.34 165.81,167.34 165.45,166.98 165.45,156.29 168.96,152.78 170.16,152.78 172.33,154.95 179.8,154.95 182.95,151.8 182.95,144.55 184.01,143.49 184.01,125.05 182.59,123.63 v2(182.59,113.56)
  BOTTOM w0.112: v2(169.75,193.57) 169.75,192.98 RM17.2 ; v2(294.24,16.58) 294.24,17.04 v1(294.08,17.21) 293.7,17.58 291.88,17.58 290.38,19.09 289.94,19.09 287.21,21.82 286.39,21.82 284.64,23.57 279.07,23.57 277.78,24.86 276.37,24.86 270.45,30.78 268.61,30.78 264.58,34.81 264.58,37.14 261.9,39.82 261.9,47.6 262.52,48.22 262.52,50.51 263.54,51.53 263.54,54.45 264.84,55.75 264.84,58.53 265.32,59.01 265.32,61.56 265.62,61.86 265.62,67.8 265.09,68.33 265.09,81.54 v2(264.57,82.07)
CDR_ON_ELC: length 303.3
  TOP w0.112: UM7.4 v2(183.28,187.76)
  TOP w0.127: UE1.21 352.95,33.11 352.83,33.23 v1(349.91,33.23) 349.3,33.23 v2(348.81,32.74)
  IN1 w0.084: v2(267.79,110.76) 276.62,101.94 279.6,101.94 281.96,99.57 281.96,96.56 291.4,87.12 291.4,81.04 292.33,80.11 292.33,77.18 293.1,76.41 293.1,73.11 300.52,65.69 300.52,64.91 302.18,63.25 302.18,63.05 303.03,62.21 303.03,60.81 307.45,56.39 322.03,56.39 324.32,55.44 332.69,52.9 335.29,52.9 336.11,52.07 336.11,51.12 336.55,50.68 338.08,50.68 339.18,51.78 347.88,51.78 349.03,50.62 349.03,49.4 348.98,49.34 348.98,40.42 350.27,39.13 350.27,35.9 349.04,34.67 349.04,34.44 348.81,34.21 v2(348.81,32.74)
  IN2 w0.104: v2(183.28,187.76) 182.53,187 181.51,187 181.4,186.9 181.4,181.86 181.63,181.63 181.63,179.7 180.88,178.95 180.88,175.22 177.76,172.11 177.24,172.11 176.65,171.52 176.65,161.53 177.03,161.15 179.74,161.15 181.28,159.61 181.28,155.8 185.33,151.75 185.33,138.89 186.14,138.07 186.14,130.13 189.47,126.8 189.47,120.56 192.06,117.98 196.77,117.98 200.94,113.8 246.99,113.8 247.74,113.05 266.23,113.05 267.79,111.48 v2(267.79,110.76)
CDR_TXRX_GOOD: length 323
  TOP w0.112: UM7.1 v2(184.58,189.73) ; v2(296.38,7.64) 296.38,8.49 295.94,8.93 UE5.40
  IN2 w0.104: v2(184.58,189.73) 184.14,190.17 182.61,190.17 182.27,189.82 180.7,189.82 178.92,188.05 170.94,188.05 167.95,185.06 167.95,178.69 162.23,172.97 162.23,168.53 163.49,167.27 163.49,162.77 161.39,160.68 161.39,148.09 169.18,140.3 169.18,126.31 180.93,114.55 180.93,113.18 185.34,108.78 185.34,104.84 189.14,101.04 195.27,101.04 195.77,100.54 197.46,100.54 198.19,101.27 211.15,101.27 212.14,100.28 236.66,100.28 237.16,99.78 253.5,99.78 254.09,99.2 258.41,99.2 262.55,95.06 262.55,89.13 v2(261.74,88.32)
  BOTTOM w0.112: v2(296.38,7.64) 296.38,6.63 292.19,2.44 283.69,2.44 280.53,5.59 280.53,6.49 279.05,7.97 279.05,9.62 v1(278.95,9.72) 278.95,10.83 276.41,13.37 275.53,15.5 275.53,19.23 272.44,22.32 267.73,22.32 265.77,24.28 265.77,28.21 260.55,33.43 260.55,35.61 258.08,38.08 258.08,49.27 258.69,49.89 258.69,51.77 256.69,53.78 256.69,65.64 258.19,67.14 258.19,70.5 259.49,71.79 259.49,72.82 259.06,73.25 259.06,84 259.87,84.81 259.87,86.45 v2(261.74,88.32)

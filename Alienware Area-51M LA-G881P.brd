# Allegro board Alienware Area-51M LA-G881P.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
XDP_TDO: length 336.8
  TOP w0.089: v2(294.87,55) 294.87,55.25 294.52,55.6 294.18,55.6 293.44,54.86 291.72,54.86 291.51,54.65 UH1.AH3
  TOP w0.112: RH627.2 123.74,85.66 v2(123.87,85.8) v3(124.54,85.8) ; v2(59.31,46.95) 59.39,46.87 JPCMC.35
  IN1 w0.084: v2(59.31,46.95) 59.31,47.56 59.84,48.09 60.86,48.09 60.89,48.06 62.91,48.06 63.7,47.27 65.63,47.27 67.46,49.1 82.4,49.1 83.27,49.1 96.74,62.57 98.17,62.57 103.74,68.14 103.74,77.1 103.8,77.15 103.8,77.15 109.6,82.95 109.6,89.84 110.94,91.18 111.22,91.18 121.85,91.18 124.48,88.54 124.48,86.41 v2(123.87,85.8)
  IN2 w0.102: v2(137.38,71.27) 137.02,71.27 136.92,71.37 136.92,75.09 136,76.01 136,81.29 132.5,84.79 129.82,84.79
  IN2 w0.104: 129.82,84.79 126.01,84.79 125,85.8 v2(123.87,85.8)
  IN4 w0.084: 139.97,88.26 141.17,89.45 152.64,89.45 158.17,94.97 163.61,94.97 165.62,96.98 180.35,96.98 181.89,98.53 185.18,98.53 185.83,97.87 204.05,97.87 204.71,98.53 209.55,98.53 210.22,97.86 229.66,97.86 230.24,98.44 246.28,98.44 246.75,97.97 258.31,97.97 260.22,96.06 265.7,96.06 271.78,89.99 271.78,87.55 274.83,84.49 275.65,84.49 275.89,84.26 275.89,83.18 278.83,80.24 280.72,80.24 281.13,79.82 283.12,79.82 290.39,72.54 290.39,69.29 291.95,67.74 291.95,67.63 293.11,66.48 293.11,63.56 292.98,63.44 292.98,59.89 294.38,58.49 294.38,57.6 294.83,57.16 294.83,56.17 294.65,55.99 294.65,55.47 294.87,55.25 v2(294.87,55)
  IN4 w0.102: v2(137.38,71.27) 136.77,71.88 136.77,81.15 137.21,81.59 137.21,85.5 139.97,88.26
  BOTTOM w0.102: v2(137.38,71.27) 137.25,71.27 UC1.H13
XDP_TMS: length 341.7
  TOP w0.089: UH1.AJ4 290.96,55.35 291.29,55.35 291.4,55.25 293.29,55.25 293.92,55.88 294.02,55.98 294.97,55.98 295.1,56.12 295.41,56.12 295.65,55.88 v2(296.83,55.88)
  TOP w0.102: RH103.2 140.56,71.97 140.12,71.53 138.73,71.53 138.61,71.65 v3(136.59,71.65) 135.03,71.65 v2(134.58,71.21)
  TOP w0.112: JPCMC.30 57.82,44.48 v2(57.68,44.35)
  IN1 w0.084: v2(57.68,44.35) 57.68,44.78 57.5,44.96 57.5,47.29 60.15,49.94 82.75,49.94 82.92,49.94 96.39,63.41 97.82,63.41 102.9,68.49 102.9,77.45 102.95,77.5 102.95,77.5 108.75,83.3 108.75,90.19 110.59,92.02 110.87,92.02 122.2,92.02 122.69,91.53 122.69,91.53 125.13,89.09 126.69,89.09 128,87.78 131.21,87.78 v2(131.34,87.65)
  IN4 w0.084: v2(296.83,55.88) 296.82,55.89 296.82,63.27 296.21,63.89 296.21,68.71 293.45,71.47 293.2,71.72 293.2,74.22 284.39,83.03 282.1,83.03 281.43,83.71 280.39,84.75 278.98,84.75 274.79,88.93 274.79,92.6 268.97,98.43 261.2,98.43 259.29,100.33 247.93,100.33 247.46,100.8 229.26,100.8 228.68,100.22 211.2,100.22 210.52,100.9 203.73,100.9 203.07,100.23 193.69,100.23 193.02,100.9 180.9,100.9 179.34,99.35 164.56,99.35 162.58,97.36 157.21,97.36 151.66,91.81 134.99,91.81 131.34,88.17 v2(131.34,87.65) 131.34,84.99
  IN4 w0.102: v2(134.58,71.21) 134.58,71.32 134.15,71.75 133.72,71.75 133.11,72.36 133.11,73.46 132.32,74.25 132.32,74.87 131.34,75.85 131.34,84.99
  BOTTOM w0.102: UC1.F13 135.03,71.66 v2(134.58,71.21)
XMP1: length 121.9
  TOP w0.089: v2(267.9,50.07) 267.97,50 269.03,50 269.29,49.73 269.63,49.73 269.76,49.87 UH1.V47
  TOP w0.112: v2(219.99,104.67) 219.19,105.47 219.19,107.38 218.47,108.1 v1(218.47,110.45) 218.47,111.02 218.32,111.16 PR212.1
  IN1 w0.084: v2(267.9,50.07) 268.99,50.07 270.06,51.14 271.01,51.14 v2(271.57,51.7)
  IN2 w0.104: v2(271.57,51.7) 271.57,52.2 272.85,53.48 272.85,53.7 273.8,54.65 273.98,54.65 274.39,55.05 274.39,56.09 274.74,56.45 274.74,59.88 274.29,60.34 274.29,62.68 274.87,63.27 274.87,66.84 275.31,67.27 275.31,70.84 276.25,71.79 276.25,74.06 275.59,74.73 275.59,77.09 273.74,78.94 273.74,84.12 274.14,84.51 274.14,97.66 268.12,103.68 250.68,103.68 250.08,104.28 238.28,104.28 237.78,104.78 222.77,104.78 222.2,104.21 220.45,104.21 v2(219.99,104.67)
XMP1-1: length 3.6
  TOP w0.112: PR212.2 217.39,109.5 v1(217.64,109.24)
  TOP w0.254: 216.61,109.49 PC217.1 ; 216.61,109.49 PR216.1 216.61,110.25 PR212.2 ; 216.61,109.49 216.6,109.5 PQ202.2
XMP1-2: length 4.3
  TOP w0.112: v1(213.33,107.72) 213.33,108.54 213.63,108.85 PQ202.6
  TOP w0.254: PQ202.6 214.08,108.85 214.47,109.24 214.47,109.46 214.95,109.94 214.95,109.98 215.02,110.05 PR213.2
XMP2: length 129.1
  TOP w0.089: UH1.V48 269.27,50.19 268.63,50.19 v2(268.31,50.51)
  TOP w0.112: PR214.1 211.59,111.97 210.95,111.34 210.95,107.36 v1(211.16,107.15) 213.21,105.1 v2(213.39,105.1)
  IN1 w0.084: v2(271.43,52.89) 270.58,52.04 269.7,52.04 268.31,50.65 v2(268.31,50.51)
  IN2 w0.104: v2(213.39,105.1) 213.45,105.1 213.51,105.04 218.36,105.04 219.41,103.98 222.3,103.98 222.87,104.55 237.54,104.55 238.64,103.45 268.03,103.45 273.91,97.57 273.91,84.61 273.51,84.21 273.51,78.84 274.63,77.72 274.63,75.36 276.02,73.97 276.02,71.88 275.01,70.87 275.01,67.3 274.64,66.93 274.64,63.37 274.05,62.78 274.05,60.24 274.51,59.78 274.51,56.54 274.16,56.19 274.16,55.15 273.88,54.88 273.7,54.88 272.62,53.8 272.62,53.58 271.93,52.89 v2(271.43,52.89)
XMP2-1: length 8.2
  TOP w0.254: PQ202.5 213.6,109.5 PR217.1 211.48,108.73 211.29,108.92 v1(211.29,109.88) 211.29,111.02 211.6,111.33 PC218.1 213.98,111.33 PR214.2
XMP2-2: length 3.8
  TOP w0.112: PQ202.3 215.6,110.15 214.79,109.34 214.79,107.91 v1(214.66,107.78)
  TOP w0.254: PR215.2 215.79,110.26 PQ202.3
XTAL24_IN: length 9
  TOP w0.089: v2(294.86,48.75) 294.29,48.75 293.81,49.23 292.79,49.23 292.77,49.25 292.73,49.25 292.67,49.3 292.11,49.3 291.92,49.12 291.09,49.12 290.93,49.28 290.33,49.28 290.26,49.21 289.05,49.21 288.77,48.94 288.35,48.94 287.79,49.49 UH1.U10
  BOTTOM w0.112: RH91.2 295.22,48.45 294.92,48.75 v2(294.86,48.75)
XTAL24_IN_R: length 4.9
  BOTTOM w0.112: YH2.1 297.84,48.57 297.69,48.57 RH72.1 297.78,48 297.78,47.85 297.66,47.73 297.29,47.73 297.27,47.71 297.11,47.71 296.95,47.87 296.73,47.87 296.58,48.02 CH47.1 296.38,48.35 295.9,47.87 RH91.1
XTAL24_OUT: length 8.6
  TOP w0.089: v2(294.98,49.38) 294.98,49.41 294.89,49.5 294.67,49.5 294.58,49.41 294.58,49.03 294.49,48.94 294.37,48.94 294.28,49.03 293.89,49.42 292.87,49.42 292.85,49.44 292.81,49.44 292.75,49.49 292.08,49.49 291.98,49.6 291.41,49.6 291.33,49.68 291.28,49.68 291.22,49.62 291,49.62 290.87,49.5 290.28,49.5 290.18,49.4 288.97,49.4 288.7,49.13 288.55,49.13 288.45,49.23 UH1.U9
  BOTTOM w0.112: v2(294.98,49.38) 295.28,49.07 RH92.2
XTAL24_OUT_R: length 5.3
  BOTTOM w0.112: YH2.3 299.32,48.98 298.03,48.98 297.76,49.25 RH72.2 297.4,49.2 CH48.1 296.57,49.2 296.2,49.56 296.18,49.56 296.09,49.66 RH92.1
N12479061: length 3
  TOP w0.112: v1(351.32,33.73) RE651.2 352.38,33.61 UE1.20
N12535590: length 3.6
  TOP w0.112: UC2.4 174.38,30.04 174.62,29.8 174.97,29.8 175.06,29.72 v1(175.06,29.36) 174.72,29.36 174.69,29.39 RH525.2 173.35,29.39 RC684.2
N12536906: length 43.8
  TOP w0.112: v2(169.38,30.57) 169.38,32.47 173.19,36.28 175.28,36.28 v1(176.24,35.33) 176.81,34.76 RC356.2
  BOTTOM w0.102: 151.37,39.31 151.37,43.92 151.82,44.38 151.82,46.27 UC1.AC38
  BOTTOM w0.127: v2(169.38,30.57) 167.86,29.04 161.63,29.04 151.37,39.31
N12705199: length 1.8
  TOP w0.112: RD56.2 v1(217.97,71.03)
  TOP w0.127: CD130.2 RD56.2
N13311446: length 1.6
  TOP w0.112: CL90.1 190.03,165.19 189.85,165.19 189.59,165.45 189.51,165.45 189.45,165.51 UL1.2
N13311484: length 2.7
  TOP w0.112: UL1.6 189.68,167.11 189.81,166.98 190.17,166.98 190.45,167.26 CL121.1 CL91.1
N13311522: length 2.7
  TOP w0.112: UL1.11 189.27,169.11 189.28,169.1 190.19,169.1 190.35,169.26 CL92.1 CL122.1
N13311576: length 2.6
  TOP w0.112: UL1.13 189.35,169.91 189.39,169.95 190.16,169.95 190.27,169.84 CL93.1 CL123.1
N13311596: length 2.7
  TOP w0.112: UL1.18 189.64,171.91 189.67,171.88 189.81,171.88 189.85,171.85 190.22,171.85 190.42,172.04 CL94.1 CL124.1
N13311632: length 3.9
  TOP w0.112: UL1.22 189.16,173.51 189.55,173.9 CL95.1 189.55,176.15 CL125.1
N13311710: length 4.9
  TOP w0.112: v1(183.48,161.95) 183.38,162.05 CL97.1 CL127.1 181.8,162.18 182.27,162.65 182.68,162.65 183.59,163.56 UL1.77
N13311746: length 2.4
  TOP w0.112: UL1.85 186.79,163.6 186.78,163.58 186.78,163.16 187.67,162.27 CL98.1
N13313839: length 2.4
  TOP w0.254: UL1.82 185.59,163.9 185.61,163.88 185.61,163.76 185.68,163.69 185.68,163.63 185.71,163.6 185.71,163.53 185.81,163.43 185.81,163.05 v1(185.78,163.03) 185.78,162.97 185.56,162.75 RL11.2
N13314155: length 2.5
  TOP w0.254: UL1.69 180.39,163.72 v1(179.78,163.11) 179.42,162.74 RL14.2
N13562288: length 5.2
  TOP w0.112: v2(177.32,166.27) 177.67,165.91 UL1.64
  BOTTOM w0.112: v1(178.02,164.17) 178.02,164.63 178.32,164.93 CL129.1 CL99.1 178.08,165.5 v2(177.32,166.27)
N16550351: length 1
  BOTTOM w0.254: PC779.1 v2(193.7,142.31)
  vias: v3(190.91,145.51)
N16606246: length 55.9
  TOP w0.254: PQS27.1 158.78,156.93 159.22,157.38 162.59,157.38 164.62,155.34 164.62,149.88 161.56,146.82 158.6,146.82 157.89,147.53 157.89,148.03 157.64,148.29 157.07,148.29 156.78,147.99 v2(156.78,147.82)
  IN3 w0.254: v2(156.78,147.82) 156.78,147.81 156.53,147.56 142.24,147.56 140.93,148.87 131.09,148.87 130.2,147.98 130.2,144.58 v2(131.19,143.6)
  vias: v1(130.14,142.61) v2(131.22,143.03) v2(131.22,142.47) v2(131.41,141.76) v2(131.41,141.17) v2(131.41,140.59) v2(131.41,140) v2(131.41,139.42) v2(131.42,138.83) v2(131.56,135.94) v2(131.77,143.6) v2(131.8,143.03) v2(131.86,142.45) v2(131.94,141.47) v2(131.94,140.88) v2(131.94,140.3) v2(131.94,139.71) v2(131.86,136.43) v2(131.98,138.86) v2(132.04,138.26) v2(132.04,137.68) v2(132.04,137.09) v2(132.33,135.85) v2(132.36,143.6) v2(132.38,143.03) v2(132.44,136.47) v2(132.45,142.44) v2(132.54,141.76) v2(132.57,139.48) v2(132.57,138.9) v2(132.63,138.26) v2(132.63,137.68) v2(132.63,137.09) v2(132.94,143.6)
N16611457: length 40.1
  TOP w0.112: v3(107.34,154.1) 107.4,154.15 108.27,154.15
  IN1 w0.254: v2(141.82,163.6) 141.82,162.11 139.45,159.74 111.84,159.74 111,158.9 v2(111,154.91)
  BOTTOM w0.254: PQS26.1 142.46,163.18 142.04,163.6 v2(141.82,163.6)
  vias: v2(108.43,148.69) v2(108.43,148.11) v2(108.43,147.52) v2(108.43,146.84) v2(108.43,146.25) v2(108.8,154.9) v2(108.8,154.26) v2(108.8,153.63) v2(108.8,152.99) v2(108.8,152.36) v2(108.8,151.6) v2(109.54,154.91) v2(109.54,154.28) v2(109.54,153.64) v2(109.56,152.99) v2(109.56,152.36) v2(109.56,151.6) v2(110.3,154.91) v2(110.3,154.28) v2(110.3,153.64) v2(110.32,152.99) v2(110.32,152.36) v2(110.32,151.6) v2(111,154.29) v2(111.06,153.64) v2(111.09,152.99) v2(113.73,149.44) v2(113.73,148.81) v2(114.41,149.44) v2(114.43,148.84)
N16639315: length 0.7
  TOP w0.508: PQS10.4 115.44,168.27 v2(115.38,168.32)
  vias: v3(115.76,170.39)
N16640057: length 3.4
  BOTTOM w0.112: v1(113.25,168.83) 113.1,168.83 112.86,169.07 PRS60.1
  BOTTOM w0.254: PRS60.1 112.28,169.06 PRS63.2 111.53,169.11 PQS12.2
N16641333: length 2.8
  BOTTOM w0.112: v3(111.44,163.18) PRS58.2
  BOTTOM w0.254: PRS58.2 111.44,165.24 PQS13.5 PQS13.6
N16644305: length 4.7
  BOTTOM w0.112: PRS57.2 114.35,166.6 v3(114.62,166.33)
  BOTTOM w0.254: PRS62.1 111.48,167.2 PQS13.2 111.49,166.88 111.78,166.58 113.23,166.58 PRS57.2
N16645109: length 2.3
  BOTTOM w0.112: PRS60.2 112.69,168.16 v1(113.31,167.54)
  BOTTOM w0.254: PQS13.3 112.29,167.34 PRS60.2
N16647112: length 8
  TOP w0.254: v2(137.22,154.61) 137.22,154.16 PQS15.4
  BOTTOM w0.112: v1(141.62,154.77) PQS16.1
  BOTTOM w0.254: PQS16.1 140.28,152.96 139.93,153.31 PRS67.2 138.38,153.31 PCS70.2 137.9,153.79 PRS68.1 137.65,154.61 v2(137.22,154.61)
N16647166: length 3.6
  BOTTOM w0.112: v1(144.3,153.06) 143.95,152.71 PRS70.2
  BOTTOM w0.254: PQS16.2 143.66,150.87 PRS64.1 144.02,151.98 PRS70.2
N16647194: length 3.8
  BOTTOM w0.112: PQS17.6 146.14,151.53 146.33,151.72 v1(146.33,152.8)
  BOTTOM w0.254: PQS17.6 145.31,151.53 145.25,151.47 145.07,151.47 PRS66.2 145.16,150.88 PQS17.5
N16647286: length 2.8
  BOTTOM w0.112: PRS69.2 v1(150.39,150.82)
  BOTTOM w0.254: PRS69.2 PRS65.1 148.49,150.88 PQS17.2
N16647302: length 5.3
  BOTTOM w0.254: PRS64.2 144.02,149.31 144.36,148.97 146.04,148.97 v1(146.07,148.93) 147.38,150.23 PQS17.3
N16677573: length 109.1
  TOP w0.254: PR703.2 155.75,130.64 155.43,130.96 153.92,130.96 153.36,131.51 153.36,141.19 155.23,143.06 156.83,143.06 159.59,145.82 v1(162.02,145.82) 163.7,145.82 171.41,153.53 171.56,153.59 172.31,154.1 172.96,154.75 173.11,154.98 173.6,155.47 175.92,155.47 176.24,155.79 180.85,155.79 182.19,157.13 185.76,157.13 186.97,158.34 v2(187.42,158.34) ; PR772.1 208.94,131.68 v2(208.96,131.66)
  IN1 w0.254: v2(187.42,158.34) 187.65,158.58 187.65,159.78 189.54,161.66 205.15,161.66 207.7,159.11 207.7,150.69 209.99,148.4 209.99,143.13 211.07,142.05 211.07,137.84 208.96,135.73 v2(208.96,131.66)
N16677640: length 109.2
  TOP w0.254: v2(208.96,131.02) 208.87,131.02 208.18,131.72 PR740.1 ; v2(187.48,157.72) 186.89,157.72 185.92,156.75 182.35,156.75 181.01,155.41 176.4,155.41 176.08,155.09 173.84,155.09 173.36,154.61 172.56,153.81 172.31,153.64 172.31,153.64 171.64,153.19 171.61,153.19 163.79,145.37 v1(159.8,145.37) 159.68,145.37 156.99,142.68 155.39,142.68 153.75,141.04 153.75,131.67 154.08,131.34 155.49,131.34 155.75,131.6 PR703.3
  IN1 w0.254: v2(208.96,131.02) 208.87,131.02 208.46,131.44 208.46,131.94 208.56,132.04 208.56,135.91 210.65,138.01 210.65,141.88 209.57,142.96 209.57,148.23 207.46,150.35 207.46,150.39 207.32,150.53 207.32,158.96 205.03,161.25 189.66,161.25 188.05,159.64 188.05,158.29 v2(187.48,157.72)
N16690790:
  vias: v1(192.05,157.88) v2(191.86,156.69) v2(191.86,156.11) v2(191.86,155.52) v2(192.45,156.69) v2(192.45,156.11) v2(192.45,155.52) v2(193.03,156.69) v2(193.03,156.11) v2(193.03,155.52) v2(193.62,156.69) v2(193.62,156.11) v2(193.62,155.52) v2(202.98,159.7) v2(203.56,159.7) v2(204.14,159.7) v2(204.73,159.7) v2(204.96,158.85) v2(204.96,158.27) v2(204.96,157.67) v2(204.96,157.08) v2(204.96,156.5) v2(204.96,155.92) v2(204.96,155.34) v2(204.96,154.76)
N16716198: length 5.4
  TOP w0.112: v1(207.42,124.61) PD704.1
  TOP w0.254: PDS705.1 205.18,128.19 207.42,125.96 PD704.1
N16781018:
  vias: v2(135.98,119.02) v2(136.57,119.02) v2(137.15,119.02) v2(139.65,119.92) v2(139.65,118.86) v3(135.03,118.39)
N16782292: length 1.5
  BOTTOM w0.112: PRA04.2 v1(149.89,121.4)
N16788054: length 4.3
  BOTTOM w0.112: v1(129.25,110.45) 129.25,111.92 128.8,112.37 PRA17.1
  BOTTOM w0.254: PRA18.2 128.35,112.95 128.35,112.38 ; 128.35,112.38 PRA17.1 ; 128.35,112.38 PRA19.1
N16828896: length 6.9
  TOP w0.254: PR18.1 352.2,11.27 352.2,10.44 v1(351.88,10.12) 351.37,9.61 v2(351.06,9.61)
  BOTTOM w0.254: JRTC.1 348.2,10.56 348.45,10.82 349.85,10.82 v2(351.06,9.61)
N16828913: length 2.2
  TOP w0.112: v1(348.26,12.02) PD5.3
  TOP w0.254: PR15.2 349.44,12.87 PD5.3
N16829365: length 1.2
  TOP w0.112: PR28.1 v1(80.28,12.65)
N16856169: length 2.6
  TOP w0.112: v1(64.55,36.98) 64.06,36.5 PRZ44.1
  TOP w0.203: PUZ01.33 63.96,35.81 PRZ44.1
N16860465: length 3
  TOP w0.112: v1(251.64,14.03) DS1.1 253.67,14.03 253.71,14 QS3.1
N16862683: length 3.6
  TOP w0.112: PCI07.2 v1(102.55,33.46)
  TOP w0.254: v2(103.09,32.85) 102.6,32.37 PCI07.2
  BOTTOM w0.254: PUI01.3 103.45,33.06 103.24,32.85 v2(103.09,32.85) 103.09,32.73 102.73,32.37 PRI12.1
N16862697: length 1.4
  TOP w0.112: v1(110.39,30.44) 109.66,31.17 PCI17.1
N16862704: length 2.5
  TOP w0.112: v1(103.85,30.12) 104.25,30.52 v2(104.62,30.52)
  TOP w0.254: v2(104.62,30.52) 104.62,30.77 PRI14.1
  BOTTOM w0.254: PUI01.26 v2(104.62,30.52)
N16862707: length 4.1
  TOP w0.112: PRI11.2 v1(104.25,33.03)
  TOP w0.254: v2(105.62,30.5) 105.5,30.63 PCI06.1 104.95,31.74 104.71,31.74 104.39,32.05 PRI11.2
  BOTTOM w0.254: PUI01.24 v2(105.62,30.5)
N16862715: length 1.9
  BOTTOM w0.254: PUI01.2 103.49,32.56 103.09,32.15 103.09,32.03 102.64,31.58 PRI15.2
N16862717: length 4.1
  BOTTOM w0.112: v1(100.87,29.93) 101.25,30.31 102.01,30.31 102.45,30.75 PRI13.2
  BOTTOM w0.254: PUI01.1 103.68,32.06 103.02,31.39 103.02,31.06 102.77,30.81 PRI13.2
N16862746: length 1.6
  BOTTOM w0.112: v1(100.3,32.03) 100.3,32.8 100.89,33.39 PCI08.1
N16862747:
  vias: v2(103.03,34.82)
N16862749: length 1.6
  TOP w0.112: v1(101.69,34.5) 102.18,34.02 v2(103.09,34.02)
N16862782: length 2.9
  BOTTOM w0.254: PUI02.3 103.06,24.09 102.34,23.36 PCI19.2 102.34,22.52 PRI29.1
N16862802: length 3.4
  TOP w0.508: v2(107.31,20.74) 107.31,20.5 107.85,19.96 PRI35.2
  BOTTOM w0.112: PCI29.1 v1(107.96,19.15)
  BOTTOM w0.508: v2(107.31,20.74) 107.77,20.74 PCI29.1
N16862811: length 2.1
  BOTTOM w0.112: v1(99.91,23.07) 99.85,23.14 99.85,24.03 100.23,24.41 PCI20.1
N16862814:
  vias: v2(103.03,25.11)
N16862866: length 3.2
  BOTTOM w0.254: PUI02.2 103.13,23.59 102.88,23.33 102.88,22.11 102.5,21.73 PRI31.2
N16862869: length 4.3
  BOTTOM w0.112: PRI28.2 v1(102.37,19.85)
  BOTTOM w0.254: PUI02.1 103.58,23.09 103.35,22.86 103.35,21.81 102.49,20.95 PRI28.2
N16862875: length 2.2
  TOP w0.254: PRI30.1 104.67,21.66 v2(104.67,21.49)
  BOTTOM w0.112: v2(104.67,21.49) 104.87,21.49 v1(105.12,21.23)
  BOTTOM w0.254: v2(104.67,21.49) 104.83,21.64 PUI02.26
N16862877: length 4.3
  TOP w0.112: PRI27.2 v1(104.25,24.09)
  TOP w0.254: v2(105.69,21.49) 105.31,21.87 PCI18.1 104.62,22.86 PRI27.2
  BOTTOM w0.254: PUI02.24 105.83,21.63 v2(105.69,21.49)
N16868018: length 5.1
  BOTTOM w0.112: PCI36.2 103.86,58.51 v1(103.66,58.32)
  BOTTOM w0.254: PUI03.3 106.72,59.55 PRI54.1 105.49,59.39 104.64,59.39 104.59,59.33 PCI36.2
N16868027: length 1.9
  BOTTOM w0.254: PRI53.2 106.15,57.3 106.54,57.69 106.54,57.81 107.28,58.55 PUI03.1
N16868085: length 1.1
  BOTTOM w0.112: PRI57.1 v1(103.34,61.66)
N16868095: length 1.8
  BOTTOM w0.254: PRI56.2 106.14,58.07 106.53,58.47 106.53,58.59 106.99,59.05 PUI03.2
N16868135: length 4.2
  TOP w0.112: v1(105.06,57.62) 105.46,57.22 106.5,57.22 106.96,57.68 PRI55.1
  TOP w0.254: v2(107.66,57.05) 107.63,57.05 PRI55.1
  BOTTOM w0.254: PUI03.26 108.1,57.49 v2(107.66,57.05)
N16868151: length 4.2
  TOP w0.254: PCI35.1 106.96,58.48 PRI52.2 107.28,58.44 108.68,57.04 v2(108.87,57.04)
  BOTTOM w0.254: v2(108.87,57.04) 108.88,57.04 108.88,57.02 108.89,57.03 108.89,57.09 109.1,57.31 PUI03.24
N16872715: length 7
  BOTTOM w0.112: PRI69.1 103.66,71 v1(103.66,70.83)
  BOTTOM w0.254: PUI04.3 108.78,70.77 108.51,70.51 107.98,70.51 107.34,71.14 106.06,71.14 PCI48.2 104.49,71.83 PRI69.1
N16872720: length 2.6
  BOTTOM w0.254: PUI04.1 108.84,69.77 108.44,69.38 v1(108.23,69.38) 108.04,69.57 PRI68.2
N16872727: length 1.5
  TOP w0.112: PCI56.1 117.95,77.37 v1(117.54,77.78)
N16872751: length 1.5
  BOTTOM w0.112: v1(105.76,74.7) 106.33,74.13 PRI72.1
N16872754:
  vias: v1(108.23,70.95)
N16872755: length 1.5
  BOTTOM w0.112: v1(107.09,74.7) 107.09,74.45 107.73,73.81 PRI72.2
N16872756: length 4.6
  BOTTOM w0.112: PRI71.2 107.17,70.43 106.77,70.83 v1(105.25,70.83)
  BOTTOM w0.254: PUI04.2 108.82,70.27 108.67,70.13 107.74,70.13 107.53,70.34 PRI71.2
N16872763: length 5.3
  BOTTOM w0.112: PRI70.1 105.63,68.81 v1(105.25,68.43)
  BOTTOM w0.254: PUI04.26 109.99,68.78 107.12,68.78 107.09,68.81 PRI70.1
N16872771: length 4.2
  BOTTOM w0.254: PUI04.24 111.24,68.2 PCI46.1 110.6,67.74 v1(109.63,67.74) 108.48,67.74 PRI67.2
N16876688: length 3.3
  TOP w0.112: PCI63.2 102.55,41.46 v1(102.26,41.17)
  TOP w0.254: PCI63.2 102.91,42.23 103.03,42.11 v2(103.16,42.11)
  BOTTOM w0.254: PRI94.1 102.69,42.11 v2(103.16,42.11) 103.26,42.11 103.44,42.29 PUI05.3
N16876692: length 2.6
  BOTTOM w0.112: PRI93.2 v1(102.58,39.65)
  BOTTOM w0.254: PUI05.1 103.27,40.66 PRI93.2
N16876699: length 1.7
  TOP w0.112: PRI98.2 v1(110.81,40.7)
N16876717:
  vias: v1(99.98,44.73)
N16876720:
  vias: v2(103.09,43.33)
N16876722: length 1.5
  BOTTOM w0.254: PUI05.2 103.52,41.79 103.16,41.44 PRI96.2
N16876729: length 3.3
  TOP w0.112: PRI95.1 104.45,40.24 v1(103.47,39.27)
  TOP w0.381: PRI95.1 104.53,40.24 105,39.77 105.03,39.77 105.06,39.74 v2(105.08,39.74)
  BOTTOM w0.254: v2(105.08,39.74) 104.9,39.74 104.65,40 PUI05.26
N16876737: length 3.9
  TOP w0.112: PRI92.2 v1(104.45,42.22)
  TOP w0.254: PRI92.2 104.6,41.17 PCI62.1 105.68,40.09 v2(105.68,39.75)
  BOTTOM w0.254: PUI05.24 105.65,39.77 v2(105.68,39.75)
N16876803: length 3.2
  TOP w0.112: v1(103.79,51.08) 104.08,50.78 v2(104.51,50.78)
  TOP w0.254: v2(104.51,50.78) 105,50.78 PCI74.2
  BOTTOM w0.254: PRI109.1 104.35,50.94 v2(104.51,50.78) 104.63,50.66 PUI06.3
N16876807: length 4
  BOTTOM w0.112: v1(102.01,48.66) 103.66,48.66 103.87,48.87 PRI108.2
  BOTTOM w0.254: PRI108.2 103.99,49.37 104.27,49.66 PUI06.1
N16876814:
  vias: v1(114.01,56.54)
N16876832: length 1.3
  BOTTOM w0.112: PCI75.1 v1(101.31,51.96)
N16876837: length 1.5
  BOTTOM w0.254: PRI111.2 104.13,50.15 104.13,50.16 PUI06.2
N16876844: length 4.5
  TOP w0.112: v1(103.34,48.73) 103.68,48.39 104.79,48.39 105.25,48.85 PRI110.1
  TOP w0.254: PRI110.1 105.34,48.85 106.04,48.16 106.32,48.16 106.32,48.16 v2(106.31,48.16)
  BOTTOM w0.254: PUI06.26 106.1,48.38 106.32,48.16 v2(106.31,48.16)
N16876852: length 3.3
  TOP w0.254: PRI107.2 105.68,49.62 PCI73.1 106.79,48.5 106.79,48.24 v2(106.89,48.14)
  BOTTOM w0.254: v2(106.89,48.14) 106.9,48.14 106.9,48.16 107.1,48.36 PUI06.24
N16880226: length 5.9
  TOP w0.112: v2(131.06,13.54) v1(131.54,13.54)
  TOP w0.254: v2(128.67,13.51) 128.67,13.37 128.16,12.86 PCG01.2
  IN4 w0.254: v2(131.06,13.54) 131,13.59 130.64,13.95 128.95,13.95 128.68,13.68 128.68,13.52 v2(128.67,13.51)
  BOTTOM w0.254: PRG03.1 131.13,13.61 v2(131.06,13.54) ; PUG01.3 128.77,13.8 128.75,13.79 128.75,13.6 v2(128.67,13.51)
N16880230: length 2.1
  BOTTOM w0.254: PRG02.2 131.77,15.21 PCG02.1 131.77,16.02 PUG01.24
N16880234: length 1.5
  BOTTOM w0.112: PRG19.2 v1(163.29,15.77)
N16880256: length 1.8
  BOTTOM w0.112: PRG07.2 v1(136.61,12.54)
N16880306: length 3.1
  BOTTOM w0.112: PRG14.2 151.23,13.22 v1(151.29,13.17)
  BOTTOM w0.254: PUG02.1 149.22,14.27 149.49,14.01 149.85,14.01 150.15,13.7 PRG14.2
N16880310: length 4.5
  BOTTOM w0.112: v1(149.25,10.95) 148.87,11.33 148.87,13.1 148.99,13.22 PRG17.2
  BOTTOM w0.254: PUG02.2 148.72,14.17 149.05,13.84 149.05,13.83 149.37,13.51 PRG17.2
N16880314: length 3.4
  TOP w0.112: PCG13.2 v1(149.76,13.04)
  TOP w0.254: PCG13.2 148.63,13.55 v2(148.37,13.8)
  BOTTOM w0.254: PUG02.3 148.22,13.95 v2(148.37,13.8) 148.37,13.25 PRG15.1
N16880326: length 5.6
  BOTTOM w0.112: PRG13.2 153.94,14.9 154.46,14.37 v1(154.72,14.37)
  BOTTOM w0.254: PRG13.2 151.76,14.9 PCG12.1 150.8,15.86 150.8,15.87 150.36,16.32 PUG02.24
N16880463: length 3.7
  BOTTOM w0.112: PRG04.1 131.55,14.18 130.97,14.18 130.59,13.8 v1(130.59,13.04)
  BOTTOM w0.254: PUG01.26 130.89,15.02 131.54,14.37 PRG04.1
N16880475: length 4.4
  BOTTOM w0.112: PRG16.1 151.22,13.87 151.79,13.29 151.79,12.85 v1(152.3,12.34)
  BOTTOM w0.254: PUG02.26 150.42,15.32 150.71,15.03 150.71,14.25 150.83,14.13 PRG16.1
N16880496: length 4.4
  BOTTOM w0.112: v1(147.93,10.5) 147.93,12.34 147.3,12.96 PCG14.2
  BOTTOM w0.254: PUG02.5 147.22,13.18 PCG14.2
N16880498: length 1.5
  BOTTOM w0.254: PUG02.7 146.22,13.22 PRG18.2
N16880500: length 1.1
  BOTTOM w0.112: PRG18.1 v1(146.09,10.57)
N16884080: length 1.2
  BOTTOM w0.112: PRG06.1 v1(125.9,10.32)
N16884081: length 1.3
  BOTTOM w0.112: PCG03.2 v1(128.42,12.92)
N16884085: length 2
  TOP w0.112: v2(129.3,13.47) 129.3,13.59 v1(128.97,13.92)
  TOP w0.254: v2(129.3,13.47) 129.3,13.47 129.17,13.34 PRG05.2
  BOTTOM w0.254: v2(129.3,13.47) 129.3,13.5 129.27,13.54 PUG01.2
N16884088: length 2.1
  TOP w0.112: v2(129.98,13.46) 129.98,13.64 v1(130.27,13.93)
  TOP w0.254: PRG01.2 129.93,13.41 v2(129.98,13.46)
  BOTTOM w0.254: PUG01.1 129.77,13.75 129.98,13.54 v2(129.98,13.46)
N17251517: length 2.7
  TOP w0.112: v2(82.96,27.62) v1(82.36,27.62)
  TOP w0.254: v2(82.96,27.62) 83.62,27.62 PRI208.2
  BOTTOM w0.254: PUI07.7 82.97,27.61 v2(82.96,27.62) 82.56,27.62 PRI207.1
N17251525: length 4.4
  BOTTOM w0.112: v1(80.8,30) 80.8,28.79 80.97,28.62 81.93,28.62 82.33,28.21 PRI202.1
  BOTTOM w0.254: PUI07.8 82.38,28.11 PRI202.1
N17251539: length 2.4
  TOP w0.112: v2(87.59,27.9) v1(88.17,27.9)
  BOTTOM w0.254: PRI206.2 88.28,27.65 88.11,27.82 87.8,27.82 87.72,27.9 v2(87.59,27.9) 87.55,27.9 87.34,28.11 PUI07.3
N17251555: length 3.4
  BOTTOM w0.112: v1(88.13,30.22) PCI205.2
  BOTTOM w0.254: PUI07.2 87.67,28.61 87.91,28.36 PRI210.2 88.16,29.18 PCI205.2
N17251561: length 3.9
  TOP w0.112: PRI201.2 v1(88.14,30.34)
  TOP w0.254: PCI201.1 86.85,28.87 v2(87.46,29.49) 87.86,29.49 PRI201.2
  BOTTOM w0.254: PUI07.1 87.08,29.11 v2(87.46,29.49)
N17251581: length 4.3
  BOTTOM w0.112: v1(88.36,24.85) 87.64,25.57 PRI203.2
  BOTTOM w0.254: PUI07.5 87.05,27.11 87.41,26.75 PCI203.2 88.31,26.53 PRI203.2
N17251587: length 4
  TOP w0.112: PRI204.2 v1(88.31,25.72)
  TOP w0.254: PRI204.2 88.17,26.75 v2(87.65,27.26) 87.55,27.26 87.26,27.55 PCI202.1
  BOTTOM w0.254: v2(87.65,27.26) 87.56,27.26 87.32,27.5 87.31,27.5 87.21,27.61 PUI07.4
N17251605: length 2.6
  BOTTOM w0.112: PRI209.1 v1(83.24,31.33)
  BOTTOM w0.254: PUI07.10 83.46,29.11 83.24,29.33 PRI209.1
N17251609: length 2.4
  BOTTOM w0.112: PRI205.1 v1(82.26,26.03)
  BOTTOM w0.254: PRI205.1 83.22,26.85 83.47,27.11 PUI07.6
N17254393: length 3
  TOP w0.112: v2(82.96,41.68) v1(82.33,41.68)
  TOP w0.254: v2(82.96,41.68) 83.08,41.8 PRI217.2
  BOTTOM w0.254: PUI08.7 83.06,41.78 v2(82.96,41.68) 82.54,41.26 PRI214.1
N17254411: length 3.6
  BOTTOM w0.112: v1(80.36,41.49) 81.69,41.49 82.2,42 PRI216.1
  BOTTOM w0.254: PUI08.8 82.57,42.28 PRI216.1
N17254421: length 1.7
  BOTTOM w0.254: PRI213.2 88.01,41.91 87.64,42.28 PUI08.3
N17254439: length 3.4
  BOTTOM w0.112: v1(88.22,44.53) PCI209.2
  BOTTOM w0.254: PCI209.2 88.22,42.71 PRI220.2 87.74,42.68 87.64,42.78 PUI08.2
N17254445: length 3.9
  TOP w0.112: PRI218.2 88.2,43.82 v1(88.2,44.79)
  TOP w0.254: PCI208.1 86.9,43.02 v2(87.53,43.65) 88.03,43.65 PRI218.2
  BOTTOM w0.254: PUI08.1 87.1,43.28 87.46,43.65 v2(87.53,43.65)
N17254465: length 4.3
  BOTTOM w0.112: PRI215.2 86.52,40.16 v1(86.2,39.84)
  BOTTOM w0.254: PUI08.5 87.18,41.28 87.39,41.07 87.43,41.07 87.45,41.05 PCI207.2 88.19,40.96 PRI215.2
N17254471: length 3.6
  TOP w0.112: v1(88.2,42.16) PRI211.2
  TOP w0.254: PCI210.1 87.44,41.7 v2(87.59,41.55) 87.96,41.18 PRI211.2
  BOTTOM w0.254: PUI08.4 87.36,41.78 v2(87.59,41.55)
N17254491: length 2.6
  BOTTOM w0.112: PRI212.1 v1(82.21,44.36)
  BOTTOM w0.254: PRI212.1 83.15,44.24 83.15,43.47 83.34,43.28 PUI08.10
N17254495: length 2.5
  BOTTOM w0.112: PRI219.1 v1(83.22,39.14)
  BOTTOM w0.254: PRI219.1 83.15,40.25 83.15,40.92 83.51,41.28 PUI08.6
N17256722: length 3.2
  TOP w0.112: v2(82.77,35.14) v1(82.14,35.14)
  TOP w0.254: v2(82.77,35.14) 83.06,35.43 PRI229.2
  BOTTOM w0.254: PUI09.7 83.01,35.38 v2(82.77,35.14) 82.51,34.88 82.34,34.88 82.18,34.72 PRI226.1
N17256744: length 4.9
  BOTTOM w0.112: PRI228.1 81.68,35.18 80.85,35.18 80.65,34.99 80.65,33.51 v1(80.8,33.36)
  BOTTOM w0.254: PUI09.8 82.37,35.88 PRI228.1
N17256762: length 1.7
  BOTTOM w0.254: PUI09.3 87.63,35.88 87.97,35.53 PRI225.2
N17256780: length 3.7
  BOTTOM w0.112: v1(88.55,38.19) 88.12,37.76 PCI214.2
  BOTTOM w0.254: PCI214.2 88.12,36.33 PRI221.2 87.59,36.31 87.52,36.38 PUI09.2
N17256786: length 3.9
  TOP w0.112: PRI230.2 v1(88.1,38.26)
  TOP w0.254: PRI230.2 87.47,37.17 v2(87.46,37.17) 86.94,36.65 PCI213.1
  BOTTOM w0.254: PUI09.1 87.17,36.88 v2(87.46,37.17)
N17256806: length 3.7
  BOTTOM w0.112: PRI227.2 v1(88.07,32.75)
  BOTTOM w0.254: PRI227.2 88.09,33.86 PCI212.2 88.08,34.66 87.26,34.66 87.04,34.88 PUI09.5
N17256812: length 3.6
  TOP w0.112: PRI223.2 88.1,34.95 v1(88.1,35.9)
  TOP w0.254: PRI223.2 87.66,34.95 v2(87.46,35.14) 87.28,35.32 PCI215.1
  BOTTOM w0.254: PUI09.4 87.22,35.38 v2(87.46,35.14)
N17256832: length 2.5
  BOTTOM w0.112: PRI224.1 v1(81.99,37.98)
  BOTTOM w0.254: PRI224.1 83.17,37.14 83.43,36.88 PUI09.10
N17256836: length 2.4
  BOTTOM w0.112: PRI222.1 v1(83.11,32.82)
  BOTTOM w0.254: PUI09.6 83.37,34.88 83.08,34.59 83.08,33.84 PRI222.1
N17290710: length 3
  TOP w0.102: UU6.7 27.62,25.33 27.3,25.64
  TOP w0.112: 27.3,25.64 27.27,25.68 27.27,25.92 R369.1 26.84,26.3 26.38,26.76 v1(25.87,26.76)
N17293226: length 3.7
  TOP w0.112: UE5.2 290.7,23.48 290.35,23.83 290.35,24.47 v1(289.91,24.91) 289.33,25.49 RE646.2
N17293290: length 2.7
  TOP w0.112: RE694.2 289.13,16.45 v1(289.84,16.45) 290.53,16.45 290.7,16.28 UE5.20
N17297096: length 7.8
  TOP w0.112: UE5.76 308.03,15.88 308.23,15.67 311.45,15.67 311.96,15.16 RE701.1 312.71,15.33 312.9,15.52 313.67,15.52 v1(314.2,14.99)
N17335181: length 7.8
  TOP w0.112: UE5.107 301.54,26.36 301.46,26.43 301.46,26.96 301.79,27.29 302.05,27.29 302.25,27.49 302.25,30.87 RE74.2 301.54,31.58 v1(300.64,31.58)
N17335675: length 5.3
  TOP w0.112: RE85.1 303.02,28.7 CE51.1 303.39,29.83 QE2.2 304.25,32.3 v1(304.7,32.75)
N17489381: length 1.5
  TOP w0.112: UL1.76 183.19,163.5 182.78,163.09 T360.1
N17490955: length 5.6
  TOP w0.112: CU27.1 17.64,36.3 v1(18.32,36.98)
  TOP w0.254: RU5.2 17.4,34.39 UU5.2 ; RU5.2 17.55,33.77 DU8.2 ; RU5.2 17.55,35.49 CU27.1
N17495484: length 2.6
  TOP w0.112: UU1.16 36.18,13.09 RU3.2 36.91,12.93 v1(37.43,12.41)
N17495486: length 3.2
  TOP w0.112: UU1.15 35.68,13.05 RU2.2 34.7,12.07 v1(34.7,11.39)
N17495513: length 2.8
  TOP w0.112: UU1.8 34.68,18.2 34.39,18.49 RU7.2 35.25,18.97 v1(35.34,18.88)
N17495517: length 2.9
  TOP w0.112: UU1.4 37.4,16.5 37.74,16.84 RU1.2 38.43,16.9 v1(39.34,17.8)
N17528252: length 3
  TOP w0.112: v1(33.91,27.04) R370.2
  TOP w0.127: R370.2 33.28,25.33 UU6.24
N17623308:
  vias: v1(200.88,162.52) v2(198.21,162.71) v2(202,162.71) v2(205.86,162.71) v2(209.64,162.71)
N18480752: length 15.3
  TOP w0.089: UH1.AN6 289.68,56.98 289.5,57.16 v2(289.38,57.16)
  TOP w0.112: RH9.1 298,61.47 v2(297.45,61.47)
  BOTTOM w0.127: v2(297.45,61.47) 298.31,61.47 298.75,61.02 v1(298.75,60.41) 298.75,59.48 296.57,57.3 294.03,57.3 293.27,56.54 291.68,56.54 291.06,57.16 v2(289.38,57.16)
N19446833: length 7
  TOP w0.112: v1(355.99,24.13) v2(355.99,24.7) 356.06,24.77 356.06,24.99 RE692.2
  TOP w0.127: UE1.27 356.82,29.11 356.49,28.78 v2(356.49,28.67)
  IN1 w0.084: v2(356.49,28.67) 356.36,28.55 356.36,25.08 v2(355.99,24.7)
N19846941: length 3.8
  TOP w0.112: v1(46.13,33.68) 45.62,33.17 45.62,32.47 45.98,32.12 RT241.1 46.06,32.09 45.6,31.63 45.6,31.18 45.53,31.11 UT6.25
N20112847: length 2.9
  BOTTOM w0.112: RT116.2 25.55,26.9 CT37.1 25.5,26.84 25.27,26.6 25.27,25.54 YT1.1
N20112857: length 2.8
  BOTTOM w0.112: YT1.3 24.75,25.71 24.92,25.71 25.03,25.82 25.03,26.52 24.82,26.73 CT38.1 25.05,27.08 25.05,27.24 RT117.2
N20119614: length 3.8
  TOP w0.112: UT7.1 49.54,16.28 49.23,16.6 RT242.2 RT243.2 48.75,17.43 49.63,17.43 v1(49.78,17.28)
N20119616: length 2.7
  TOP w0.112: v1(61.5,10.63) 61.29,10.84 CT212.1 61.21,11.72 RT249.1 59.86,11.72 RT245.1
N20119618: length 2.8
  TOP w0.112: v1(61.88,13.52) 61.29,12.93 CT211.1 61.21,12.46 RT247.1 59.81,12.46 RT246.1
N20119620: length 2.8
  TOP w0.112: UT7.17 57.03,14.33 57.35,14.65 v1(57.69,14.65) 58.07,14.27 58.07,14.2 RT702.1
N20119626: length 5.1
  TOP w0.112: v1(59.15,17.68) 59.89,16.93 RT250.2 59.84,16.61 CT214.1 CT215.1 57.53,16.61 57.2,16.28 UT7.20
N20119654: length 2.6
  TOP w0.112: UT7.18 57.15,14.98 57.24,15.07 58.05,15.07 RT248.2
N20119690: length 4.7
  TOP w0.112: UT7.13 57.22,11.73 57.48,11.47 57.83,11.47 58.31,11.95 RT719.1 58.73,11.81 RT245.2 59.19,11.02 59.14,10.98 v1(59.14,10.37)
N20119692: length 3.4
  TOP w0.112: UT7.14 57.15,12.38 57.56,11.97 v1(57.75,11.97) 57.95,11.97 58.53,12.56 RT718.1 58.73,12.42 RT246.2
N20119710: length 3.2
  TOP w0.112: UT7.2 49.71,15.63 49.64,15.56 48.7,15.56 48.37,15.23 RT716.1 47.48,15.23 RT705.1
N20119714: length 4.4
  TOP w0.112: UT7.3 49.8,14.98 49.46,15.32 48.83,15.32 48.14,14.64 RT717.1 RT706.1 47.47,14.06 v1(47.21,13.8)
N20119734: length 6.3
  TOP w0.112: UT7.4 49.33,14.33 48.3,13.31 46.42,13.31 RT244.2 45.34,13.59 v1(44.86,13.1)
N20124859: length 16.6
  TOP w0.112: v2(29.68,37.16) 29.68,37.11 v1(30.06,36.73)
  IN4 w0.084: v2(29.68,37.16) 29.68,37.36 28.76,38.28 25.25,38.28 24.97,38.56 24.97,40.92 25.22,41.17 25.35,41.17 26.09,41.91 v2(26.17,41.91)
  BOTTOM w0.076: v2(26.17,41.91) 26.16,41.92 26.16,42.01 25.93,42.24 UT1.R13 ; 31.77,36.38 CT153.1 30.67,36.38 30.17,36.88 29.96,36.88 v2(29.68,37.16)
  BOTTOM w0.112: 31.77,36.38 31.88,36.38 CT154.1 CT155.1 35.25,36.79 LT4.1
N20389048: length 85.6
  IN2 w0.254: v2(290.92,36.89) 289.27,36.89 288.02,35.65 279.11,35.65 278.04,36.71 256.37,36.71 256.12,36.46 v2(256.12,35.71)
  BOTTOM w0.254: v2(256.12,35.71) 256.33,35.5 256.33,27.84 253.93,25.44 253.93,15.41 251.25,12.72 250.77,12.72 250,11.96 249.53,11.96 248.75,12.74 247.81,12.74 246,10.94 246,10.63 244.86,9.48 240.25,9.48 v1(239.83,9.9) 238.91,10.82 238.91,12.15 239.46,12.7 PR1806.2 ; v2(290.92,36.89) 291.06,37.03 293.1,37.03 293.54,36.6 PC1807.1 295.41,36.02 PU1801.4
N20408000: length 2
  TOP w0.112: RS9.1 113.38,173.19 113.16,172.97 US2.12
N20412193: length 2.7
  TOP w0.112: v1(257.81,5.67) RS17.2 257.14,6.59 v2(257.08,6.65)
  BOTTOM w0.112: v2(257.08,6.65) 257.05,6.63 JHDD.11
N20418101: length 9.3
  TOP w0.112: v1(209.64,129.82) v2(208.94,129.82)
  TOP w0.254: v2(208.94,129.82) 207.74,131.02 PD706.1
  TOP w0.508: PR729.1 209.59,135.09 v2(209.58,135.09)
  IN4 w0.254: v2(208.94,129.82) 208.44,130.33 208.44,133.57 209.58,134.71 v2(209.58,135.09)
N20451899: length 8.5
  TOP w0.112: RN118.1 341.97,42.48 341.97,42.06 v2(341.65,41.74) v1(341.02,41.74)
  IN3 w0.104: v2(337.34,41.81) 337.64,42.11 341.29,42.11 v2(341.65,41.74)
  BOTTOM w0.112: v2(337.34,41.81) 336.96,41.81 336.66,42.1 JWLAN.38
N20451900: length 11.8
  TOP w0.112: RN119.1 341.39,43.2 v1(341.24,43.05) 341.24,42.76 v2(341.56,42.44)
  IN3 w0.104: v2(341.56,42.44) 341.46,42.34 337.13,42.34 336.87,42.6 333.82,42.6 v2(333.53,42.31)
  BOTTOM w0.112: JWLAN.40 333.82,42.6 v2(333.53,42.31)
N20453798: length 12.9
  TOP w0.112: v2(148.04,148.04) v3(148.04,148.68)
  TOP w0.254: v2(148.04,148.04) 148.16,147.93 PRS74.1 ; PQS30.6 156.34,147.58 156.25,147.66 v2(156.25,148.08)
  IN2 w0.254: v2(156.25,148.08) 156.21,148.04 v2(152.81,148.04) 151.54,149.31 150.46,149.31 149.82,148.68 148.61,148.68 148.04,148.11 v2(148.04,148.04)
  BOTTOM w0.254: PCS85.2 152.98,148.22 v2(152.81,148.04)
N20463917: length 4.9
  TOP w0.112: v1(200.05,129.94) 200.44,129.94 201.38,130.88 201.38,131.28 201.59,131.49 PQ710.1
  TOP w0.254: PQ709.2 202.55,130.78 PQ710.1
N20466818: length 2
  TOP w0.112: v1(111.54,140.93) 112.42,140.04 PRS83.2
N20469265: length 1.5
  TOP w0.112: v3(151.98,139.6) 151.64,139.25 PCS81.1
N20478252: length 4
  BOTTOM w0.112: PU2501.4 239.23,14.76 v3(237.9,13.42)
N20591895: length 0.6
  TOP w0.112: v2(377.92,49.74) v3(377.92,49.11)
N20642816: length 8.4
  TOP w0.089: UH1.BC1 292.55,62.21 292.7,62.36 292.7,63.14 293.22,63.66 293.22,64.46 294.53,65.76 294.53,66.01 294.78,66.27
  TOP w0.112: T372.1 295.94,67.08 295.27,66.4 294.92,66.4 294.78,66.27
N20764785: length 5.9
  TOP w0.089: RH580.1 295.73,40.23 293.9,42.06 293.9,42.99 293.49,43.41 292.81,43.41 292.62,43.59 292.21,43.59 292.05,43.44 UH1.F3
N20764786: length 5.8
  TOP w0.089: RH581.1 294.93,41.78 294.28,42.43 294.28,42.89 294.28,43.15 293.64,43.79 292.97,43.79 292.78,43.98 292,43.98 291.97,43.94 291.56,43.94 UH1.G3
N20781272: length 2.9
  TOP w0.112: v1(312.96,19.84) 313.22,20.1 RE698.2 314.1,20.81 QE64.6 QE64.5
N20905330: length 3.9
  TOP w0.112: v2(44.46,43.77) 44.35,43.67 44.35,42.75 RT22.1 44.75,42.61 45.24,42.12 v1(45.56,42.12)
  BOTTOM w0.076: v2(44.46,43.77) 44.29,43.94 UT4.A7 UT4.A6
N20905578: length 1.9
  TOP w0.112: v2(44.63,48.58) v1(44.63,49.15)
  TOP w0.127: v2(44.63,48.58) 44.55,48.5 CT104.1
  BOTTOM w0.104: v2(44.63,48.58) 44.63,48.41 UT4.H7
N20905857: length 4.9
  BOTTOM w0.102: UT4.F1 40.1,47.07 39.95,46.92 39.81,46.92 39.69,46.8
  BOTTOM w0.112: v1(36.86,47.52) 37.62,47.52 37.81,47.33 38.32,47.33 38.72,46.94 RT83.2
  BOTTOM w0.127: 39.69,46.8 RT83.2
N20990559: length 4
  TOP w0.112: v1(158.27,164.55) 160.11,164.55 160.5,164.16 RL42.2 161.08,163.34 UL13.2
N20994075:
  vias: v1(165,161.06)
N20998853: length 5.8
  TOP w0.254: v2(195.99,164.49) 196.31,164.17 v1(196.31,162.71) 196.31,162.57 195.72,161.98 194.93,161.98 194.65,162.25 UL10.7
  BOTTOM w0.254: v2(195.99,164.49) 195.86,164.49 195.55,164.81 RL57.1
N21000962:
  vias: v1(193.7,161.5)
N21009233: length 2.9
  BOTTOM w0.112: v1(216.86,104.53) R181.2 216.91,105.7 U2407.7
N21009259: length 7.4
  BOTTOM w0.112: JFAN1.4 91.74,59.46 v3(91.74,55.84) 91.74,55.01 RF3.1 92.13,54.02 92.75,54.02 DF1.1
N21011071: length 2.9
  TOP w0.112: v1(370.73,30.68) RE14.2
  TOP w0.127: UE2.3 369.7,30.71 RE14.2
N21011075: length 4.4
  TOP w0.112: RE9.1 371.44,41.98 371.44,42.73 371.29,42.89 371.24,42.89 370.96,43.16 v1(370.96,43.77)
  TOP w0.127: UE2.5 RE9.1
N21011082: length 3.8
  TOP w0.112: v1(367.88,43.46) 367.88,42.12 368.43,41.58 RE13.2
  TOP w0.127: UE2.7 RE13.2
N21011109: length 4.2
  TOP w0.112: RE10.1 368.35,30.65 367.69,30 v1(367.69,28.73)
  TOP w0.127: UE2.2 368.43,31.3 368.35,31.22 RE10.1
N21011136: length 5
  TOP w0.112: UE9.3 350.1,29.8 349.22,28.92 v1(349.22,26.82)
  TOP w0.127: RE20.1 349.53,31.06 350.1,30.49 UE9.3
N21021693: length 2.6
  TOP w0.112: UZ21.6 164.38,100.94 164.2,100.76 C3.1 v1(163.7,101.75)
N21094566: length 2.5
  TOP w0.203: PUZ01.46 61.43,30.22 60.91,29.69 60.91,29.32 60.63,29.04 PRZ02.2
N21094590: length 3.9
  TOP w0.203: PUZ01.41 61.32,32.22 61.14,32.4 60.82,32.4 v2(60.82,32.4) 60.3,32.92 PRZ04.1
  BOTTOM w0.254: v2(60.82,32.4) 61.14,32.72 v1(61.37,32.72) 61.82,32.72 61.95,32.59 PCZ04.1
N21094642: length 2.6
  TOP w0.112: PRZ07.1 58.56,29.87 v2(58.6,29.83) PRZ08.1
  BOTTOM w0.112: v1(59.08,29.49) 58.74,29.83 v2(58.6,29.83) 57.97,29.83 PRZ01.2
N21094652: length 2.7
  TOP w0.112: PRZ10.1 v2(58.58,30.62) 58.57,30.63 PRZ09.1
  BOTTOM w0.112: PRZ05.2 58.58,30.62 v2(58.58,30.62) 58.91,30.95 v1(59.21,30.95)
N21094662: length 3.1
  TOP w0.112: PRZ13.1 v2(58.64,31.38) 58.63,31.39 PRZ12.1 v1(57.95,32.46)
  BOTTOM w0.112: v2(58.64,31.38) 58.63,31.39 PRZ06.2
N21094718: length 1.9
  TOP w0.203: PUZ01.44 61.24,31.02 61.17,30.95 61.15,30.95 60.82,30.62 PRZ10.2
N21094756: length 4.6
  TOP w0.112: PRZ26.2 60.17,25.81 v1(60.1,25.74)
  TOP w0.203: PUZ01.1 62.76,28.34 62.59,28.17 62.04,28.17 61.59,27.72 61.11,27.72 60.84,27.45 60.84,27.25 60.33,26.73 PRZ26.2
N21094764: length 4.5
  TOP w0.203: PRZ16.2 60.29,28.41 60.76,28.41 v2(60.97,28.62) 61.24,28.89 61.24,29.55 61.5,29.82 PUZ01.47
  BOTTOM w0.112: v2(60.97,28.62) v1(60.97,29.34)
  BOTTOM w0.203: v2(60.97,28.62) 60.63,28.28 PRZ21.2
N21094776: length 3.1
  TOP w0.203: PUZ01.48 61.94,28.53 61.45,28.05 60.95,28.05 60.4,27.51 PRZ24.2
N21207101: length 1.1
  TOP w0.112: TC28.1 288.13,69.7 RP7.1
N21214430: length 6.2
  TOP w0.112: JPCMC.23 60.87,42.02 RC688.1 61.31,37.93 v1(62.13,37.11)
N21284890: length 1.8
  TOP w0.112: US3.2 276.4,79.65 276.38,79.63 RS15.2 276.03,80.32 v1(275.81,80.54)
N21889161: length 2.9
  TOP w0.112: UL14.3 167.5,169.65 RL69.1 167.51,169.79 166.97,170.33 166.97,170.65 v1(166.53,171.09)
N21968037: length 6.4
  BOTTOM w0.112: RL66.1 193.04,183.44 v1(193.96,183.44) JLAN.9
N21970003: length 22.8
  BOTTOM w0.112: RL68.1 211.75,165.31 211.75,166.3 CL109.1 211.75,167.28 211.75,169.34 213.96,171.55 v1(213.96,179.73) 213.96,181.61 213.01,182.55 212.19,182.55 211.31,183.44 JLAN.11
N21970023: length 19.7
  BOTTOM w0.112: JLAN.13 214.3,181.7 v1(214.3,177.7) 214.3,169.35 CL108.1 213.96,168.93 214.43,168.46 214.43,166.37 213.96,165.9 213.96,165.89 RL67.1
N21970031: length 20.2
  IN3 w0.254: JLAN.12 213.05,184.94 214.32,183.67 214.32,171.04 v2(213,169.72)
  BOTTOM w0.112: v2(213,169.72) 213.22,169.95 v1(213.58,169.95)
  BOTTOM w0.254: RL71.1 212.63,169.01 CL31.1 213.05,169.66 v2(213,169.72)
N21995476: length 2.3
  BOTTOM w0.112: RT122.2 46.25,35.23 CT156.1 47.05,35.23 v1(48.04,36.22)
N22716130: length 15.1
  BOTTOM w0.254: PQS22.2 142.9,157.5 PRS87.1 142.39,158.75 PRS86.2 141.57,158.77 141.21,159.13 v1(141.21,160.55) 141.21,163.92 141.37,164.08 143.06,164.08 143.72,163.42 PQS26.2 145.81,163.42 PCS82.2
N22716132: length 20.5
  IN1 w0.254: v2(142.39,155.79) 140.28,155.79 135.01,150.52 130.64,150.52 130.12,150 129.62,150 129.37,150.25 129.37,150.62 129.06,150.92 v2(128.88,150.92)
  BOTTOM w0.254: PQS23.1 129.51,152.8 129.76,152.55 129.76,152.19 128.88,151.31 v2(128.88,150.92) ; PRS87.2 v2(142.39,155.79)
N22717170: length 2.1
  TOP w0.112: PQS27.2 157.31,153.96 v3(156.18,155.09)
N22717172: length 3.7
  TOP w0.254: PQS28.1 154.9,152.93 155.41,153.44 v1(155.79,153.44) 156.18,153.44 156.49,153.13 PRS90.2
N22717182: length 21.6
  TOP w0.254: PRS89.1 156.54,149.02 PQS24.3 158.27,149.02 158.27,147.69 158.75,147.2 161.28,147.2 v3(161.94,147.87) 164.24,150.17 164.24,154.26 163.73,154.77 161.76,154.77 161.38,154.39 PCS83.1 160,153.06 159.74,153.31 PQS27.3
N22744293:
  vias: v1(147.1,160.04)
N22801974: length 2.4
  BOTTOM w0.112: v1(126.01,150.65) PRS92.2
  BOTTOM w0.254: PRS92.2 126.53,152.15 PQS23.2
N22803402: length 2.4
  TOP w0.254: PQS28.2 154.25,149.9 v1(154.52,149.63) 154.88,149.27 PRS93.2
N22855815: length 17.2
  BOTTOM w0.102: 132.51,84.99 132.88,84.62 132.88,84.01 133.2,83.68 UC1.D1
  BOTTOM w0.112: RC692.2 v1(122.78,92.03) 122.78,91.72 123.3,91.21 127.2,91.21 132.51,85.89 132.51,84.99
N22932271:
  vias: v2(124.72,153.85)
N22933167: length 4.3
  TOP w0.254: PQS30.3 157.64,145.33 157.46,145.5 157.17,145.5 156.99,145.32 PQS30.2 156.99,144.25 156.71,143.97 v1(156.1,143.97) 155.05,143.97 PRS95.2
N22940727: length 2.2
  BOTTOM w0.112: PR27.2 v1(151.02,163.8)
  BOTTOM w0.254: PR27.2 151.02,162.47 151.44,162.05 PQ6.6
N22940749: length 3.3
  BOTTOM w0.112: PC15.1 149.07,158.72 v1(148.75,158.39)
  BOTTOM w0.254: PC15.1 149.56,159 PR22.2 150.14,159.14 PQ6.3
N22943813: length 4.2
  BOTTOM w0.112: PQ10.6 146.9,165.63 147.16,165.89 148.67,165.89 PR42.2 149.27,164.46 v1(149.46,164.27)
N22943835: length 1
  BOTTOM w0.112: PR40.2 v1(150.36,167.07)
N22956288: length 3.5
  BOTTOM w0.112: v1(154.03,164.27) 153.51,163.75 PQ11.1
  BOTTOM w0.254: PQ11.1 153.51,162.89 153.76,162.63 154.86,162.63 PR44.2
N22957086: length 1
  BOTTOM w0.112: PR45.2 v1(150.64,171.24)
N22958603:
  vias: v1(127.91,130.66)
N23062034: length 12.9
  TOP w0.112: RT718.2 57.84,13.14 v1(57.69,13.29) 57.57,13.41 v2(57.57,14.11) ; RT716.2 48.26,15.97 v2(49.09,15.97)
  IN2 w0.104: v2(49.09,15.97) 49.49,15.57 50.68,15.57 53.1,13.16 56.62,13.16 v2(57.57,14.11)
N23062041: length 14.2
  TOP w0.112: v2(49.19,14.91) 49.19,14.67 v1(48.94,14.42) 48.58,14.06 RT717.2 ; v2(58.73,10.74) 58.59,10.88 RT719.2
  IN2 w0.104: v2(58.73,10.74) 58.73,11.24 57.04,12.93 53,12.93 50.59,15.34 49.62,15.34 v2(49.19,14.91)
N24139767:
  vias: v1(266.84,68.26)
N24365027: length 6.4
  TOP w0.112: v1(251.17,6.31) 251.17,8.28 251.01,8.44 250.19,8.44 249.72,7.97 RE530.2 CE63.2 248.58,8.96 248.42,9.12 UE10.3
N24654525:
  vias: v1(276.32,89.3)
N24654698: length 2.5
  TOP w0.112: U18.3 275.45,84.67 275.45,84.67 275.12,84.67 275,84.78 R367.1 273.66,84.78 v1(273.59,84.86)
N24774570: length 4
  TOP w0.112: v2(304.72,19.81) 304.79,19.88 UE5.86
  BOTTOM w0.112: RE702.1 304.72,19.69 v2(304.72,19.81) 305,20.09 v1(305.21,20.09)
N24886534: length 3.2
  TOP w0.112: v1(55.85,20.67) 56.42,20.67 57.04,21.29 RT132.1 57.04,22.39 56.93,22.5 UT8.3
N24894786: length 2.7
  TOP w0.112: UE6.3 285.57,8.43 CE202.2 RE704.2
N25336280: length 4.2
  BOTTOM w0.112: RN7.2 354.26,37.74 354.08,37.57 QN8.6 353.26,37.57 352.87,37.96 v1(352.74,37.96) 352.74,37.49 353.31,36.92 QN8.5
N25337275: length 3.8
  BOTTOM w0.112: v1(350.42,39.71) 350.42,39.96 350.74,40.28 RN9.2 350.89,40.63 351.12,40.85 QN9.5 352.07,40.85 352.2,40.98 352.2,41.43 352.12,41.5 QN9.6
N25456628: length 4.5
  TOP w0.089: UH1.BC17 284.33,62.36 284.25,62.44 284.25,62.52 284.17,62.59 284.17,63.66 283.97,63.86 283.97,64.2 283.78,64.39 283.78,65.84 TC29.1
N25456636: length 4.9
  TOP w0.089: UH1.BD17 284.55,62.78 284.36,62.97 284.36,63.74 284.16,63.94 284.16,64.28 284,64.44 284,66.06 284.45,66.51 TC30.1
N25456691: length 1.9
  BOTTOM w0.112: RH591.2 CH232.1 v1(261.89,109.84)
N25457743: length 15.3
  TOP w0.089: v2(275.3,61.87) 275.24,61.87 UH1.BB36
  TOP w0.112: RH89.1 v2(273.81,73.68) 274.71,73.68 v1(275.16,74.14)
  IN1 w0.084: v2(273.81,73.68) 273.81,67.49 275.04,66.25 275.04,64.6 275.41,64.23 275.41,61.98 v2(275.3,61.87)
N25459397: length 2.3
  TOP w0.089: UH1.AP21 282.55,57.89 v2(282.98,58.32)
  BOTTOM w0.112: v2(282.98,58.32) 283.65,58.32 RT694.2 v1(283.74,57.37)
N25467546: length 5.5
  TOP w0.112: v1(159.03,182.65) 159.03,182.46 158.08,181.51 RE25.2 157.99,180.65 157.64,180.3 157.64,179.6 157.76,179.47 158.33,179.47 158.51,179.3 158.51,179.14 158.38,179.01 UE3.24
N25467550: length 2.6
  TOP w0.112: UE3.30 154.65,180.49 155.1,180.94 v1(155.1,181) 155.1,181.89 RE31.1
N25468008: length 2.7
  TOP w0.112: QE22.6 155.59,172.38 155.78,172.18 RE157.2 156.43,172.42 156.05,172.81 v1(156.05,173.25)
N25468398: length 4.2
  TOP w0.112: RE155.2 152.94,169.75 152.84,169.84 152.84,170.18 153.12,170.46 154.22,170.46 v2(154.69,169.99) 154.8,169.88 QE21.6
N25468783: length 4.5
  TOP w0.112: RE160.2 158.03,170.34 157.64,169.95 157.64,168.81 157.47,168.64 QE13.6 156.92,168.04 157.37,167.59 v1(157.64,167.59)
N25473625: length 4.9
  TOP w0.112: v2(90.13,17.49) v1(90.65,17.49)
  IN1 w0.254: v2(90.13,17.49) 89.37,18.25 v2(89.37,20.3)
  BOTTOM w0.254: UT5.4 89.44,19.59 89.26,19.77 89.26,20.19 v2(89.37,20.3)
N25473695: length 4.6
  TOP w0.112: RT90.1 80.7,8.94 CT115.1 81.09,8.94 81.32,8.71 QT2.5 82.25,8.71 82.39,8.85 v1(82.39,10.5)
N25473720: length 5
  TOP w0.112: RT89.2 82.5,13.18 83.34,12.34 v1(83.34,11.39) 83.34,9.65 QT2.3
N25473733: length 4.7
  TOP w0.112: RT88.2 RT90.2 81.66,8.13 QT2.6 82.73,8.06 83.4,7.39 v1(84.36,7.39)
N25473775: length 2.5
  BOTTOM w0.112: v1(94.39,19.58) 94.25,19.44 CT117.1 92.92,19.44 92.57,19.09 UT5.6
N25486032: length 4.5
  BOTTOM w0.112: v1(159.92,190.14) 159.92,190.52 160.62,191.22 QM2.6 161.13,191.22 161.4,190.96 RM92.2 162.34,190.96 162.41,191.03 QM1.2
N25486052: length 14
  BOTTOM w0.112: QM3.2 158.76,187.04 157.57,188.24 v1(157.57,188.68) 157.57,192.96 158.25,193.65 RM94.2 158.98,192.53 QM2.3
N25488294: length 3.3
  BOTTOM w0.112: v1(164.03,184.6) 164.03,184.12 163.83,183.91 RM72.1 164.11,183.67 164.98,182.8 UM8.27
N25488305: length 3.7
  BOTTOM w0.112: v1(179.29,179.13) 177.8,179.13 177.34,179.58 RM61.2 176.59,179.59 176.38,179.8 UM8.52
N25488307: length 4.2
  BOTTOM w0.112: RM64.1 177.48,181.54 177.73,181.29 v1(179.1,181.29) ; RM64.1 177.19,181.76 177.13,181.82 176.57,181.82 176.54,181.8 UM8.48 ; RM64.1 RM66.1
N25489376: length 5.1
  BOTTOM w0.112: UM4.1 164.67,169.36 164.77,169.26 165.02,169.26 165.45,169.7 RM21.2 RM96.2 165.76,170.64 166.34,171.22 v1(167.73,171.22)
N25489378: length 3.3
  BOTTOM w0.112: RM28.1 159.02,178.74 159.84,179.56 RM29.1 159.87,180.3 CM99.1 159.42,180.74 v1(158.65,180.74)
N25489380: length 3.2
  BOTTOM w0.112: v1(161.7,180.68) 161.4,180.38 CM98.1 160.71,180.19 160.6,180.08 RM38.1 160.6,179.46 159.88,178.74 RM27.1
N25489388:
  vias: v1(164.49,177.19)
N25489416: length 1.7
  BOTTOM w0.112: UM4.18 163.37,176.52 RM25.2
N25489452: length 3.7
  BOTTOM w0.112: UM4.13 160.12,176.29 159.02,177.4 RM28.2 158.58,177.82 158.39,177.63 v1(157.95,177.63)
N25489454: length 3.9
  BOTTOM w0.112: UM4.14 160.77,176.85 160.55,177.07 160.55,177.19 159.92,177.82 RM27.2 160.25,178.27 160.68,178.27 v1(160.9,178.48)
N25489496: length 3.1
  BOTTOM w0.112: UM4.4 162.72,168.72 RM20.2 163.02,168.5 163.86,167.66 v1(164.11,167.66)
N25570567: length 5.5
  TOP w0.112: UL1.27 186.4,174.37 186.4,175.41 186.65,175.66 187.46,175.66 187.81,176.02 CL126.1 187.81,177.3 CL96.1 187.81,177.61 187.66,177.76 v1(187.66,178.7)
N25983095: length 2.6
  BOTTOM w0.076: 28.73,49.43 28.73,48.75 28.23,48.24 UT1.Y1
  BOTTOM w0.112: 28.73,49.43 28.73,50.13 RT724.1
N25983098: length 3.2
  BOTTOM w0.076: 29.15,49.28 29.15,48.93 28.45,48.23 28.45,47.71 UT1.Y2
  BOTTOM w0.112: RT725.1 v1(29.15,49.41) 29.15,49.28
N26130108: length 3.1
  BOTTOM w0.112: v1(297.59,44.47) 298.92,44.47 299.5,45.04 RE161.1 299.53,45.02 UE12.3
N26166089: length 4.7
  TOP w0.112: v1(106.11,116.27) 106.24,116.39 106.24,117.82 106.71,118.29 RV1.1
  TOP w0.254: UV65.5 107.01,119.89 106.71,119.59 RV1.1
N26166093: length 2.4
  TOP w0.254: RV2.2 106.06,118.63 v1(106.06,119.29) UV65.4
N26166280: length 3.6
  TOP w0.112: v1(105.43,126.95) 105.43,125.44 RV4.1
  TOP w0.254: UV65.3 106.06,124.81 RV4.1
N26241219: length 2.3
  TOP w0.254: UH1.AF19 283.56,53.53 v2(283.24,53.2) 282.91,53.53 UH1.AF20
  BOTTOM w0.112: v2(283.24,53.2) v1(283.72,53.2)
  BOTTOM w0.254: v2(283.24,53.2) 283.15,53.29 RH598.1
N26426233: length 91.7
  TOP w0.254: UE5.9 290.48,20.68 290.33,20.83 289.46,20.83 289.36,20.72 CE174.1
  TOP w0.381: v2(314.79,24.01) 319.49,24.01 319.96,23.54 319.96,19.63 320.64,18.95 320.64,17.9 318.61,15.87 v1(318.61,11.14) v2(318.61,7.92) ; RE705.2 315.19,8.13 v2(314.99,7.92)
  TOP w0.508: CE174.1 288.77,21 v2(289.16,21.38)
  IN1 w0.381: v2(289.16,21.38) 289.16,20.91 288.17,19.92 288.17,19.06 287.38,18.27 287.38,16.6 291.9,12.08 v2(291.9,10.5)
  IN2 w0.381: v2(314.99,7.92) 313.68,7.92 311.34,10.26 293.46,10.26 293.01,10.72 292.12,10.72 v2(291.9,10.5)
  IN4 w0.381: v2(314.79,24.01) 314.79,26.58 313.55,27.81 310.51,27.81 309.19,29.13 306.63,29.13 305.81,29.96 305.81,30.9 305.14,31.56 305.14,32.56 304.3,33.41 304.3,38.12 304.64,38.47 v2(304.64,38.5)
  BOTTOM w0.381: v2(304.64,38.5) 304.22,38.93 RE706.2 ; v2(318.61,7.92) v2(314.99,7.92)
N26580757: length 2.2
  TOP w0.112: UE13.3 270.69,83.26 RE707.1 v1(272.06,83.6)
N26581315: length 3.4
  TOP w0.112: UE6.6 285.09,9.93 RE703.2 285.51,10.25 285.78,10.51 v1(285.78,11.83)
N27290476: length 5.1
  TOP w0.112: UE5.111 299.94,26.32 300.64,27.02 300.74,27.02 301.04,27.33 301.04,28.46 300.93,28.57 RE77.2 v1(300.57,29.66)
N28714534: length 3.2
  TOP w0.112: PC752.2 211.73,144.79 212.25,145.31 v1(212.88,145.31)
  TOP w0.254: PR754.1 209.97,144.84 210,144.81 211.65,144.81 PC752.2
N28714560: length 1.5
  TOP w0.254: PC749.2 PR775.1
N28714625: length 1.9
  BOTTOM w0.112: v1(202.28,145.12) PR779.2
  BOTTOM w0.254: PR779.2 PR757.1
N28714782:
  vias: v1(191.08,154.33)
N28714793: length 12.8
  IN1 w1.016: 192.56,142.71 192.56,141.06 196.56,137.06 201.19,137.06 201.76,136.48
  vias: v1(192.69,144.49) v2(192.3,144.04) v2(192.94,144.04) v2(202.59,136.8) v2(202.59,136.22)

# Allegro board Alienware Area-51M LA-G881P.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_D18: length 82.8
  IN3 w0.15: v2(210.67,41.78) 212.88,41.78 213.66,42.57 222.66,42.57 222.88,42.34 222.88,41.53 223,41.42 224.83,41.42 224.97,41.27 224.97,41.07 225.12,40.92 225.4,40.92 225.55,41.07 v2(225.55,41.93)
  IN4 w0.102: 173.77,41.62 170.11,45.28 166.55,45.28 165.94,45.89 165.43,45.89 165.29,45.76 163.58,45.76 163.19,46.16 163.19,50.09 162.18,51.09 161.86,51.09 161.48,51.47 161.48,51.87 161.26,52.09 160.65,52.09 v2(160.21,52.54)
  IN4 w0.122: 173.77,41.62 174.66,41.62 174.78,41.5 174.78,41.29 174.9,41.17 175.14,41.17 175.26,41.29 175.26,41.5 175.39,41.62 175.63,41.62 175.75,41.5 175.75,41.05 175.87,40.93 176.12,40.93 176.24,41.05 176.24,41.5 176.36,41.62 176.61,41.62 176.73,41.5 176.73,41.05 176.85,40.93 208.35,40.93 208.47,40.81 208.47,40.53 208.59,40.41 208.83,40.41 208.96,40.53 208.96,40.81 209.08,40.93 209.82,40.93 v2(210.67,41.78)
  BOTTOM w0.157: v2(210.67,41.78) 210.92,42.03 212.9,42.03 JDIMM4.62 ; JDIMM2.62 225.64,42.03 v2(225.55,41.93)
  BOTTOM w0.191: v2(160.21,52.54) 160.64,52.11 UC1.AN32
DDR_B_D19: length 82.9
  IN3 w0.15: v2(221.88,41.92) 221.88,41.89 220.95,40.97 220.67,40.97 220.48,40.78 207.86,40.78 206.86,41.77 v2(206.86,41.78)
  IN4 w0.102: 174.27,42.47 171.05,45.69 166.72,45.69 164.03,48.38 164.03,49.99 162.31,51.71 v2(162.07,51.71)
  IN4 w0.122: v2(206.86,41.78) 193.23,41.78 193.11,41.9 193.11,42.01 192.99,42.14 192.75,42.14 192.62,42.01 192.62,41.9 192.5,41.78 192.2,41.78 192.08,41.9 192.08,42.35 191.96,42.47 191.71,42.47 191.59,42.35 191.59,41.9 191.47,41.78 191.23,41.78 191.1,41.9 191.1,42.35 190.98,42.47 190.74,42.47 190.62,42.35 190.62,41.9 190.49,41.78 190.25,41.78 190.13,41.9 190.13,42.35 190.01,42.47 189.76,42.47 189.64,42.35 189.64,41.9 189.52,41.78 189.28,41.78 189.15,41.9 189.15,42.35 189.03,42.47 188.79,42.47 188.67,42.35 188.67,41.9 188.54,41.78 188.3,41.78 188.18,41.9 188.18,42.35 188.06,42.47 187.81,42.47 187.69,42.35 187.69,41.9 187.57,41.78 187.32,41.78 187.2,41.9 187.2,42.35 187.08,42.47 186.84,42.47 186.71,42.35 186.71,41.9 186.59,41.78 186.35,41.78 186.23,41.9 186.23,42.35 186.11,42.47 185.82,42.47 185.7,42.35 185.7,41.9 185.57,41.78 185.33,41.78 185.21,41.9 185.21,42.35 185.09,42.47 184.7,42.47 184.58,42.35 184.58,41.99 184.46,41.87 184.21,41.87 184.09,41.99 184.09,42.35 183.97,42.47 183.68,42.47 183.56,42.35 183.56,41.9 183.44,41.78 183.19,41.78 183.07,41.9 183.07,42.35 182.95,42.47 174.27,42.47
  BOTTOM w0.157: JDIMM4.63 206.77,42.28 206.86,42.18 v2(206.86,41.78) ; JDIMM2.63 219.7,42.28 219.84,42.42 221.38,42.42 v2(221.88,41.92)
  BOTTOM w0.191: v2(162.07,51.71) 161.92,51.71 UC1.AP32
DDR_B_D20: length 82.3
  IN3 w0.15: v2(210.33,39.02) 210.33,39 210.76,38.57 211.23,38.57 211.66,39 213.68,39 214.11,38.57 216.46,38.57 216.83,38.94 222.94,38.94 223.14,39.13 223.14,39.32 223.34,39.52 223.72,39.52 223.95,39.29 223.95,38.3 223.81,38.16 v2(223.81,37.89)
  IN4 w0.102: 174.27,38.97 173.78,38.97 170.49,42.26 164.14,42.26 162.69,43.71 162.69,45.51 161.52,46.68 161.52,49.94 161.14,50.32 160.6,50.32 v2(160.21,50.71)
  IN4 w0.122: v2(210.33,39.02) 210.34,39.02 210.34,38.38 210.11,38.15 199.95,38.15 199.14,38.97 174.27,38.97
  BOTTOM w0.157: v2(210.33,39.02) 211.33,38.03 212.9,38.03 JDIMM4.46 ; JDIMM2.46 225.93,38.03 225.63,38.33 224.25,38.33 v2(223.81,37.89)
  BOTTOM w0.191: UC1.AN34 160.64,50.28 v2(160.21,50.71)
DDR_B_D21: length 81.2
  IN3 w0.15: v2(206.82,36.4) 205.63,36.4 205.41,36.62 205.41,37.85 205.62,38.05 209.86,38.05 210.35,37.56 216.87,37.56 217.2,37.89 v2(220.06,37.89)
  IN4 w0.102: v2(161.12,49.8) 161.12,50.01 161.02,50.11 160.72,50.11 160.62,50.01 160.62,46.04 162.28,44.38 162.28,43.54 163.97,41.85 170.3,41.85 173.65,38.5
  IN4 w0.122: 173.65,38.5 174.05,38.11 198.79,38.11 199.6,37.3 205.61,37.3 205.73,37.18 205.73,36.64 205.85,36.52 206.09,36.52 206.22,36.64 206.22,37.18 206.34,37.3 207.54,37.3 207.66,37.18 207.66,36.94 207.54,36.82 206.95,36.82 206.82,36.68 v2(206.82,36.4)
  BOTTOM w0.102: UC1.AP34 161.55,50.23 v2(161.12,49.8)
  BOTTOM w0.157: v2(206.82,36.4) 205.44,37.78 JDIMM4.45 ; v2(220.06,37.89) 219.95,37.78 JDIMM2.45
DDR_B_D22: length 85.1
  IN3 w0.15: v2(209.4,41.78) 209.4,42.02 209.7,42.31 212.66,42.31 213.41,43.07 222.88,43.07 223.05,42.9 224.43,42.9 224.57,42.77 224.57,42.45 224.44,42.33 224.44,42.33 224.28,42.18 v2(224.28,41.89)
  IN4 w0.102: 174.27,42.05 170.83,45.49 166.63,45.49 165.44,46.67 163.56,46.67 163.43,46.8 163.43,50.23 162.36,51.3 161.94,51.3 161.68,51.56 161.68,51.95 v2(161.09,52.54)
  IN4 w0.122: v2(209.4,41.78) 209.45,41.73 209.45,41.55 209.25,41.35 182.13,41.35 182.01,41.48 182.01,41.62 181.89,41.74 181.65,41.74 181.52,41.62 181.52,41.48 181.4,41.35 181.18,41.35 181.06,41.48 181.06,41.92 180.93,42.05 180.69,42.05 180.57,41.92 180.57,41.48 180.45,41.35 180.2,41.35 180.08,41.48 180.08,41.92 179.96,42.05 179.71,42.05 179.59,41.92 179.59,41.48 179.47,41.35 179.23,41.35 179.11,41.48 179.11,41.92 178.98,42.05 178.74,42.05 178.62,41.92 178.62,41.48 178.5,41.35 178.25,41.35 178.13,41.48 178.13,41.92 178.01,42.05 177.76,42.05 177.64,41.92 177.64,41.48 177.52,41.35 177.28,41.35 177.15,41.48 177.15,41.92 177.03,42.05 174.27,42.05
  BOTTOM w0.157: v2(224.28,41.89) 225.15,41.03 226.9,41.03 JDIMM2.58 ; JDIMM4.58 212.9,41.03 210.16,41.03 v2(209.4,41.78)
  BOTTOM w0.191: UC1.AN31 v2(161.09,52.54)
DDR_B_D23: length 84.2
  IN3 w0.15: v2(208.13,41.78) 208.13,41.75 208.6,41.28 214.45,41.28 214.58,41.4 214.58,41.91 214.73,42.07 215.18,42.07 215.32,41.93 215.32,41.48 215.51,41.28 215.83,41.28 216.03,41.48 216.03,41.87 216.22,42.07 216.56,42.07 216.76,41.87 216.76,41.48 216.96,41.28 217.3,41.28 217.5,41.48 217.5,41.87 217.7,42.07 218.04,42.07 218.24,41.87 218.24,41.48 218.43,41.28 218.77,41.28 218.97,41.48 218.97,41.87 219.17,42.07 219.48,42.07 219.66,41.88 219.66,41.5 219.86,41.3 220.17,41.3 220.34,41.48 220.34,41.78 220.48,41.92 v2(220.67,41.92)
  IN4 w0.102: v2(162.01,52.54) 162.42,52.13 163.02,52.13 163.37,51.78 163.37,51.46 164.36,50.48 164.36,49.2 167.66,45.89 171.28,45.89 174.27,42.9
  IN4 w0.122: v2(208.13,41.78) 208.18,41.78 208.65,42.25 208.65,42.42 208.42,42.65 207.62,42.65 207.28,42.31 200.11,42.31 199.52,42.9 199.13,42.9 199.01,42.78 199.01,42.33 198.89,42.21 198.64,42.21 198.52,42.33 198.52,42.78 198.4,42.9 198.16,42.9 198.03,42.78 198.03,42.33 197.91,42.21 197.67,42.21 197.55,42.33 197.55,42.78 197.42,42.9 197.18,42.9 197.06,42.78 197.06,42.33 196.94,42.21 196.69,42.21 196.57,42.33 196.57,42.78 196.45,42.9 196.2,42.9 196.08,42.78 196.08,42.33 195.96,42.21 195.72,42.21 195.6,42.33 195.6,42.78 195.47,42.9 195.23,42.9 195.11,42.78 195.11,42.33 194.99,42.21 194.74,42.21 194.62,42.33 194.62,42.78 194.5,42.9 194.25,42.9 194.13,42.78 194.13,42.33 194.01,42.21 193.77,42.21 193.64,42.33 193.64,42.78 193.52,42.9 193.28,42.9 193.16,42.78 193.16,42.77 193.03,42.64 192.79,42.64 192.67,42.77 192.67,42.78 192.55,42.9 174.27,42.9
  BOTTOM w0.157: JDIMM2.59 219.66,41.28 219.93,41.54 219.93,41.79 220.07,41.93 220.66,41.93 v2(220.67,41.92) ; v2(208.13,41.78) 207.63,41.28 JDIMM4.59
  BOTTOM w0.191: UC1.AP31 v2(162.01,52.54)
DDR_B_D24: length 80.2
  IN3 w0.15: v2(224.73,44.25) 224.79,44.25 225.02,44.02 225.02,43.74 224.89,43.61 223.34,43.61 223.04,43.91 223.04,45.08 222.81,45.31 213.23,45.31 212.15,44.23 v2(211.49,44.23)
  IN4 w0.102: v2(158.35,54.37) 158.81,53.91 159.42,53.91 160.41,52.92 163.09,52.92 165.16,50.86 165.16,48.68 167.75,46.1 171.7,46.1 174.27,43.53
  IN4 w0.122: 174.27,43.53 199.78,43.53 200.37,42.94 206.97,42.94 207.31,43.28 210.54,43.28 v2(211.49,44.23)
  BOTTOM w0.157: JDIMM2.70 224.96,44.03 v2(224.73,44.25) ; JDIMM4.70 211.7,44.03 v2(211.49,44.23)
  BOTTOM w0.191: UC1.AL29 v2(158.35,54.37)
DDR_B_D25: length 79.4
  IN3 w0.15: v2(205.96,44.23) 205.96,43.37 206.23,43.09 206.5,43.09 206.84,43.43 207.19,43.43 207.53,43.09 212.43,43.09 213.12,43.78 217.95,43.78 218.14,43.98 218.14,44.11 218.34,44.31 218.74,44.31 218.94,44.11 218.94,43.98 219.13,43.78 219.93,43.78 220.08,43.93 v2(220.08,44.23)
  IN4 w0.102: v2(160.18,54.37) 161.2,53.35 163.3,53.35 165.98,50.67 165.98,50.1 168.94,47.14 172,47.14 174.27,44.87
  IN4 w0.122: v2(205.96,44.23) 205.96,43.94 205.83,43.82 205.41,43.82 205.29,43.94 205.29,44.26 205.16,44.38 204.92,44.38 204.8,44.26 204.8,43.94 204.68,43.82 204.3,43.82 204.18,43.94 204.18,44.26 204.06,44.38 203.82,44.38 203.7,44.26 203.7,43.94 203.57,43.82 200.7,43.82 200.14,44.38 185.54,44.38 185.42,44.5 185.42,44.75 185.3,44.87 185.05,44.87 184.93,44.75 184.93,44.5 184.81,44.38 184.56,44.38 184.44,44.5 184.44,44.75 184.32,44.87 184.08,44.87 183.95,44.75 183.95,44.5 183.83,44.38 183.59,44.38 183.47,44.5 183.47,44.75 183.35,44.87 183.1,44.87 182.98,44.75 182.98,44.5 182.86,44.38 182.61,44.38 182.49,44.5 182.49,44.75 182.37,44.87 182.13,44.87 182,44.75 182,44.5 181.88,44.38 181.64,44.38 181.52,44.5 181.52,44.75 181.39,44.87 181.15,44.87 181.03,44.75 181.03,44.5 180.91,44.38 180.66,44.38 180.54,44.5 180.54,44.75 180.42,44.87 180.18,44.87 180.05,44.75 180.05,44.5 179.93,44.38 179.69,44.38 179.57,44.5 179.57,44.75 179.44,44.87 179.2,44.87 179.08,44.75 179.08,44.5 178.96,44.38 178.71,44.38 178.59,44.5 178.59,44.75 178.47,44.87 178.22,44.87 178.1,44.75 178.1,44.5 177.98,44.38 177.74,44.38 177.61,44.5 177.61,44.75 177.49,44.87 177.25,44.87 177.13,44.75 177.13,44.5 177.01,44.38 176.76,44.38 176.64,44.5 176.64,44.55 176.33,44.87 176.06,44.87 175.93,44.75 175.93,44.5 175.81,44.38 175.45,44.38 175.33,44.5 175.33,44.75 175.2,44.87 174.27,44.87
  BOTTOM w0.157: v2(220.08,44.23) 220.04,44.28 JDIMM2.71 ; JDIMM4.71 205.91,44.28 v2(205.96,44.23)
  BOTTOM w0.191: UC1.AM29 v2(160.18,54.37)
DDR_B_D26: length 79.6
  IN3 w0.15: v2(220.75,50.05) 220.75,50.01 219.98,49.24 219.11,49.24 218.91,49.44 218.91,50.07 218.72,50.26 218.32,50.26 218.12,50.07 218.12,49.44 217.92,49.24 215.03,49.24 214.44,48.65 211.95,48.65 211.36,48.06 209.09,48.06 207.8,46.77 v2(207.8,46.76)
  IN4 w0.102: 174.27,47.12 173.98,47.12 172.1,48.99 168.79,48.99 167.92,49.86 167.92,51.39 165.44,53.86 164.12,53.86 163.76,54.22 162.69,54.22 162.01,54.9 v2(162.01,55.26)
  IN4 w0.122: 174.27,47.12 191.85,47.12 191.97,47 191.97,46.75 192.09,46.63 192.34,46.63 192.46,46.75 192.46,47 192.58,47.12 192.83,47.12 192.95,47 192.95,46.46 193.07,46.34 193.31,46.34 193.43,46.46 193.43,47 193.56,47.12 193.8,47.12 193.92,47 193.92,46.46 194.04,46.34 194.29,46.34 194.41,46.46 194.41,47 194.53,47.12 194.78,47.12 194.9,47 194.9,46.46 195.02,46.34 195.3,46.34 195.42,46.46 195.42,47 195.54,47.12 195.79,47.12 195.91,47 195.91,46.46 196.03,46.34 207.38,46.34 v2(207.8,46.76)
  BOTTOM w0.157: JDIMM2.83 219.69,47.28 220.75,48.33 v2(220.75,50.05) ; JDIMM4.83 207.28,47.28 v2(207.8,46.76)
  BOTTOM w0.191: UC1.AP29 161.58,54.83 v2(162.01,55.26)
DDR_B_D27: length 79.7
  IN3 w0.15: v2(209.07,46.76) 209.07,46.77 209.86,47.56 211.57,47.56 212.16,48.15 214.65,48.15 215.24,48.74 220.19,48.74 220.99,49.54 221.78,49.54 222.02,49.78 224.73,49.78 224.93,49.58 224.93,49.28 v2(224.75,49.1)
  IN4 w0.102: 174.27,47.97 174.1,47.97 172.67,49.4 168.95,49.4 168.55,49.8 168.55,51.33 165.61,54.27 164.36,54.27 164,54.63 163.55,54.63 v2(162.92,55.26)
  IN4 w0.122: 174.27,47.97 205.6,47.97 205.72,47.85 205.72,47.64 205.84,47.52 206.09,47.52 206.21,47.64 206.21,47.85 206.33,47.97 206.66,47.97 206.79,47.85 206.79,47.34 206.91,47.22 207.15,47.22 207.27,47.34 207.27,47.85 207.4,47.97 207.64,47.97 207.76,47.85 207.76,47.34 207.88,47.22 208.13,47.22 208.25,47.34 208.25,47.85 208.37,47.97 208.76,47.97 208.86,47.88 208.86,46.99 209.07,46.78 v2(209.07,46.76)
  BOTTOM w0.157: JDIMM4.84 209.83,47.53 v2(209.07,46.76) ; v2(224.75,49.1) 224.75,48.76 225.98,47.53 JDIMM2.84
  BOTTOM w0.191: UC1.AR29 162.49,54.83 v2(162.92,55.26)
DDR_B_D28: length 81.4
  IN3 w0.15: v2(210.22,44.23) 210.22,44.69 210.42,44.88 212.09,44.88 213.02,45.81 223.4,45.81 223.65,45.57 223.65,44.34 v2(223.55,44.25)
  IN4 w0.102: 174.27,43.96 171.93,46.3 167.83,46.3 165.58,48.55 165.58,50.76 163.2,53.15 160.86,53.15 159.7,54.31 159.7,54.49 159.27,54.92 v2(159.27,55.29)
  IN4 w0.122: v2(210.22,44.23) 209.7,43.71 207.14,43.71 206.82,43.39 200.53,43.39 199.96,43.96 174.27,43.96
  BOTTOM w0.157: JDIMM2.66 226.9,43.03 224.66,43.03 223.55,44.14 v2(223.55,44.25) ; JDIMM4.66 211.43,43.03 v2(210.22,44.23)
  BOTTOM w0.191: UC1.AM28 v2(159.27,55.29)
DDR_B_D29: length 82.2
  IN3 w0.15: v2(207.23,44.23) 207.8,43.66 212.29,43.66 213.44,44.81 221.77,44.81 221.92,44.66 221.92,44.32 221.68,44.08 221.47,44.08 v2(221.3,44.25)
  IN4 w0.102: 174.27,45.29 174.16,45.29 172.11,47.34 169.17,47.34 166.18,50.33 166.18,50.8 163.41,53.57 161.36,53.57 160.62,54.31 160.62,54.49 160.35,54.75 160.01,54.75 159.79,54.97 159.79,55.4 159.41,55.78 158.84,55.78 v2(158.35,55.29)
  IN4 w0.122: 174.27,45.29 186.03,45.29 186.15,45.17 186.15,44.93 186.27,44.81 186.52,44.81 186.64,44.93 186.64,45.17 186.76,45.29 187,45.29 187.12,45.17 187.12,44.93 187.25,44.81 187.49,44.81 187.61,44.93 187.61,45.17 187.73,45.29 187.98,45.29 188.1,45.17 188.1,44.93 188.22,44.81 188.47,44.81 188.59,44.93 188.59,45.17 188.71,45.29 188.95,45.29 189.08,45.17 189.08,44.93 189.2,44.81 189.44,44.81 189.56,44.93 189.56,45.17 189.69,45.29 189.93,45.29 190.05,45.17 190.05,44.93 190.17,44.81 190.42,44.81 190.54,44.93 190.54,45.17 190.66,45.29 190.9,45.29 191.03,45.17 191.03,44.93 191.15,44.81 207.47,44.81 207.59,44.69 207.59,44.35 207.47,44.23 v2(207.23,44.23)
  BOTTOM w0.157: JDIMM4.67 206.32,43.28 207.23,44.18 v2(207.23,44.23) ; v2(221.3,44.25) 220.33,43.28 JDIMM2.67
  BOTTOM w0.191: UC1.AL28 v2(158.35,55.29)
DDR_B_D30: length 77.4
  IN3 w0.15: v2(206.15,46.76) 206.15,48.13 206.33,48.31 206.73,48.31 206.93,48.11 206.93,47.95 207.13,47.75 207.52,47.75 207.72,47.95 207.72,48.37 207.92,48.57 211.15,48.57 211.74,49.16 214.23,49.16 214.86,49.78 216.01,49.78 v2(216.27,50.05)
  IN4 w0.102: 174.27,47.54 173.84,47.54 172.19,49.2 168.87,49.2 168.15,49.92 168.15,51.45 165.53,54.07 164.28,54.07 163.92,54.43 163,54.43 162.51,54.91 162.51,55.75 v2(162.92,56.16)
  IN4 w0.122: 174.27,47.54 196.22,47.54 196.34,47.42 196.34,46.89 196.46,46.77 196.7,46.77 196.82,46.89 196.82,47.42 196.95,47.54 197.19,47.54 197.31,47.42 197.31,46.89 197.43,46.77 197.68,46.77 197.8,46.89 197.8,47.42 197.92,47.54 198.17,47.54 198.29,47.42 198.29,46.89 198.41,46.77 198.65,46.77 198.78,46.89 198.78,47.42 198.9,47.54 199.14,47.54 199.26,47.42 199.26,46.89 199.38,46.77 199.63,46.77 199.75,46.89 199.75,47.42 199.87,47.54 200.12,47.54 200.24,47.42 200.24,47 200.36,46.88 200.6,46.88 200.73,47 200.73,47.42 200.85,47.54 201.09,47.54 201.21,47.42 201.21,47.3 201.34,47.18 201.58,47.18 201.7,47.3 201.7,47.42 201.82,47.54 202.07,47.54 202.19,47.42 202.19,47.39 202.31,47.27 202.55,47.27 202.68,47.39 202.68,47.42 202.8,47.54 204.12,47.54 204.24,47.42 204.24,46.92 204.39,46.77 206.14,46.77 v2(206.15,46.76)
  BOTTOM w0.157: v2(216.27,50.05) 216.48,49.84 216.48,47.17 217.38,46.28 JDIMM2.79 ; JDIMM4.79 205.66,46.28 v2(206.15,46.76)
  BOTTOM w0.191: UC1.AR28 162.5,55.74 v2(162.92,56.16)
DDR_B_D31: length 79.7
  IN3 w0.15: v2(223.48,49.1) 223.48,48.95 222.76,48.24 222.38,48.24 222.18,48.43 222.18,48.83 222.03,48.98 221.54,48.98 221.39,48.83 221.39,48.43 221.19,48.24 215.45,48.24 214.86,47.65 212.37,47.65 211.48,46.76 v2(210.34,46.76)
  IN4 w0.102: v2(162.01,56.16) 162.46,56.61 164.06,56.61 164.36,56.31 164.36,54.94 164.83,54.47 165.7,54.47 169.55,50.62 172.12,50.62 174.27,48.47
  IN4 w0.122: 174.27,48.47 174.34,48.4 209.16,48.4 209.28,48.28 209.28,47.39 209.41,47.27 209.65,47.27 209.77,47.39 209.77,48.28 209.89,48.4 210.21,48.4 210.34,48.28 210.34,47.99 210.46,47.86 210.53,47.86 210.65,47.74 210.65,47.5 210.53,47.38 210.46,47.38 210.34,47.25 v2(210.34,46.76)
  BOTTOM w0.157: JDIMM2.80 226.01,46.53 223.48,49.06 v2(223.48,49.1) ; v2(210.34,46.76) 210.57,46.53 JDIMM4.80
  BOTTOM w0.191: v2(162.01,56.16) 161.59,55.74 UC1.AP28
DDR_B_D32: length 77.8
  IN3 w0.15: v2(211.51,72.83) 212.15,72.18 218.17,72.18 218.37,71.99 218.37,71.54 218.56,71.35 218.96,71.35 219.16,71.54 219.16,71.86 219.36,72.06 219.75,72.06 219.95,71.86 219.95,71.54 220.14,71.34 220.54,71.34 220.74,71.54 220.74,71.78 220.94,71.98 221.34,71.98 221.51,71.8 221.51,71.55 221.66,71.4 222.13,71.4 222.27,71.55 222.27,71.85 222.5,72.08 223.1,72.08 223.59,72.57 v2(223.59,72.83)
  IN4 w0.102: 174.14,73.86 172.46,73.86 171.41,72.81 167.05,72.81 166.2,71.96 166.2,71.73 165.64,71.17 164.56,71.17 163.6,70.22 163.6,70.21 163.07,69.68 162.35,69.68 v2(162,70.03)
  IN4 w0.122: v2(211.51,72.83) 211.52,72.82 212.12,72.82 212.24,72.7 212.24,72.11 212.12,71.98 203.33,71.98 203.02,72.29 199.99,72.29 199.67,71.97 197.17,71.97 195.04,74.11 174.38,74.11 174.14,73.86
  BOTTOM w0.157: v2(223.59,72.83) 223.59,72.86 224,73.28 225.55,73.28 225.78,73.05 225.78,72.16 225.91,72.03 JDIMM2.174 ; JDIMM4.174 211.74,72.03 211.51,72.26 v2(211.51,72.83)
  BOTTOM w0.191: UC1.AR12 162.12,70.03 v2(162,70.03)
DDR_B_D33: length 79.1
  IN3 w0.15: v2(216.03,70.08) 216.03,70.18 215.65,70.56 214.05,70.56 213.28,69.8 206.5,69.8 206.3,70 206.3,70.36 206.5,70.56 207.88,70.56 208.08,70.76 208.08,71.12 207.88,71.32 206.52,71.32 206.32,71.52 206.32,71.91 206.52,72.11 207.77,72.11 207.97,72.31 v2(207.97,72.83)
  IN4 w0.102: 175.62,74.96 173.78,74.96 173.18,74.37 171.86,74.37 171.49,74 167.42,74 166.09,72.67 165.53,72.67 164.52,71.65 163.12,71.65 162.3,70.83 v2(161.21,70.83)
  IN4 w0.122: v2(207.97,72.83) 208.15,73.01 208.15,73.3 208.07,73.39 203.83,73.39 203.59,73.15 201.48,73.15 201.36,73.27 201.36,73.36 201.24,73.48 201,73.48 200.88,73.36 200.88,73.27 200.75,73.15 200.51,73.15 200.39,73.27 200.39,73.64 200.27,73.76 200.02,73.76 199.9,73.64 199.9,73.27 199.78,73.15 199.53,73.15 199.41,73.27 199.41,73.64 199.29,73.76 199.05,73.76 198.92,73.64 198.92,73.27 198.8,73.15 198.56,73.15 198.44,73.27 198.44,73.64 198.32,73.76 198.07,73.76 197.95,73.64 197.95,73.27 197.83,73.15 197.35,73.15 195.53,74.96 175.62,74.96
  BOTTOM w0.157: v2(216.03,70.08) 216.03,70.91 216.89,71.78 218.7,71.78 JDIMM2.173 ; v2(207.97,72.83) 206.91,71.78 JDIMM4.173
  BOTTOM w0.191: UC1.AP12 161.55,70.48 v2(161.21,70.83)
DDR_B_D34: length 85.4
  IN3 w0.15: v2(220.03,75.11) 219.93,75.22 219.49,75.22 219.31,75.03 218.89,75.03 218.71,75.22 210.35,75.22 209.95,74.81 209.62,74.81 209.03,75.4 208.58,75.4 208.37,75.61 208.37,76.06 208.2,76.22 207.38,76.22 207.23,76.07 207.23,75.86 208.24,74.85 208.71,74.85 209.22,74.34 v2(209.22,74.31)
  IN4 w0.102: v2(159.27,69.92) 158.78,70.4 158.78,71.86 159.92,73 164.32,73 165.2,73.88 165.2,74.02 165.63,74.45 165.79,74.45 166.86,75.51 169.36,75.51 171.73,77.87 174.27,77.87
  IN4 w0.122: v2(209.22,74.31) 209.22,74.32 207.39,76.14 198.57,76.14 196.84,77.87 174.27,77.87
  BOTTOM w0.157: JDIMM2.187 219.45,75.27 220.27,76.1 221.8,76.1 221.96,75.94 221.96,75.68 221.82,75.54 220.46,75.54 v2(220.03,75.11) ; v2(209.22,74.31) 209.22,74.39 208.22,75.39 205.87,75.39 205.76,75.28 JDIMM4.187
  BOTTOM w0.191: UC1.AM13 v2(159.27,69.92)
DDR_B_D35: length 82.7
  IN3 w0.15: v2(211.56,74.31) 211.56,74.31 218.15,74.31 218.34,74.12 222.46,74.12 222.66,73.92 222.66,73.53 222.86,73.33 223.25,73.33 223.45,73.53 223.45,73.92 223.65,74.12 224.05,74.12 224.24,73.92 224.24,73.53 224.44,73.33 225.4,73.33 225.64,73.57 225.64,73.97 225.42,74.19 225.2,74.19 225.02,74.36 225.02,74.73 225.29,75 v2(225.29,75.08)
  IN4 w0.102: v2(158.35,69.92) 157.97,70.3 157.97,71.63 159.75,73.41 162.73,73.41 164.63,75.31 164.89,75.31 165.8,76.22 166.67,76.22 169.32,78.88 171.34,78.88
  IN4 w0.122: v2(211.56,74.31) 211.56,74.57 209.89,76.24 209.64,76.24 208.88,77 198.92,77 197.04,78.88 171.34,78.88
  BOTTOM w0.157: v2(225.29,75.08) 225.35,75.02 JDIMM2.186 ; v2(211.56,74.31) 211.56,74.81 211.78,75.03 JDIMM4.186
  BOTTOM w0.191: UC1.AL13 v2(158.35,69.92)
DDR_B_D36: length 80.8
  IN3 w0.15: v2(224.76,72.83) 224.76,70.96 224.56,70.76 224.12,70.76 223.93,70.96 223.93,71.38 223.73,71.58 223.36,71.58 223.16,71.38 223.16,71.04 222.97,70.84 218.17,70.84 217.39,71.62 211.39,71.62 210.34,72.66 v2(210.34,72.83)
  IN4 w0.102: 173.69,74.12 172.42,74.12 171.32,73.01 166.97,73.01 166,72.04 166,71.82 165.56,71.38 164.23,71.38 v2(162.91,70.06)
  IN4 w0.122: v2(210.34,72.83) 210.41,72.76 210.41,72.53 210.29,72.41 207.47,72.41 207.35,72.53 207.35,72.84 207.23,72.96 206.99,72.96 206.86,72.84 206.86,72.53 206.74,72.41 206.5,72.41 206.38,72.53 206.38,72.84 206.25,72.96 206.01,72.96 205.89,72.84 205.89,72.53 205.77,72.41 205.52,72.41 205.4,72.53 205.4,72.84 205.28,72.96 205.03,72.96 204.91,72.84 204.91,72.53 204.79,72.41 204.5,72.41 204.37,72.53 204.37,72.84 204.25,72.96 204.01,72.96 203.89,72.84 203.89,72.53 203.76,72.41 203.5,72.41 203.19,72.72 199.17,72.72 199.05,72.6 199.05,72.52 198.93,72.4 198.68,72.4 198.56,72.52 198.56,72.6 198.44,72.72 198.2,72.72 198.07,72.6 198.07,72.52 197.95,72.4 197.71,72.4 197.59,72.52 197.59,72.6 197.46,72.72 197.17,72.72 195.36,74.53 174.11,74.53 173.69,74.12
  BOTTOM w0.157: JDIMM2.170 226.1,71.03 224.76,72.37 v2(224.76,72.83) ; JDIMM4.170 211.34,71.03 210.34,72.03 v2(210.34,72.83)
  BOTTOM w0.191: v2(162.91,70.06) 162.91,69.9 UC1.AR13
DDR_B_D37: length 83.6
  IN3 w0.15: v2(209.17,72.83) 209.17,72.62 208.76,72.21 208.76,70.44 208.9,70.3 209.35,70.3 209.55,70.5 209.55,71.88 209.7,72.03 210.19,72.03 210.34,71.88 210.34,70.5 210.54,70.3 210.96,70.3 211.16,70.5 211.16,70.91 211.36,71.11 211.76,71.11 211.95,70.91 211.95,70.5 212.15,70.3 212.55,70.3 212.75,70.5 212.75,70.91 212.95,71.11 215.88,71.11 216.26,70.74 216.57,70.74 216.94,71.11 217.18,71.11 217.7,70.58 217.7,70.05 217.91,69.85 218.21,69.85 218.39,70.03 218.39,70.18 218.54,70.33 220.37,70.33 v2(220.62,70.08)
  IN4 w0.102: v2(161.1,69.91) 161.1,70.4 160.82,70.67 160.82,70.99 161.06,71.22 162.4,71.22 163.18,72 164.5,72 165.46,72.97 166.09,72.97 167.33,74.2 171.12,74.2 171.67,74.76 172.69,74.76 173.32,75.39 175.62,75.39
  IN4 w0.122: v2(209.17,72.83) 209.17,73.05 209.37,73.25 209.96,73.25 210.08,73.37 210.08,73.73 209.96,73.85 202.72,73.85 202.38,74.18 196.91,74.18 195.71,75.39 175.62,75.39
  BOTTOM w0.157: v2(209.17,72.83) 207.12,70.78 204.7,70.78 JDIMM4.169 ; v2(220.62,70.08) 219.93,70.78 218.7,70.78 JDIMM2.169
  BOTTOM w0.191: UC1.AP13 v2(161.1,69.91)
DDR_B_D38: length 83.6
  IN3 w0.15: v2(208.05,74.31) 208.05,74.39 206.53,75.92 206.53,76.26 206.94,76.68 208.39,76.68 209.4,75.67 220.74,75.67 221.28,75.13 v2(221.28,75.08)
  IN4 w0.102: v2(159.19,70.9) 159.75,71.45 159.75,71.85 160.56,72.67 164.3,72.67 165.21,73.58 165.84,73.58 167.47,75.21 170.33,75.21 172.05,76.92 173.35,76.92
  IN4 w0.122: 173.35,76.92 174.51,76.92 174.63,77.04 174.63,77.32 174.75,77.45 174.99,77.45 175.11,77.32 175.11,77.04 175.24,76.92 175.48,76.92 175.6,77.04 175.6,77.32 175.72,77.45 175.97,77.45 176.09,77.32 176.09,77.04 176.21,76.92 176.46,76.92 176.58,77.04 176.58,77.32 176.7,77.45 176.94,77.45 177.07,77.32 177.07,77.04 177.19,76.92 177.43,76.92 177.55,77.04 177.55,77.32 177.68,77.45 195.82,77.45 196.13,77.14 196.3,77.14 196.36,77.2 196.53,77.2 196.71,77.03 196.71,76.85 196.65,76.79 196.65,76.62 196.87,76.39 197.05,76.39 197.22,76.57 197.39,76.57 197.57,76.4 197.57,76.22 197.39,76.05 197.39,75.88 197.55,75.72 197.72,75.72 197.97,75.97 198.14,75.97 198.39,75.72 207.22,75.72 208.05,74.88 v2(208.05,74.31)
  BOTTOM w0.157: JDIMM4.183 205.44,74.28 206.1,74.93 207.59,74.93 208.05,74.47 v2(208.05,74.31) ; JDIMM2.183 219.5,74.27 219.63,74.14 221.12,74.14 221.28,74.3 v2(221.28,75.08)
  BOTTOM w0.191: v2(159.19,70.9) 159.2,70.9 UC1.AM12
DDR_B_D39: length 83.6
  IN3 w0.15: v2(224.07,75.08) 224.07,74.73 223.92,74.58 222.78,74.58 222.56,74.8 222.56,75.01 222.64,75.09 222.76,75.09 222.98,75.31 222.98,75.67 222.83,75.82 221.81,75.82 221.66,75.67 221.66,75.39 221.74,75.31 221.74,74.87 221.44,74.58 218.53,74.58 218.34,74.76 210.54,74.76 210.39,74.61 v2(210.39,74.31)
  IN4 w0.102: 174.27,78.3 171.83,78.3 169.33,75.79 166.06,75.79 165.27,75 165.27,74.84 164.86,74.43 164.26,74.43 163.04,73.2 159.83,73.2 158.35,71.72 v2(158.35,70.83)
  IN4 w0.122: v2(210.39,74.31) 210.39,74.88 210.14,75.13 209.97,75.13 209.77,74.93 209.6,74.93 209.43,75.1 209.43,75.27 209.63,75.47 209.63,75.65 209.38,75.9 209.2,75.9 208.94,75.63 208.77,75.63 208.6,75.81 208.6,75.98 208.81,76.19 208.86,76.24 208.86,76.41 208.7,76.57 198.75,76.57 197.02,78.3 174.27,78.3
  BOTTOM w0.157: JDIMM2.182 226.1,74.02 226.01,74.12 224.94,74.12 224.07,74.99 v2(224.07,75.08) ; JDIMM4.182 211.92,74.03 211.76,73.86 210.69,73.86 210.39,74.16 v2(210.39,74.31)
  BOTTOM w0.191: UC1.AL12 v2(158.35,70.83)
DDR_B_D40: length 81
  IN3 w0.15: v2(206.53,79.02) 206.2,79.02 205.82,78.64 205.82,77.8 206,77.61 206.35,77.61 206.48,77.74 206.48,78.33 206.63,78.48 206.98,78.48 207.14,78.33 207.14,77.75 207.4,77.48 219.86,77.48 v2(219.95,77.57)
  IN4 w0.102: 172.13,83.74 166.9,78.51 164.21,78.51 163.46,77.76 163.46,77.44 161.32,75.31 160.76,75.31 160.31,74.86 v2(160.21,74.86)
  IN4 w0.122: v2(206.53,79.02) 203.8,79.02 203.29,79.53 199.1,79.53 197.84,80.79 180.87,80.79 178.67,82.99 178.5,82.99 178.24,82.74 178.07,82.74 177.89,82.91 177.89,83.08 178.15,83.34 178.15,83.51 177.93,83.74 177.46,83.74 177.34,83.61 177.34,82.41 177.22,82.29 176.97,82.29 176.85,82.41 176.85,83.61 176.73,83.74 174.83,83.74 174.71,83.61 174.71,82.41 174.59,82.29 174.34,82.29 174.22,82.41 174.22,83.61 174.1,83.74 172.13,83.74
  BOTTOM w0.102: v2(160.21,74.86) 160.64,74.43 UC1.AP10
  BOTTOM w0.157: JDIMM4.195 206.05,77.28 206.53,77.75 v2(206.53,79.02) ; v2(219.95,77.57) 219.65,77.27 JDIMM2.195
DDR_B_D41: length 79
  IN3 w0.15: v2(211.03,76.77) 211.29,77.03 222.6,77.03 222.68,77.11 224.45,77.11 224.65,77.31 224.65,77.52 224.92,77.79 225.18,77.79 225.44,77.52 225.44,76.66 v2(225.51,76.6)
  IN4 w0.102: v2(162.04,74.06) 162.66,74.06 163.34,74.73 163.34,75.81 165.27,77.75 167.03,77.75 168.93,79.65 170.18,79.65 171.96,81.43 174.27,81.43
  IN4 w0.122: v2(211.03,76.77) 209.75,78.05 199.36,78.05 197.48,79.93 177.99,79.93 177.86,80.06 177.86,80.34 177.74,80.47 177.5,80.47 177.38,80.34 177.38,80.06 177.25,79.93 177,79.93 176.87,80.06 176.87,81.31 176.75,81.43 176.51,81.43 176.39,81.31 176.39,80.06 176.26,79.93 176.02,79.93 175.9,80.06 175.9,81.31 175.78,81.43 174.27,81.43
  BOTTOM w0.102: v2(162.04,74.06) 161.7,74.4 UC1.AR10
  BOTTOM w0.157: v2(225.51,76.6) 225.93,77.03 225.93,77.02 JDIMM2.194 ; v2(211.03,76.77) 211.29,77.03 JDIMM4.194
DDR_B_D42: length 78.6
  IN3 w0.15: v2(221.31,80.24) 221.31,80.23 220.77,79.68 217.5,79.68 217.26,79.93 212.43,79.93 212.2,80.15 210.32,80.15 209.69,79.53 207.43,79.53 206.07,80.89 v2(206.07,80.95)
  IN4 w0.102: 171.65,84.99 166.97,80.31 165.4,80.31 165,79.91 163.77,79.91 162.39,78.52 162.39,77.98 v2(162.01,77.6)
  IN4 w0.122: v2(206.07,80.95) 205.97,81.05 203.89,81.05 203.24,81.7 199.09,81.7 198.47,82.32 189.64,82.32 189.52,82.44 189.52,82.51 189.4,82.64 189.16,82.64 189.04,82.51 189.04,82.44 188.91,82.32 188.57,82.32 188.44,82.44 188.44,82.71 188.32,82.83 188.08,82.83 187.96,82.71 187.96,82.44 187.83,82.32 187.59,82.32 187.47,82.44 187.47,82.71 187.35,82.83 187.1,82.83 186.98,82.71 186.98,82.46 186.86,82.34 186.61,82.34 186.49,82.46 186.49,82.71 186.37,82.83 186.13,82.83 186,82.71 186,82.46 185.88,82.34 185.64,82.34 185.52,82.46 185.52,82.71 185.4,82.83 185.15,82.83 185.03,82.71 185.03,82.46 184.91,82.34 184.66,82.34 184.54,82.46 184.54,82.71 184.42,82.83 184.18,82.83 184.05,82.71 184.05,82.46 183.93,82.34 183.69,82.34 183.57,82.46 183.57,82.71 183.44,82.83 183.2,82.83 183.08,82.71 183.08,82.46 182.96,82.34 182.71,82.34 182.59,82.46 182.59,82.71 182.47,82.83 182.23,82.83 182.1,82.71 182.1,82.46 181.98,82.34 181.74,82.34 181.62,82.46 181.62,82.71 181.49,82.83 181,82.83 178.56,85.27 171.93,85.27 171.65,84.99
  BOTTOM w0.157: JDIMM4.207 205.6,80.28 205.92,79.96 206.65,79.96 206.78,80.08 206.78,80.37 206.65,80.49 206.2,80.49 206.07,80.62 v2(206.07,80.95) ; JDIMM2.207 219.44,80.27 219.89,80.72 220.83,80.72 v2(221.31,80.24)
  BOTTOM w0.191: UC1.AR7 v2(162.01,77.6)
DDR_B_D43: length 79.8
  IN3 w0.15: v2(209.57,80.95) 209.57,81.05 209.72,81.2 212.57,81.2 212.67,81.1 213.82,81.1 214.09,80.83 215.28,80.83 215.55,81.1 217.51,81.1 217.8,80.82 222.53,80.82 222.68,80.67 222.68,80.43 222.49,80.24 v2(222.48,80.24)
  IN4 w0.102: v2(161.09,77.6) 161.09,77.66 160.71,78.04 160.71,78.98 161.57,79.84 161.57,80.44 161.92,80.8 162.37,80.8 163.14,81.56 165.85,81.56 169.28,84.99
  IN4 w0.122: 169.28,84.99 170.85,86.55 179.09,86.55 181.48,84.16 198.44,84.16 199.62,82.98 203.77,82.98 204.14,82.61 207.97,82.61 209.57,81 v2(209.57,80.95)
  BOTTOM w0.157: v2(222.48,80.24) 222.33,80.39 222.33,80.57 222.61,80.85 225.48,80.85 225.8,80.53 226.9,80.53 JDIMM2.208 ; JDIMM4.208 212.9,80.53 210,80.53 v2(209.57,80.95)
  BOTTOM w0.191: UC1.AP7 v2(161.09,77.6)
DDR_B_D44: length 81.5
  IN3 w0.15: v2(221.12,77.57) 221.12,77.64 220.75,78 209.37,78 209.09,78.28 209.09,78.86 208.88,79.07 208.6,79.07 208.38,78.86 208.38,78.13 208.23,77.98 207.85,77.98 207.7,78.13 v2(207.7,79.02)
  IN4 w0.102: v2(162.08,74.83) 162.08,75.47 162.81,76.2 163.21,76.2 165.13,78.12 166.9,78.12 168.79,80.01 170.01,80.01 171.85,81.86 174.27,81.86
  IN4 w0.122: 174.27,81.86 178.19,81.86 178.31,81.74 178.31,80.51 178.43,80.39 178.67,80.39 178.79,80.51 178.79,81.74 178.92,81.86 179.16,81.86 179.28,81.74 179.28,80.51 179.4,80.39 179.65,80.39 179.77,80.51 179.77,80.8 179.89,80.92 180.14,80.92 180.26,80.8 180.26,80.51 180.41,80.36 197.66,80.36 199.43,78.59 207.27,78.59 207.7,79.01 v2(207.7,79.02)
  BOTTOM w0.102: v2(162.08,74.83) 161.59,75.32 UC1.AR9
  BOTTOM w0.157: v2(207.7,79.02) 207.7,77.32 206.65,76.28 JDIMM4.191 ; JDIMM2.191 219.51,76.27 220.14,76.91 221.79,76.91 221.9,77.02 221.9,77.43 221.76,77.57 v2(221.12,77.57)
DDR_B_D45: length 81.3
  IN3 w0.15: v2(209.76,76.77) 209.76,76.48 209.91,76.33 212.58,76.33 212.72,76.47 223.55,76.47 223.75,76.27 223.75,75.82 223.9,75.67 224.26,75.67 224.46,75.87 224.46,76.38 v2(224.24,76.6)
  IN4 w0.102: 172.97,81.01 172.4,81.01 170.66,79.27 169.06,79.27 167.32,77.53 165.97,77.53 164.23,75.79 164.23,75.34 162.57,73.68 161.88,73.68 161.09,74.47 v2(161.09,74.86)
  IN4 w0.122: v2(209.76,76.77) 209.76,77.03 209.16,77.63 199.18,77.63 197.3,79.51 175.57,79.51 175.45,79.63 175.45,80.46 175.3,80.6 175.11,80.6 174.96,80.46 174.96,79.63 174.84,79.51 174.6,79.51 174.48,79.63 174.48,80.88 174.35,81.01 172.97,81.01
  BOTTOM w0.157: JDIMM4.190 212.2,76.03 212.05,75.88 210.3,75.88 209.71,76.47 209.71,76.72 v2(209.76,76.77) ; v2(224.24,76.6) 224.24,76.42 224.63,76.02 JDIMM2.190
  BOTTOM w0.191: UC1.AP9 v2(161.09,74.86)
DDR_B_D46: length 77.8
  IN3 w0.15: v2(220.04,80.24) 220.02,80.26 217.64,80.26 217.52,80.38 212.68,80.38 212.41,80.65 210.11,80.65 209.44,79.98 208.94,79.98 208.79,80.13 208.79,80.31 208.61,80.49 208.28,80.49 208.13,80.34 208.13,80.13 207.98,79.98 207.62,79.98 207.05,80.55 207.05,80.76 v2(207.24,80.95)
  IN4 w0.102: v2(162.01,78.52) 162.71,79.22 162.71,79.76 163.88,80.92 167.12,80.92 171.18,84.99
  IN4 w0.122: 171.18,84.99 171.18,85.12 171.75,85.7 178.74,85.7 181.13,83.31 191.88,83.31 192,83.19 192,82.87 192.13,82.75 192.37,82.75 192.49,82.87 192.49,83.19 192.61,83.31 192.86,83.31 192.98,83.19 192.98,82.87 193.1,82.75 193.34,82.75 193.47,82.87 193.47,83.19 193.59,83.31 193.83,83.31 193.95,83.19 193.95,82.87 194.08,82.75 194.32,82.75 194.44,82.87 194.44,83.19 194.56,83.31 194.81,83.31 194.93,83.19 194.93,82.87 195.05,82.75 195.3,82.75 195.42,82.87 195.42,83.01 195.54,83.13 195.78,83.13 195.9,83.01 195.9,82.87 196.03,82.75 198.65,82.75 199.27,82.13 203.41,82.13 203.97,81.57 206.72,81.57 207.24,81.05 v2(207.24,80.95)
  BOTTOM w0.157: v2(220.04,80.24) 220.04,79.9 220.17,79.78 221.06,79.78 221.23,79.6 221.23,79.22 221.11,79.09 219.71,79.09 219.53,79.27 JDIMM2.203 ; JDIMM4.203 205.92,79.28 206.12,79.47 206.83,79.47 207.24,79.88 v2(207.24,80.95)
  BOTTOM w0.191: UC1.AR6 v2(162.01,78.52)
DDR_B_D47: length 80.7
  IN3 w0.15: v2(223.65,80.24) 223.86,80.44 223.86,80.67 224.02,80.83 224.02,81.02 223.72,81.32 218.01,81.32 217.77,81.56 212.93,81.56 212.83,81.66 208.56,81.66 208.41,81.51 v2(208.41,80.95)
  IN4 w0.102: 169.89,84.99 166.2,81.3 163.57,81.3 162.17,79.91 161.95,79.91 161.09,79.06 v2(161.09,78.52)
  IN4 w0.122: v2(208.41,80.95) 208.41,81.25 207.57,82.09 204.06,82.09 203.59,82.55 199.45,82.55 198.82,83.18 197.51,83.18 197.39,83.3 197.39,83.47 197.27,83.59 197.03,83.59 196.9,83.47 196.9,83.3 196.78,83.18 196.54,83.18 196.42,83.3 196.42,83.61 196.3,83.74 181.3,83.74 178.92,86.12 171.02,86.12 169.89,84.99
  BOTTOM w0.157: JDIMM4.204 212.9,79.53 209.6,79.53 208.41,80.72 v2(208.41,80.95) ; JDIMM2.204 226.9,79.53 225.68,79.53 225.42,79.78 223.95,79.78 223.65,80.08 v2(223.65,80.24)
  BOTTOM w0.191: UC1.AP6 v2(161.09,78.52)
DDR_B_D48: length 87.8
  IN3 w0.15: v2(224.3,84.12) 224.3,83.52 223.89,83.11 222.45,83.11 222.4,83.05 218.7,83.05 218.21,83.54 211.43,83.54 v2(211.03,83.94)
  IN4 w0.102: 163.92,83.08 163.55,82.71 161.46,82.71 159.3,80.55 159.3,76.01 158.35,75.06 v2(158.35,74.86)
  IN4 w0.122: v2(211.03,83.94) 211.03,84.42 210.61,84.84 204.66,84.84 204.14,85.36 199.95,85.36 199.23,86.07 195.23,86.07 195.11,86.2 195.11,86.46 194.98,86.59 194.74,86.59 194.62,86.46 194.62,86.2 194.5,86.07 194.25,86.07 194.13,86.2 194.13,86.4 194.01,86.52 193.77,86.52 193.64,86.4 193.64,86.2 193.52,86.07 193.21,86.07 193.09,86.2 193.09,86.55 192.97,86.67 192.72,86.67 192.6,86.55 192.6,86.2 192.48,86.07 192.24,86.07 192.11,86.2 192.11,86.58 191.99,86.7 181.65,86.7 179.88,88.46 169.93,88.46 165.19,83.72 164.54,83.72 163.92,83.1 163.92,83.08
  BOTTOM w0.102: UC1.AM10 v2(158.35,74.86)
  BOTTOM w0.157: JDIMM2.216 226.9,82.53 225.83,82.53 224.3,84.05 v2(224.3,84.12) ; JDIMM4.216 211.45,82.53 211.3,82.67 211.3,83.03 211.73,83.46 211.73,83.82 211.61,83.94 v2(211.03,83.94)
DDR_B_D49: length 91.1
  IN3 w0.15: v2(223.11,84.1) 223.11,84.02 222.7,83.61 222.24,83.61 222.19,83.56 220.18,83.56 219.89,83.84 219.48,83.84 219.19,83.56 218.9,83.56 218.42,84.04 212.67,84.04 212.3,84.41 210.13,84.41 209.76,84.04 v2(209.76,83.94)
  IN4 w0.102: v2(158.35,73.94) 158.83,74.42 158.83,75.25 159.55,75.97 159.55,80.52 161.54,82.51 163.92,82.51 164.24,82.83 164.24,83.11 164.55,83.43 165.5,83.43 167.06,84.99
  IN4 w0.122: 167.06,84.99 170.11,88.03 179.71,88.03 181.47,86.27 188.55,86.27 188.67,86.15 188.67,85.8 188.79,85.68 189.03,85.68 189.16,85.8 189.16,86.15 189.28,86.27 189.52,86.27 189.64,86.15 189.64,85.8 189.77,85.68 190.01,85.68 190.13,85.8 190.13,86.15 190.25,86.27 190.5,86.27 190.62,86.15 190.62,85.8 190.74,85.68 190.98,85.68 191.11,85.8 191.11,86.01 191.23,86.13 191.47,86.13 191.59,86.01 191.59,85.77 191.72,85.65 199.05,85.65 199.86,84.84 204.06,84.84 204.52,84.38 209.55,84.38 209.76,84.17 v2(209.76,83.94)
  BOTTOM w0.157: JDIMM4.215 206.61,82.28 208.09,82.28 v2(209.76,83.94) ; v2(223.11,84.1) 221.29,82.27 JDIMM2.215
  BOTTOM w0.191: UC1.AL10 v2(158.35,73.94)
DDR_B_D50: length 85
  IN3 w0.15: v2(211.23,86.15) 213.16,86.15 213.54,85.78 219.3,85.78 219.41,85.67 221.59,85.67 222.22,85.04 225.28,85.04 225.68,85.43 v2(225.68,85.49)
  IN4 w0.102: v2(158.36,77.57) 157.7,78.23 157.7,81.49 158.5,82.3 159.34,82.3 159.35,82.31
  IN4 w0.122: 159.35,82.31 160.17,83.13 160.17,84.02 160.65,84.49 160.65,84.51 160.78,84.64 162.53,84.64 168.31,90.42 183.84,90.42 185.6,88.66 195.71,88.66 196.34,88.03 201.68,88.03 201.8,88.16 201.8,88.29 201.93,88.42 202.17,88.42 202.29,88.29 202.29,88.16 202.41,88.03 203.24,88.03 203.37,88.16 203.37,88.38 203.49,88.51 203.73,88.51 203.85,88.38 203.85,88.16 203.98,88.03 204.22,88.03 204.34,88.16 204.34,88.38 204.46,88.51 204.71,88.51 204.83,88.38 204.83,88.16 204.95,88.03 205.13,88.03 206.06,87.1 210.28,87.1 v2(211.23,86.15)
  BOTTOM w0.157: v2(225.68,85.49) 225.71,85.53 226.9,85.53 JDIMM2.228 ; v2(211.23,86.15) 211.23,85.47 211.35,85.34 211.68,85.34 211.86,85.53 212.9,85.53 JDIMM4.228
  BOTTOM w0.191: v2(158.36,77.57) 158.78,77.14 UC1.AM7
DDR_B_D51: length 87.9
  IN3 w0.15: v2(214.53,86.76) 214.01,87.28 210.36,87.28 210.05,86.97 207.29,86.97 207.16,86.84 207.16,85.9 207.01,85.75 206.5,85.75 206.35,85.9 206.35,87.63 206.53,87.81 207.43,87.81 v2(207.57,87.67)
  IN4 w0.102: v2(157.44,76.69) 157.82,77.07 157.82,77.82 157.47,78.17 157.47,81.56 159.39,83.47 159.39,84.13 160.25,84.99
  IN4 w0.122: v2(207.57,87.67) 207.57,88.21 207.45,88.33 207.02,88.33 206.9,88.21 206.9,87.97 206.78,87.84 206.54,87.84 206.41,87.97 206.41,88.21 206.29,88.33 205.94,88.33 205.35,88.93 201.35,88.93 201.23,88.81 201.23,88.58 201.11,88.46 200.87,88.46 200.74,88.58 200.74,88.81 200.62,88.93 200.38,88.93 200.26,88.81 200.26,88.58 200.14,88.46 199.89,88.46 199.77,88.58 199.77,88.81 199.65,88.93 199.27,88.93 199.15,88.81 199.15,88.58 199.02,88.46 198.78,88.46 198.66,88.58 198.66,88.96 198.54,89.09 198.29,89.09 198.17,88.96 198.17,88.58 198.05,88.46 197.81,88.46 197.68,88.58 197.68,88.96 197.56,89.09 197.32,89.09 197.2,88.96 197.2,88.58 197.07,88.46 196.83,88.46 196.71,88.58 196.71,88.96 196.59,89.09 185.78,89.09 184.02,90.85 168.14,90.85 163.23,85.94 162.14,85.94 161.19,84.99 160.25,84.99
  BOTTOM w0.157: v2(207.57,87.67) 207.34,87.67 205.45,85.78 JDIMM4.229 ; JDIMM2.229 218.7,85.78 214.75,85.78 214.53,86 v2(214.53,86.76)
  BOTTOM w0.191: UC1.AL7 v2(157.44,76.69)
DDR_B_D52: length 89.2
  IN3 w0.15: v2(222.91,82.15) 222.74,81.98 221.77,81.98 221.6,82.14 221.02,82.14 220.85,81.98 220.27,81.98 220.1,82.14 219.52,82.14 219.36,81.98 218.35,81.98 217.8,82.53 213.6,82.53 213.39,82.32 212.41,82.32 212.26,82.47 212.26,82.48 212.11,82.63 211.66,82.63 211.51,82.48 211.51,82.47 211.36,82.32 209.53,82.32 209.38,82.47 209.38,82.69 v2(209.44,82.75)
  IN4 w0.102: v2(159.27,74.86) 159.81,75.4 159.81,80.49 161.62,82.3 164.69,82.3 167.38,84.99
  IN4 w0.122: v2(209.44,82.75) 209.44,82.88 208.47,83.85 204.39,83.85 203.92,84.32 199.78,84.32 198.88,85.22 188.37,85.22 188.25,85.34 188.25,85.37 188.13,85.49 187.88,85.49 187.76,85.37 187.76,85.34 187.64,85.22 187.4,85.22 187.27,85.34 187.27,85.72 187.15,85.84 186.91,85.84 186.79,85.72 186.79,85.34 186.66,85.22 186.42,85.22 186.3,85.34 186.3,85.72 186.18,85.84 185.93,85.84 185.81,85.72 185.81,85.34 185.69,85.22 185.42,85.22 185.3,85.34 185.3,85.72 185.17,85.84 184.93,85.84 184.81,85.72 184.81,85.39 184.69,85.27 184.44,85.27 184.32,85.39 184.32,85.72 184.2,85.84 181.29,85.84 179.53,87.61 170.41,87.61 167.79,84.99 167.38,84.99
  BOTTOM w0.102: UC1.AM9 v2(159.27,74.86)
  BOTTOM w0.157: v2(209.44,82.75) 209.44,82.69 208.51,81.76 206.55,81.76 206.25,81.46 205.59,81.46 205.41,81.28 JDIMM4.211 ; JDIMM2.211 219.48,81.27 219.85,81.65 222.41,81.65 v2(222.91,82.15)
DDR_B_D53: length 88.2
  IN3 w0.15: v2(224.08,82.15) 224.08,82.21 223.68,82.6 222.45,82.6 222.45,82.6 218.44,82.6 217.95,83.09 210.95,83.09 v2(210.61,82.75)
  IN4 w0.102: 168.39,84.99 168.11,84.7 168.11,84.48 166.19,82.56 165.44,82.56 164.97,82.09 162.28,82.09 160.7,80.51 160.7,79.37 160.51,79.18 160.51,77.96 160.59,77.88 160.59,75.62 160.33,75.36 160.17,75.36 159.69,74.88 159.69,74.74 158.51,73.56 158.19,73.56 157.86,73.9 157.86,74.43 v2(157.44,74.86)
  IN4 w0.122: 168.39,84.99 170.58,87.18 179.35,87.18 181.12,85.42 181.7,85.42 181.82,85.3 181.82,84.96 181.94,84.83 182.19,84.83 182.31,84.96 182.31,85.3 182.43,85.42 182.67,85.42 182.8,85.3 182.8,84.96 182.92,84.83 183.16,84.83 183.28,84.96 183.28,85.3 183.41,85.42 183.65,85.42 183.77,85.3 183.77,84.92 183.89,84.79 198.7,84.79 199.7,83.8 203.84,83.8 204.31,83.33 208.14,83.33 209.28,82.19 210.21,82.19 210.61,82.59 v2(210.61,82.75)
  BOTTOM w0.157: v2(210.61,82.75) 210.61,82.02 211.11,81.53 212.9,81.53 JDIMM4.212 ; v2(224.08,82.15) 224.08,81.94 224.49,81.53 JDIMM2.212
  BOTTOM w0.191: UC1.AL9 v2(157.44,74.86)
DDR_B_D54: length 86.4
  IN3 w0.15: v2(224.51,85.49) 223.83,86.17 223.4,86.17 223.25,86.02 223.25,85.93 223.1,85.78 222.65,85.78 222.5,85.93 222.5,86.02 222.35,86.17 219.62,86.17 219.51,86.28 213.82,86.28 213.41,86.69 210.48,86.69 210.01,86.21 v2(210.01,86.15)
  IN4 w0.102: 160.87,84.41 160.43,83.97 160.43,83.08 159.44,82.09 158.62,82.09 157.94,81.42 157.94,78.9 v2(158.33,78.52)
  IN4 w0.122: 160.87,84.41 162.91,84.41 168.49,89.99 181.46,89.99 181.59,89.87 181.59,89.2 181.71,89.08 181.95,89.08 182.07,89.2 182.07,89.87 182.19,89.99 183.67,89.99 185.43,88.23 195.53,88.23 196.16,87.61 204.16,87.61 204.29,87.49 204.29,87.09 204.4,86.97 205.56,86.97 205.85,86.68 209.47,86.68 209.99,86.15 v2(210.01,86.15)
  BOTTOM w0.157: JDIMM4.224 210.19,84.53 209.93,84.78 209.93,85.11 210.2,85.39 210.2,85.96 v2(210.01,86.15) ; v2(224.51,85.49) 224.51,85.45 225.4,84.55 225.81,84.55 225.83,84.53 226.9,84.53 JDIMM2.224
  BOTTOM w0.191: v2(158.33,78.52) 158.78,78.06 UC1.AM6
DDR_B_D55: length 88.9
  IN3 w0.15: v2(208.88,87.65) 209.01,87.78 214.22,87.78 214.73,87.27 217.62,87.27 218.11,86.78 219.71,86.78 219.83,86.67 222.26,86.67 222.67,87.09 v2(222.67,87.16)
  IN4 w0.102: v2(157.44,77.6) 157.27,77.77 157.27,81.64 159.16,83.53 159.16,84.35 160.17,85.37 161.06,85.37 162.08,86.38 163.07,86.38 164.59,87.91
  IN4 w0.122: v2(208.88,87.65) 209.26,87.65 209.51,87.91 209.51,88.45 209.2,88.76 206.25,88.76 205.66,89.36 199.95,89.36 199.79,89.51 185.96,89.51 184.2,91.27 167.96,91.27 164.59,87.91
  BOTTOM w0.102: UC1.AL6 v2(157.44,77.6)
  BOTTOM w0.157: JDIMM4.225 205.55,84.78 207.92,87.15 208.46,87.15 208.88,87.57 v2(208.88,87.65) ; v2(222.67,87.16) 222.67,87.06 220.39,84.78 JDIMM2.225
DDR_B_D56: length 97.3
  IN3 w0.15: v2(220.34,87.16) 220.01,87.49 218.45,87.49 218.24,87.7 218.24,88.33 218.08,88.49 207.69,88.49 207.33,88.85 206.76,88.85 206.55,89.05 v2(206.55,89.49)
  IN4 w0.102: v2(156.53,78.52) 157.07,79.06 157.07,81.73 158.77,83.43 158.77,84.27
  IN4 w0.122: 158.77,84.27 160.19,85.68 161.08,85.68 163.3,87.91 163.7,87.91 167.7,91.9 184.93,91.9 185.06,91.78 185.06,91.31 185.18,91.18 185.42,91.18 185.54,91.31 185.54,91.78 185.66,91.9 185.98,91.9 186.1,91.78 186.1,90.26 186.22,90.14 186.46,90.14 186.59,90.26 186.59,91.76 186.73,91.9 186.95,91.9 187.07,91.78 187.07,90.26 187.19,90.14 187.44,90.14 187.56,90.26 187.56,91.76 187.71,91.9 187.93,91.9 188.05,91.78 188.05,90.26 188.17,90.14 188.41,90.14 188.54,90.26 188.54,91.76 188.68,91.9 188.9,91.9 189.02,91.78 189.02,90.36 189.15,90.24 189.39,90.24 189.52,90.36 189.52,91.78 189.64,91.9 189.88,91.9 190,91.78 190,90.36 190.13,90.24 190.37,90.24 190.49,90.36 190.49,91.78 190.61,91.9 190.86,91.9 190.98,91.78 190.98,90.36 191.1,90.24 202.13,90.24 202.19,90.18 205.73,90.18 206.09,89.81 206.3,89.81 206.55,89.55 v2(206.55,89.49)
  BOTTOM w0.102: UC1.AJ6 v2(156.53,78.52)
  BOTTOM w0.157: JDIMM2.237 219.73,87.78 v2(220.34,87.16) ; v2(206.55,89.49) 206.55,88.7 205.63,87.78 JDIMM4.237
DDR_B_D57: length 99.2
  IN3 w0.15: v2(223.84,87.16) 223.84,87.19 223.1,87.93 221.67,87.93 220.93,88.67 219.56,88.67 218.68,89.55 210.12,89.55 v2(210.06,89.49)
  IN4 w0.102: v2(155.61,76.69) 155.02,77.27 155.02,78.32 154.84,78.5 154.84,79.68 155.47,80.31 155.47,81.3 156.62,82.45 156.62,83.47
  IN4 w0.122: v2(210.06,89.49) 210.84,89.49 210.97,89.62 210.97,90.7 210.72,90.96 208.44,90.96 207.83,91.56 204.19,91.56 203.84,91.91 202.49,91.91 202.1,91.52 201.28,91.52 201.16,91.64 201.16,92.94 201.04,93.06 200.79,93.06 200.67,92.94 200.67,91.64 200.55,91.52 200.31,91.52 200.18,91.64 200.18,93.06 200.06,93.18 199.82,93.18 199.7,93.06 199.7,91.83 199.57,91.71 199.33,91.71 199.21,91.83 199.21,93.06 199.09,93.18 167.17,93.18 165.12,91.13 163.18,91.13 157.23,85.19 157.23,84.08 156.62,83.47
  BOTTOM w0.102: UC1.AJ7 v2(155.61,76.69)
  BOTTOM w0.157: v2(210.06,89.49) 210.06,89.2 211.73,87.53 212.9,87.53 JDIMM4.236 ; v2(223.84,87.16) 223.84,87.29 224.21,87.65 225.73,87.65 225.86,87.53 JDIMM2.236
DDR_B_D58: length 100.5
  IN3 w0.15: v2(207.4,93.32) 207.19,93.11 207.19,91.31 207.37,91.13 207.85,91.13 207.97,91.26 207.97,92.09 208.13,92.25 210.09,92.25 210.29,92.05 216.81,92.05 217.1,91.76 220.11,91.76 v2(220.43,91.44)
  IN4 w0.102: 156.13,88.79 156.13,88.78 ; v2(151.96,78.66) 151.96,79.98 154.79,82.81 154.79,84.55 154.74,84.6 154.74,84.99
  IN4 w0.122: 154.74,84.99 154.74,87.4 156.13,88.78 ; 156.13,88.79 157.76,90.41 157.93,90.41 158.34,90 158.52,90 158.77,90.26 158.77,90.43 158.36,90.84 158.36,91.02 160.01,92.67 164.48,92.67 166.53,94.72 192.1,94.72 192.22,94.84 192.22,94.9 192.35,95.02 192.59,95.02 192.71,94.9 192.71,94.84 192.83,94.72 193.06,94.72 193.18,94.84 193.18,95.06 193.3,95.18 193.54,95.18 193.67,95.06 193.67,94.84 193.79,94.72 194.03,94.72 194.15,94.84 194.15,95.06 194.28,95.18 194.52,95.18 194.64,95.06 194.64,94.84 194.76,94.72 195.01,94.72 195.13,94.84 195.13,95.06 195.25,95.18 195.5,95.18 195.62,95.06 195.62,94.84 195.74,94.72 195.98,94.72 196.11,94.84 196.11,95.06 196.23,95.18 196.47,95.18 196.59,95.06 196.59,94.84 196.71,94.72 196.96,94.72 197.08,94.84 197.08,95.06 197.2,95.18 197.45,95.18 197.57,95.06 197.57,94.84 197.69,94.72 197.93,94.72 198.06,94.84 198.06,95.06 198.18,95.18 198.42,95.18 198.54,95.06 198.54,94.84 198.67,94.72 201.13,94.72 201.25,94.84 201.25,95.06 201.37,95.18 201.62,95.18 201.74,95.06 201.74,94.84 201.86,94.72 202.1,94.72 202.23,94.84 202.23,95.06 202.35,95.18 206.02,95.18 206.14,95.06 206.14,93.84 206.26,93.72 206.51,93.72 206.63,93.84 206.63,95.06 206.75,95.18 207.11,95.18 207.51,94.78 207.51,93.43 v2(207.4,93.32)
  BOTTOM w0.102: UC1.AE6 151.96,78.51 v2(151.96,78.66)
  BOTTOM w0.157: JDIMM4.249 206.02,90.78 207.4,92.15 v2(207.4,93.32) ; v2(220.43,91.44) 219.77,90.78 JDIMM2.249
DDR_B_D59: length 100.9
  IN3 w0.15: v2(223.01,91.44) 223.01,91.95 221.91,93.05 210.75,93.05 210.49,93.32 v2(210.4,93.32)
  IN4 w0.102: v2(152.92,76.74) 152.58,77.09 150.89,77.09 150.32,77.66 150.32,80.43 152.03,82.14 152.95,82.14 153.59,82.78 153.59,84.03 153.57,84.06 153.57,84.61 153.46,84.71 153.46,84.99
  IN4 w0.122: v2(210.4,93.32) 210.51,93.32 210.79,93.6 210.79,94.38 208.71,96.46 184.65,96.46 184.18,96 166,96 163.95,93.95 159.48,93.95 153.46,87.93 153.46,84.99
  BOTTOM w0.157: JDIMM2.250 225.33,91.02 224.38,91.97 223.42,91.97 223.01,91.57 v2(223.01,91.44) ; v2(210.4,93.32) 210.4,92.77 211.51,91.67 211.51,91.54 212.02,91.03 JDIMM4.250
  BOTTOM w0.191: UC1.AF7 v2(152.92,76.74)
DDR_B_D60: length 101.5
  IN3 w0.15: v2(225.01,87.16) 225.01,87.22 223.8,88.44 221.87,88.44 221.19,89.12 219.82,89.12 218.89,90.05 209.4,90.05 208.89,89.54 v2(208.89,89.49)
  IN4 w0.102: v2(155.61,77.61) 155.23,77.99 155.23,78.4 155.11,78.51 155.11,79.6 155.67,80.16 155.67,80.91 157.46,82.69 157.46,84.47
  IN4 w0.122: 157.46,84.47 157.46,84.81 163.36,90.71 165.3,90.71 167.35,92.76 195.73,92.76 195.86,92.64 195.86,91.21 195.98,91.09 196.22,91.09 196.34,91.21 196.34,92.64 196.47,92.76 196.71,92.76 196.83,92.64 196.83,91.21 196.95,91.09 197.2,91.09 197.32,91.21 197.32,92.64 197.44,92.76 197.69,92.76 197.81,92.64 197.81,91.27 197.93,91.14 198.17,91.14 198.29,91.27 198.29,92.64 198.42,92.76 198.66,92.76 198.78,92.64 198.78,91.21 198.9,91.09 199.15,91.09 199.34,91.29 199.69,91.29 199.88,91.09 202.28,91.09 202.67,91.48 203.67,91.48 204.02,91.13 207.66,91.13 208.26,90.53 209.01,90.53 209.13,90.41 209.13,90.02 208.89,89.78 v2(208.89,89.49)
  BOTTOM w0.102: UC1.AH7 v2(155.61,77.61)
  BOTTOM w0.157: v2(225.01,87.16) 225.65,86.53 226.9,86.53 JDIMM2.232 ; v2(208.89,89.49) 208.89,89.23 211.59,86.53 JDIMM4.232
DDR_B_D61: length 99.3
  IN3 w0.15: v2(207.72,89.49) 207.72,89.16 207.9,88.99 218.53,88.99 218.75,88.77 218.75,88.27 219.02,87.99 219.57,87.99 219.79,88.21 220.67,88.21 221.51,87.38 v2(221.51,87.16)
  IN4 w0.102: v2(155.61,78.52) 155.88,78.79 155.88,80.39 156.39,80.9 156.39,81.34 157.67,82.62 157.67,84.42 158.01,84.76
  IN4 w0.122: v2(207.72,89.49) 207.72,90.33 207.6,90.45 207.25,90.45 207.16,90.36 207.16,90.1 207.04,89.98 206.73,89.98 206.61,90.1 206.61,90.48 206.49,90.6 202.67,90.6 202.61,90.67 195.59,90.67 195.43,90.82 195.43,92.21 195.31,92.33 195.06,92.33 194.94,92.21 194.94,90.79 194.82,90.67 194.58,90.67 194.45,90.79 194.45,92.21 194.33,92.33 194.09,92.33 193.97,92.21 193.97,90.79 193.84,90.67 193.6,90.67 193.48,90.79 193.48,92.21 193.36,92.33 193.11,92.33 192.99,92.21 192.99,90.79 192.87,90.67 192.63,90.67 192.5,90.79 192.5,92.21 192.38,92.33 192.14,92.33 192.02,92.21 192.02,90.79 191.89,90.67 191.65,90.67 191.53,90.79 191.53,92.21 191.41,92.33 167.52,92.33 165.47,90.28 163.53,90.28 158.01,84.76
  BOTTOM w0.102: UC1.AH6 v2(155.61,78.52)
  BOTTOM w0.157: v2(207.72,89.49) 207.72,89 205.5,86.78 JDIMM4.233 ; v2(221.51,87.16) 221.51,87.06 221.08,86.64 219.94,86.64 219.8,86.78 JDIMM2.233
DDR_B_D62: length 103.1
  IN3 w0.15: v2(208.56,93.32) 208.56,92.98 208.8,92.75 210.3,92.75 210.5,92.55 217.02,92.55 217.31,92.27 217.7,92.27 217.98,92.55 218.48,92.55 218.75,92.28 219.27,92.28 219.54,92.55 220.06,92.55 220.58,92.03 220.79,92.03 221.3,92.55 221.7,92.55 222.02,92.23 222.02,92.02 221.75,91.75 v2(221.75,91.43)
  IN4 w0.102: v2(152.84,77.72) 152.3,78.26 151.83,78.26 151.58,78.5 151.58,80.05 154.58,83.06 154.58,84.33 154.31,84.6 154.31,84.99
  IN4 w0.122: v2(208.56,93.32) 208.56,93.32 207.94,93.95 207.94,94.91 208.24,95.21 208.24,95.46 208.1,95.61 191.81,95.61 191.69,95.49 191.69,95.27 191.57,95.15 191.32,95.15 191.2,95.27 191.2,95.49 191.08,95.61 190.83,95.61 190.71,95.49 190.71,95.27 190.59,95.15 190.35,95.15 190.22,95.27 190.22,95.49 190.1,95.61 189.86,95.61 189.74,95.49 189.74,95.27 189.62,95.15 189.37,95.15 189.25,95.27 189.25,95.49 189.13,95.61 188.88,95.61 188.76,95.49 188.76,95.27 188.64,95.15 188.4,95.15 188.27,95.27 188.27,95.49 188.15,95.61 187.91,95.61 187.79,95.49 187.79,95.27 187.66,95.15 187.42,95.15 187.3,95.27 187.3,95.49 187.18,95.61 186.93,95.61 186.81,95.49 186.81,95.27 186.69,95.15 186.47,95.15 186.34,95.27 186.34,95.49 186.22,95.61 185.98,95.61 185.86,95.49 185.86,95.27 185.73,95.15 185.49,95.15 185.37,95.27 185.37,95.49 185.25,95.61 185,95.61 184.88,95.49 184.88,95.27 184.76,95.15 166.36,95.15 164.31,93.1 159.83,93.1 154.31,87.58 154.31,84.99
  BOTTOM w0.102: v2(152.84,77.72) 152.41,77.29 UC1.AE7
  BOTTOM w0.157: v2(208.56,93.32) 208.56,92.38 205.96,89.78 JDIMM4.245 ; JDIMM2.245 220.76,89.78 221.75,90.76 v2(221.75,91.43)
DDR_B_D63: length 101.4
  IN3 w0.15: v2(209.18,93.32) 209.18,93.35 209.65,93.82 210.75,93.82 211.01,93.56 222.18,93.56 224.26,91.48 v2(224.26,91.44)
  IN4 w0.102: v2(152.86,78.36) 153.22,78.01 153.22,77.56 152.99,77.34 152.68,77.34 152.35,77.67 152.35,77.74 152.09,78 151.66,78 151.28,78.38 151.28,81.11 151.94,81.76 152.86,81.76 153.8,82.7 153.8,84.2 153.89,84.29 153.89,84.99
  IN4 w0.122: v2(209.18,93.32) 209.66,93.79 209.66,94.91 208.53,96.04 184.83,96.04 184.36,95.57 166.18,95.57 164.13,93.52 159.66,93.52 153.89,87.75 153.89,84.99
  BOTTOM w0.102: UC1.AF6 152.89,78.36 v2(152.86,78.36)
  BOTTOM w0.157: v2(224.26,91.44) 225.68,90.02 JDIMM2.246 ; JDIMM4.246 211.9,90.03 211.02,90.9 211.02,91.48 v2(209.18,93.32)

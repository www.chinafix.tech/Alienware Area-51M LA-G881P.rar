# Allegro board Alienware Area-51M LA-G881P.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+VCCST_PECI: length 5.6
  TOP w0.127: v1(297.46,29.61) 297.4,29.55 297.4,28.21 297.85,27.76 CE171.1
  TOP w0.254: CE171.1 297.93,27.73 297.93,27.1 297.54,26.7 UE5.117
  TOP w0.508: CE171.1 297.88,27.73 RH613.1
+VDD09: length 13.3
  TOP w0.254: CL102.1 165.07,164.74 RL41.1 CL101.1
  IN4 w1.524: 184.56,174.27 183.86,173.57 183.86,164.62 183.04,163.79
  vias: v2(168.49,164.04) v2(169.07,164.04) v2(169.66,164.04) v2(179.24,160.35) v2(179.67,159.92) v2(180.12,159.54) v2(189.05,178.83) v2(189.63,178.83) v2(189.63,178.24) v3(169.13,163.15)
+VDD18:
  vias: v2(173.32,171.3) v2(173.96,171.22) v2(174.54,171.22) v2(191.57,176.25) v2(191.57,175.66) v2(191.56,175.1) v3(173.13,171.98)
+VDD25: length 5.7
  TOP w0.508: v2(173.94,162.47) 174.02,162.39 RL46.2
  BOTTOM w0.254: 197.35,164.08 197.35,165.22 196.66,165.91 RL21.1 CL21.1
  vias: v2(191.55,162.52) v3(191.99,161.82)
+VDDA: length 20.8
  TOP w0.127: LE4.2 364.51,26.43 v3(364.07,25.99)
  TOP w0.254: v2(357.06,40.04) 357.32,39.78 UE1.9
  TOP w0.356: CE169.1 CE7.1 ; CE7.1 LE4.2 ; CE7.1 CE9.1 v2(365.4,28.62)
  IN1 w0.508: v2(365.4,28.62) 363.24,30.79 363.24,32.67 357.06,38.85 v2(357.06,40.04)
GND: length 6630
  TOP w0.089: UH1.T4 291.04,48.93 292.02,48.93 292.21,49.11 292.59,49.11 292.65,49.06 292.69,49.06 292.71,49.04 293.73,49.04 294.21,48.56 294.45,48.56 v2(294.92,48.09) ; v2(288.33,50.06) 288.34,50.04 288.34,49.97 288.72,49.59 288.89,49.59 288.89,49.59 290,49.59 290.21,49.81 290.42,49.81 UH1.V4 290.75,50.14 291.21,50.14 291.37,49.98 291.37,49.91 291.49,49.79 292.06,49.79 292.16,49.69 292.83,49.69 292.89,49.63 292.95,49.63
  TOP w0.102: UH1.A8 288.83,41.53 288.79,41.57 288.79,41.75 288.77,41.77 288.77,42.11 288.8,42.14 288.8,42.79 UH1.D8 ; UH1.BG22 282.21,64.21 282.01,64.42 v2(281.94,64.42)
  TOP w0.127: v2(331.84,54.59) 331.11,53.86 326.81,53.86 325.72,54.95 309.03,54.95 308.66,54.58 308.66,54.11 308.88,53.9 309.87,53.9 v2(309.91,53.93) 326.04,53.93 326.69,53.28 333.24,53.28 333.53,52.99 334.36,52.99 334.36,52.98 335.15,52.98 335.82,52.31 335.82,51.33 336.66,50.49 338.17,50.49 338.4,50.73 338.58,50.73 338.86,50.44 v2(339.34,50.44) ; v2(343.88,51.35) 343.35,51.35 342.61,52.09 339.07,52.09 337.96,50.98 336.86,50.98 336.31,51.53 336.31,52.51 335.34,53.48 334.61,53.48 334.09,54 v2(334.09,54.21) ; v2(294.92,48.09) 295.1,48.27 295.23,48.27 295.43,48.47 295.43,50.32 295.3,50.44 294.34,50.44 v2(294.13,50.24) 293.52,49.63 292.95,49.63 ; v2(357.07,28.7) 357.32,28.95 UE1.28
  TOP w0.152: UH1.W27 279.76,50.51 v2(280.11,50.85) ; UH1.AL38 274.12,56.35 v2(273.83,56.64) ; v2(270.35,49.53) 270.48,49.66 UH1.V46 ; v2(279.42,45.16) 279.67,45.4 UH1.J26 ; UH1.T49 268.72,48.57 269.06,48.23 v2(269.06,48.16) ; UH1.AT24 281.6,58.58 v2(281.66,58.52) ; v2(277.82,55.46) UH1.AK31 ; v2(277.82,55.46) UH1.AK30 278.28,55.85 v2(278.64,55.48) ; v2(277.82,55.46) UH1.AJ31 277.82,54.69 ; v2(277.82,55.46) UH1.AJ30 ; UH1.E35 275.49,43.12 275.24,43.12 v2(275.14,43.02) ; v2(280.92,50.82) v2(281.7,50.82) v2(282.47,50.82) UH1.AA20 ; v2(280.92,50.82) UH1.AA25 280.46,51.2 v2(280.11,50.85) ; v2(280.92,50.82) UH1.W25 v2(280.11,50.85) ; v2(279.46,55.48) 279.39,55.48 UH1.AJ28 ; v2(279.46,55.48) 279.46,55.55 UH1.AK27 279.82,55.85 v2(280.22,55.45) ; v2(279.46,55.48) 279.08,55.85 UH1.AK28 278.99,55.83 v2(278.64,55.48) ; v2(293.93,52.6) 293.83,52.7 292.41,52.7 UH1.AD1 292.29,52.7 291.9,52.7 UH1.AD2 ; v2(271.45,62.01) UH1.BD43 271.56,62.81 UH1.BE44 ; v2(271.45,62.01) UH1.BC45 ; v2(271.45,62.01) UH1.BB43 ; UH1.BC24 281.19,62.39 v2(281.66,62.39) ; v2(282.97,58.94) 282.69,58.66 UH1.AT21 ; v2(277.1,43.12) 277.68,43.12 UH1.E31 ; v2(277.1,43.12) 277.1,43.13 277.08,43.14 277.07,43.2 UH1.E33 ; v2(277.1,43.12) 277.1,43.11 277.08,43.11 277.07,43.08 UH1.D33 ; v2(278.63,50.85) 278.28,51.2 UH1.AA30 v2(277.82,51.59) ; v2(278.63,50.85) UH1.AA28 ; v2(278.63,50.85) UH1.W30 ; v2(278.63,50.85) 278.99,50.5 UH1.W28 ; v2(278.64,55.48) 278.24,55.08 UH1.AJ30 ; v2(278.64,55.48) 278.99,55.14 UH1.AJ28 ; UH1.F43 UH1.E42 v2(272.81,43.12) ; UH1.M49 268.53,46.85 v2(268.53,47.37) ; UH1.Y17 284.85,51.02 ; UH1.Y17 284.28,51.02 ; UH1.Y17 284.28,50.45 ; UH1.Y17 284.85,50.45 ; UH1.R16 UH1.N16 UH1.M16 284.68,46.62 v2(284.41,46.63) 284,46.63 UH1.M18 ; UH1.AD49 267.71,52.75 v2(267.6,52.87) ; UH1.AJ19 284.02,55.46 UH1.AK19 ; UH1.AJ19 284.02,54.69 ; UH1.AJ19 v2(283.25,55.46) ; UH1.AJ19 283.25,54.69 UH1.AJ20 ; UH1.AA20 v2(283.25,51.59) ; UH1.AA20 v2(282.47,51.59) ; UH1.C30 UH1.E31 ; UH1.E31 UH1.D30 ; UH1.AB19 v2(283.25,51.59) ; v2(283.25,51.59) UH1.AA19 ; v2(276.35,64.38) 276.66,64.07 UH1.BG33 ; UH1.AW46 270.48,60.4 v2(270.4,60.48) 270.55,60.62 271.08,60.62 UH1.BA44 ; UH1.AJ20 282.47,55.46 UH1.AK20 ; UH1.AJ20 UH1.AG22 282.47,53.92 UH1.AF22 282.47,53.14 UH1.AD22 ; UH1.AJ20 v2(283.25,55.46) ; v2(290.67,47.23) UH1.M5 ; v2(290.67,47.23) 290.27,47.23 290.08,47.42 289.54,47.42 289.25,47.72 289.25,48.01 289.35,48.12 v2(289.35,48.46) ; v2(290.67,47.23) 290.6,47.31 UH1.P4 UH1.R4 ; 284.38,49.78 UH1.U17 ; UH1.U17 284.95,49.78 ; UH1.U17 284.35,49.17 UH1.T17 ; UH1.U17 UH1.U15 ; UH1.U17 284.95,49.21 ; v2(277.32,62.51) 277.44,62.39 277.68,62.39 UH1.BC31 ; v2(280.22,55.45) 280.54,55.76 UH1.AK25 280.92,55.46 UH1.AJ25 ; v2(280.22,55.45) 280.54,55.13 UH1.AJ25 ; v2(280.22,55.45) 279.86,55.08 UH1.AJ27 ; 280.92,54.69 UH1.AG25 ; 280.92,54.69 UH1.AG23 281.31,54.28 v2(280.92,53.88) ; 280.92,54.69 UH1.AJ25 ; UH1.AG25 280.54,54.26 v2(280.92,53.88) ; UH1.AG25 280.15,54.69 ; UH1.AT18 283.97,58.85 v2(284.34,58.85) 284.61,58.86 284.8,58.69 UH1.AT16 UH1.AR16 UH1.AN16 ; UH1.E24 281.19,43.12 281.53,43.12 v2(281.57,43.16) 281.68,43.13 UH1.E22 ; v2(292.92,57.03) 292.53,56.63 UH1.AM1 ; UH1.R38 274.09,48.07 v2(274.22,47.94) ; 276.22,48.88 276.19,48.85 UH1.R34 UH1.N34 276.19,47.38 276.56,47.01 v2(276.72,47.01) 276.9,46.84 UH1.M32 ; v2(274.13,50.19) UH1.Y38 ; UH1.A28 279.22,41.08 v2(279.63,41.08) ; UH1.AM49 268.17,56.63 v2(268.13,56.67) ; UH1.K11 UH1.J10 UH1.J9 UH1.H8 UH1.G6 289.76,44.55 290.25,45.04 v2(290.25,45.23) 290.6,45.57 UH1.J4 ; UH1.M24 v2(281.66,46.93) ; UH1.BC13 v2(286.06,62.39) 285.59,62.39 UH1.BC15 ; UH1.BG28 278.86,66.72 278.66,66.92 278.66,70.36 v2(278.53,70.49) ; v2(294.87,54.41) 294.81,54.47 294.73,54.47 294.43,54.77 294.19,54.77 294.09,54.77 293.73,54.4 292.38,54.4 UH1.AG1 ; UH1.R4 290.4,48.28 v2(290.21,48.1) ; UH1.R4 290.88,48.24 UH1.R3 ; UH1.R4 290.85,48.5 UH1.T4 290.61,48.74 UH1.T5 289.22,48.95 UH1.T7 289.17,48.77 289.35,48.59 v2(289.35,48.46) ; UH1.AR12 286.98,58.74 287.24,59 287.24,59.26 287.33,59.34 287.33,59.44 UH1.AV11 UH1.AW10 ; UH1.U33 276.4,49.96 v2(276.63,50.19) 276.64,50.2 276.64,50.61 UH1.Y33 ; v2(285.7,54.33) 286.45,54.33 286.86,53.92 UH1.AE12 ; v2(288.26,62.39) UH1.BB9 ; v2(288.26,62.39) 287.78,62.39 UH1.BC10 ; v2(288.26,62.39) UH1.BC8 ; UH1.BB41 272.61,61.79 272.86,61.92 v2(272.89,61.91) 272.96,61.91 UH1.BC40 ; UH1.AE4 290.6,53.71 v2(290.52,53.78) ; v2(286.98,51.65) 286.86,51.76 UH1.AC12 ; UH1.E10 287.78,43.12 288.03,43.12 v2(288.27,43.36) 288.55,43.29 UH1.E8 ; UH1.AR38 273.92,58.37 v2(273.92,58.7) 273.92,58.97 273.46,59.43 UH1.AV39 273.27,59.91 UH1.AW40 ; UH1.AA49 268.72,51.66 v2(268.75,51.68) ; UH1.AC38 v2(274.21,51.63) ; v2(273.73,55.31) 274.13,54.91 UH1.AH38 ; 279.37,54.69 UH1.AG28 278.6,54.69 ; 279.37,54.69 UH1.AJ27 ; 279.37,54.69 UH1.AG27 280.15,54.69 ; 279.37,54.69 UH1.AJ28 ; v2(277.82,51.59) UH1.AB31 ; v2(277.82,51.59) UH1.AA31 ; UH1.J48 269.59,45.48 UH1.J47 269.98,45.45 270.4,45.03 270.7,45.03 271.18,44.55 UH1.G44 ; UH1.N35 275.44,47.13 v2(275.44,46.75) UH1.M34 ; 278.6,54.69 UH1.AG30 277.82,54.69 ; 278.6,54.69 UH1.AJ28 ; 278.6,54.69 UH1.AJ30 ; UH1.AH12 286.94,55.1 v2(286.69,55.34) 286.69,55.75 UH1.AL12 ; UH1.AJ25 280.15,54.69 ; UH1.R12 286.51,47.93 v2(285.85,47.93) ; UH1.AE33 v2(276.5,53.88) ; v2(280.11,50.85) UH1.AA27 v2(280.1,51.59) UH1.AB25 280.92,52.37 UH1.AD25 280.92,53.14 UH1.AF25 280.56,53.53 v2(280.92,53.88) ; UH1.U38 274.66,50.04 v2(274.75,50.04) ; 284.02,52.37 UH1.AD19 284.02,53.14 ; UH1.AJ30 277.82,54.69 ; UH1.A33 276.47,41.25 276.47,40.74 276.62,40.58 v2(276.63,40.58) ; v2(287.22,42.14) 286.92,42.44 UH1.C12 ; UH1.AT29 278.2,58.66 v2(278.03,58.82) ; UH1.AE46 270.48,53.34 270.87,53.74 270.95,53.74 v2(271.04,53.82) ; UH1.M21 282.91,46.85 v2(283.07,46.69) ; v2(283.25,55.46) UH1.AK19 ; v2(283.25,55.46) UH1.AK20 ; UH1.AK20 283.25,56.24 UH1.AK19 ; v2(274.21,64.44) 274.46,64.19 UH1.BG37 ; v2(287.72,50.19) UH1.Y10 ; v2(287.72,50.19) 287.02,49.49 UH1.U12 286.95,49 v2(286.98,48.98) 287.12,49.12 287.85,49.12 288.26,48.71 288.44,48.71 288.69,48.46 289.35,48.46 v2(289.35,48.46) ; v2(287.72,50.19) 288.21,50.19 288.33,50.08 v2(288.33,50.06) 288.34,50.06 288.45,50.17 UH1.Y9 ; UH1.AC4 290.6,51.66 v2(290.57,51.64) 290.6,51.51 UH1.AA5 ; UH1.J29 278.61,45.06 v2(278.76,45.06) ; UH1.AF28 279.37,53.14 ; UH1.BC35 275.49,62.39 v2(275.02,62.39) ; v2(292.88,58.89) 292.84,58.85 UH1.AT1 ; UH1.C25 UH1.E26 279.9,43.14 279.69,43.14 v2(279.51,43.31) ; v2(274.59,41) 274.59,41.24 274.46,41.37 UH1.A37 ; UH1.AJ27 280.15,54.69 ; UH1.D12 286.66,42.85 286.44,42.85 v2(286.3,42.99) 286.3,42.99 286.25,43.03 285.67,43.03 UH1.E15 UH1.D16 ; UH1.P26 v2(279.44,47.69) ; UH1.AN38 v2(274.09,57.64) ; v2(267.58,54.19) 267.58,54.28 267.74,54.43 UH1.AG49 ; v2(272.81,43.12) 273.29,43.12 UH1.E40 ; v2(272.81,43.12) 272.7,43.44 272.68,43.5 UH1.F41 ; UH1.E19 283.39,43.12 v2(283.86,43.12) ; v2(283.86,43.12) UH1.E17 ; v2(283.86,43.12) UH1.D17 ; 284.85,54.48 UH1.AH17 ; UH1.AH17 284.56,55.31 v2(284.57,55.31) 284.67,55.42 UH1.AL17 ; UH1.AH17 284.28,54.48 ; UH1.J40 273.27,45.6 UH1.K39 273.46,45.84 273.84,46.22 v2(273.84,46.81) 273.84,47.06 UH1.N38 ; v2(270.71,47.36) 270.48,47.59 UH1.P46 ; UH1.AT26 v2(279.15,58.58) ; UH1.BC26 279.88,62.39 v2(279.41,62.39) ; UH1.V20 v2(282.47,50.04) UH1.V22 ; v2(270.65,51.63) 270.48,51.81 UH1.AC46 ; UH1.AE38 v2(274.21,53.88) ; UH1.R26 v2(280.54,48.45) ; v2(276.61,51.61) 276.61,51.66 276.5,51.77 UH1.AC33 ; v2(278.03,47.78) 278.11,47.69 UH1.P29 ; UH1.A8 288.83,41.36 288.81,41.34 288.81,40.83 288.82,40.82 v2(288.82,40.43) ; UH1.N37 v2(274.85,46.83) ; v2(284.45,64.52) 284.41,64.48 UH1.BG17 ; v2(287.07,50.19) 286.94,50.33 UH1.Y12
  TOP w0.203: UH1.AC17 284.21,52.17 284.02,52.37 ; PU201.14 220.58,117.28 v2(220.91,117.6) ; JCDRA.17 v2(173.35,193.53) ; R393.1 28.04,29.63 27.69,29.98 27.69,30.75 R405.1 ; UH1.B48 269.16,41.97 UH1.C48 269.16,43.38 UH1.F47 ; UH1.AW4 290.69,59.99 v2(290.77,60.58) 290.57,60.9 UH1.BA5 UH1.BA6 ; UH1.A2 UH1.A3 UH1.A4 UH1.A5 ; UH1.AK46 270.75,55.81 270.75,56.16 271,56.4 271,56.4 271.01,56.42 271.01,56.69 270.82,56.88 270.82,57.31 270.48,57.65 UH1.AP46 270.5,57.76 v2(270.5,58.24) 270.5,58.57 UH1.AT45 ; UH1.BG25 280.54,66.22 v2(280.96,66.64) ; v2(167.41,191.07) 167.41,191.09 167.35,191.16 JCDRA.32 ; UH1.AP4 290.3,57.43 290.3,56.93 290.06,56.69 290.06,56.34 v2(290.44,55.97) 290.6,55.81 UH1.AK4 ; JCDRA.35 166.15,191.13 v2(166.09,191.07) ; v2(170.65,193.57) 170.95,193.27 JCDRA.23 ; JCDRA.29 168.55,193.31 v2(168.81,193.57) ; v2(172.36,193.57) 172.15,193.36 JCDRA.20 ; v2(290.07,42.94) 290.11,42.9 290.18,42.9 290.5,42.58 UH1.C5 ; JCDRA.5 v2(178.15,193.53) ; v2(290.44,41.93) 290.45,41.97 290.88,42.24 UH1.C4 ; JCDRA.41 v2(163.75,193.83) ; UH1.E13 286.53,43.22 v2(286.3,42.99) ; UH1.J46 270.08,45.58 UH1.J47 ; JCDRA.38 v2(164.95,191.07) ; JCDRA.8 v2(176.95,193.53) ; U17.11 v2(342.44,21.46) ; JCDRA.14 v2(174.55,193.53) ; JCDRA.44 v2(162.55,193.53) ; v2(177.94,167.51) UL1.60 ; JCDRA.11 v2(175.75,193.53)
  TOP w0.254: RH30.2 275.24,66.55 274.6,67.19 v2(274.6,67.59) ; DT7.2 v2(12.51,47.28) ; DT7.2 v2(13.69,47.28) ; DT7.2 v2(13.08,46.81) ; v2(25.53,41.92) 25.03,41.41 CT77.2 24.97,41.27 CT55.2 ; JUSBC.5 5.95,49.2 JUSBC.B12 ; v2(299.09,26.74) 299.14,26.69 UE5.113 ; v2(11.02,40.97) DT4.2 ; DT4.2 v2(10.37,41.53) ; DT4.2 v2(11.68,41.53) ; UU6.21 32.83,23.83 32.85,23.81 v2(33.31,23.81) ; UH1.BG2 v2(292.36,64.62) 292.36,64.59 292.41,64.53 292.41,63.77 UH1.BF1 UH1.BF2 ; UH1.BG2 UH1.BF2 ; UH1.BG2 UH1.BG3 ; v2(10.92,46.78) 10.92,46.77 DT12.2 ; RT128.2 RT129.2 v2(33.42,49.07) ; v2(27.47,45.82) 27.32,45.67 CT46.2 ; v2(11.02,43.56) DT5.2 ; DT5.2 v2(11.56,43.02) ; DT5.2 v2(10.39,43.02) ; UC2.3 174.38,31.96 173.68,31.27 171.91,31.27 171.27,30.63 v2(171.27,30.53) ; CE86.2 158.72,178.85 158.39,178.51 UE3.23 ; v2(294.47,7.9) 294.43,7.9 293.99,8.33 293.99,8.86 293.94,8.91 UE5.35 ; US2.2 111.24,172 v2(110.9,171.66) 111.06,171.5 US2.3 ; UH1.AL33 276.4,55.9 276.66,55.65 276.66,55.29 v2(276.63,55.27) 276.51,55.15 UH1.AH33 ; US3.6 277.8,78.28 v2(277.52,78) 277.3,78.23 US3.5 ; v2(41.11,50.1) 41.76,50.1 41.96,49.9 RT125.2 ; RT35.2 18.54,47.54 v2(18.39,47.7) ; UE5.11 290.24,19.88 v2(290.02,20.09) ; v2(293.43,14.5) 293.26,14.68 UE5.24 ; RT17.2 v2(18.67,49.37) ; v2(156.9,175.77) 157.14,176.01 UE3.18 ; UH1.BF2 UH1.BF3 290.99,63.88 UH1.BG4 UH1.BG3 ; v2(173.51,164.36) 172.93,163.78 UL11.4 ; UH1.BG3 291.5,64.42 v2(291.81,64.73) ; v2(160.91,162.23) 161.02,162.34 UL13.4 ; CT86.2 22.75,40.79 v2(22.27,41.27) ; UU1.14 35.18,15.5 v2(35.43,15.75) ; CT85.2 23.68,39.42 v2(23.57,39.32) ; UH1.AT32 277.18,58.67 v2(276.7,58.19) ; v2(83.24,20.21) 82.99,20.46 U19.5 ; v2(292,40.92) UH1.A2 ; UL10.8 195.15,162.98 v2(194.4,163.73) ; UH1.N12 286.62,46.95 v2(286.62,46.75) 287.59,45.78 UH1.K11 ; RT216.2 v2(43.16,32.7) ; v2(14.4,35.61) 15.34,35.61 15.91,35.04 UU5.3 ; UE6.12 v2(280.66,11.51) ; v2(244.81,12.29) 244.72,12.2 UE10.12 ; US3.7 278.55,78.65 v2(278.79,78.89) 278.53,79.15 US3.8 ; PCI07.1 101.64,33.01 v2(101.63,33.01) ; UH1.AR12 286.98,57.81 v2(287.23,57.56) 287.23,57.35 UH1.AN12 ; CT72.2 24.44,38.2 24.23,38.41 v2(24.23,39.31) ; v2(30.81,43) 31.26,43 31.72,42.54 32.44,42.54 RT79.2 RT78.2 ; v2(101.71,42.86) 101.71,42.3 PCI63.1 ; v2(26.16,38.67) 26.16,38.57 25.79,38.2 CT71.2 ; v2(27.08,23.77) 27.14,23.83 UU6.10 ; v2(215.63,116.83) 215.68,116.88 PU201.3 ; v2(43.92,43.41) 43.92,42.19 44.07,42.03 RT22.2 ; v2(276.7,58.19) 276.45,57.94 UH1.AR34 276.25,57.87 276.25,57.22 UH1.AN34 ; v2(276.7,58.19) UH1.AT34 ; v2(263.26,63.19) 263.15,63.09 260.88,63.09 260.63,63.35 v2(260.63,63.78) 260.63,65.49 v2(260.67,65.53) 260.67,65.75 260.68,65.76 260.68,67.16 260.93,67.41 262.47,67.41 ; v2(26.83,41.92) 26.83,41.92 CT61.2 ; v2(278.03,47.78) 278.52,48.27 UH1.R29 ; v2(193.23,165.31) 193.39,165.31 193.65,165.05 UL10.4 ; DT6.2 v2(12.53,48.78) ; DT6.2 v2(13.6,48.78) ; DT6.2 v2(13.08,49.3) ; v2(44.23,16.67) 43.75,16.67 43.38,17.05 43.38,17.41 43.4,17.43 RT221.1 ; RT75.2 44.35,47.23 CT104.2 ; RT241.2 v2(46.67,32.7) ; PR207.2 v2(215.28,115.14) ; v2(9.19,48.13) 9.1,48.23 JUSBC.A1 ; v2(355.52,31.85) 355.26,32.11 UE1.23 353.24,32.11 352.62,32.74 CE1.2 ; UL13.8 164.5,163.84 v2(164.67,164.01) ; UH1.AW10 287.8,60.66 v2(287.57,60.89) UH1.BA12 v2(286.33,60.89) UH1.BA14 ; v2(46.62,31.35) 46.62,31.66 46.66,31.7 RT219.2 ; RT80.2 19.22,45.64 v2(18.97,45.39) ; PU201.1 216.43,117.68 216.25,117.85 v2(215.95,117.85) ; 284.9,48.8 284.89,48.79 UH1.R16 ; JUSBC.A12 8.12,42.73 8.16,42.76 v2(8.35,42.76) ; v2(151.44,175.95) 152.01,175.95 152.08,176.01 UE3.7 ; v2(308.46,23.09) 308.45,23.08 UE5.94 ; JUSBC.6 5.95,42.01 JUSBC.B1 ; v2(283.61,61.94) 283.31,62.24 UH1.BC19 ; UE1.47 v2(364.13,36.61) ; UE1.8 v2(357.82,40.09) ; DT14.2 11.7,44.66 v2(11.9,44.66) ; v2(171.15,166.32) 171.15,166.24 171.43,165.97 UL11.8 ; v2(22.02,36.48) 22.02,36.47 22.38,36.47 22.64,36.73 22.64,37.37 22.97,37.7 RT43.2 22.85,37.95 21.89,37.95 RT44.2 ; v2(22.27,40.62) 21.92,40.27 RT200.1 21.87,39.85 CT84.2 ; UH1.J46 270.92,46.02 v2(270.92,46.25) ; UE1.35 v2(360.82,31.33) ; 268.76,64.38 268.23,64.38 v2(268.18,64.33) 268.18,64.18 268.64,63.71 UH1.BF49 UH1.BF48 UH1.BG48 268.76,64.38
  TOP w0.305: v2(15.52,44.75) 15.52,45.03 16.14,45.65 16.15,45.65 16.26,45.77 RT37.2 ; CD73.2 217.36,35.43 v2(217.33,35.39) ; v2(244.27,89.92) 245.1,90.75 CD11.2 ; CD69.2 225.26,65.23 v2(225.25,65.22) ; v2(255.07,68.99) 255.34,68.99 255.65,68.68 RD11.1 ; CD47.2 228.71,78.99 v2(228.7,79) ; v2(233.7,59.38) 233.7,59.74 233.22,60.22 CD36.2 ; CD25.2 v2(246.06,95.41) ; v2(24.22,43.22) 24.29,43.22 24.75,43.68 CT80.2 24.9,44.31 CT79.2 ; RT224.1 41.48,17.96 41.1,18.34 40.46,18.34 39.92,18.88 v2(39.92,19.95) ; v2(240.16,94.84) RD15.1 RD16.1 ; v2(241.03,71.65) 241.12,71.56 RD17.1 ; v2(233.63,55.89) 233.63,55.72 233.12,55.22 CD38.2 ; v2(254.99,70.74) 254.79,70.74 253.85,69.8 CD30.2 RD10.1 ; v2(220.9,68.46) 220.9,68.3 220.25,67.65 CD67.2 ; v2(224.18,39.96) 224.22,40 CD76.2 ; CD107.2 214.08,82.09 v2(214.11,82.07) ; CL126.2 188.4,176.54 188.21,176.35 CL125.2 ; CD74.2 216.34,86.85 v2(216.43,86.76) ; v2(214.86,73.87) 214.78,73.8 214.78,73.28 CD109.2 214.82,72.17 214.35,71.7 RD43.1 ; v2(220.6,57.22) 220.6,57.53 219.84,58.29 CD66.2 ; CD132.2 225.83,72.34 v2(225.34,72.83) ; CD95.2 205.54,58.37 205.85,58.06 206.79,58.06 207.1,58.36 v2(207.1,58.57) ; v2(210.62,58.57) 210.62,58.34 210.93,58.04 CD98.2 ; v2(257.34,60.27) 257.14,60.47 CD2.2 ; v2(126.19,145.28) 125.76,144.85 125.33,144.85 PCS67.2 ; CD72.2 227.74,29.56 v2(228.27,29.03) ; v2(237.98,55.01) 237.98,54.76 238.29,54.46 CD34.2 ; v2(247.07,5.87) 247.07,6.42 246.72,6.77 UE10.23 ; CD41.2 230.39,36.78 v2(230.37,36.81) ; CD103.2 202.96,46.75 v2(202.97,46.76) ; PCS52.1 146.55,147.74 146.77,147.96 v2(146.77,148.56) ; v2(203.09,79.02) 203.26,78.84 CD108.2 ; v2(222.91,72.54) 223.24,72.21 CD82.1 ; CD24.2 v2(251.97,95.43) ; v2(215.42,30.88) 215.42,31.43 CD102.2 ; CD43.2 234.61,46 v2(234.85,46.24) ; R370.1 35,25.96 35.39,25.57 v2(35.39,25.57) ; v2(226.57,97.1) 226.07,96.61 CD87.2 ; CD3.2 246.61,61.87 v2(246.93,61.56) ; CD15.2 248.54,35.37 v2(248.54,35.58) ; v2(246.92,69.32) 246.16,68.56 CD4.2 ; UE9.2 v2(351.05,29.3) ; v2(127.28,146.38) 127.07,146.16 PRS18.1 ; CD65.2 227.81,67.92 228.83,66.9 v2(228.83,65.22) ; v2(217.35,44.23) 217.39,44.27 CD77.2 ; CD35.2 238.07,57.48 237.46,58.09 v2(237.46,58.56) 237.46,59.66 238.25,60.45 CD37.2 ; CD90.2 CD84.2 228.89,96.49 v2(228.9,96.5) ; CD131.2 227.76,71.93 v2(228.24,72.41) ; v2(255.03,50.12) 255.03,50.09 254.73,49.78 CD10.2 ; CD12.2 243.7,76.52 v2(243.68,76.53) ; CE173.2 349.25,35.05 348.45,34.25 348.45,34.26 v2(348.42,34.26) ; v2(237.77,65.09) 237.85,65.17 CD33.2 ; v2(351.69,32.79) 351.28,32.38 CE64.2 CE65.2 ; CD79.2 225.67,83.97 v2(225.52,84.12) ; RD56.1 220.31,71.94 v2(220.94,72.57) ; v2(206.65,34.31) 206.65,34.4 206.23,34.82 204.67,34.82 204.18,34.33 CD105.2 ; v2(257.45,64.74) 256.84,65.35 CH241.2 ; v2(233.38,69.26) 232.77,68.65 CD32.2 ; v2(224.17,72.83) 224.13,72.79 CD81.2 RD54.1 ; RH28.2 v2(282.96,70.58) ; v2(262.47,67.42) 262.47,67.41 262.52,67.46 263,67.46 263.6,66.86 CH46.2 ; QE1.1 v2(353.49,42.91) ; v2(236.73,73.15) 236.68,73.1 236.68,71.5 CD52.1 ; CT56.2 27.29,40.3 27.46,40.13 27.46,39.95 v2(27.46,39.95) ; v2(224.8,55.84) 224.8,55.45 225.11,55.14 CD71.2 ; CD28.2 v2(254.13,94.26) ; v2(210.97,68.46) 210.97,67.97 211.27,67.66 CD96.2 ; CD5.2 257.21,58.21 v2(257.34,58.34) ; v2(251.89,72.22) 251.89,71.91 252.2,71.6 CD18.2 CD19.1 ; CD88.2 v2(219.56,96.5) ; v2(210.97,60.85) 211.36,61.24 CD97.2 ; v2(241.08,30.58) 240.96,30.7 CD40.2 ; CD46.2 241.74,74.29 v2(241.07,73.61) ; RD31.1 229.05,69.3 229.64,69.9 229.64,69.92 229.72,70 v2(229.72,70.1) ; v2(247.66,57.84) 247.66,58.05 247.36,58.35 246.78,58.35 246.57,58.14 CD8.2 ; CD100.2 205.49,56.34 205.99,56.84 206.9,56.84 207.36,56.38 v2(207.36,56.33) ; CU108.1 32.55,28.85 33.16,29.46 v2(33.18,29.46) ; v2(230.06,90.48) 230.01,90.42 CD45.2 ; CE60.2 v2(362.94,42.16) ; v2(243.86,44.35) 243.86,44.92 CD13.2 ; v2(241.07,39.39) 240.97,39.49 CD42.2 ; v2(30.23,42) 30.09,42 30.07,41.98 29.38,41.98 29.17,42.19 CT62.2 ; CD21.2 v2(254.71,94.26) ; v2(204.01,93.85) 204.74,94.57 CD118.2 ; CD94.2 202.3,71.79 v2(202.21,71.88) ; v2(301.19,52.98) 301.14,52.93 RH14.2 ; v2(255.01,40.53) 254.64,40.16 CD14.2 ; JPCMC.19 64.25,42.84 64.52,42.57 v2(64.61,42.48) ; CD9.2 257.1,72.97 v2(257.45,72.62) ; CD7.2 246.84,55.47 247.57,56.2 v2(247.57,56.43) ; CD78.2 216.6,78.54 v2(216.57,78.51) ; v2(200.93,89.82) 201.15,89.6 CD106.2 ; v2(227.28,97.1) 227.29,97.09 CD83.2 ; CD64.2 219.29,64.67 219.51,64.45 221.27,64.45 221.74,64.92 v2(221.74,65.22) ; v2(247.52,64.84) 247.52,64.94 246.78,65.68 CD1.2 ; RD41.1 214.86,93.14 v2(214.86,91.53) ; CD44.2 v2(237.71,82.26) ; v2(223.55,93.77) 223.27,93.49 RD29.1 ; QE3.4 350.68,38.27 v2(350.88,38.47) ; v2(351.98,38.95) QE3.1 ; RD30.1 v2(224.99,96.34) ; CD114.1 CD113.1 211.53,71.24 210.93,71.85 v2(210.93,72.83) ; UV64.5 115.34,123.03 v2(115.6,122.77) ; CD70.2 220.32,54.79 221.13,55.6 v2(221.13,55.8) ; CD104.2 214.26,38.99 v2(214.3,39.02) ; RD6.1 v2(257.35,70.64) ; v2(206.85,67.02) 206.85,67.11 206.43,67.53 205.87,67.53 CD101.2 ; CD27.2 v2(244.4,94.97) ; v2(237.9,73.15) 237.9,71.8 CD51.1 ; v2(224.95,57.22) 224.95,57.75 225.71,58.51 CD68.2 ; v2(238.61,51.24) 238.9,50.95 CD39.2 ; CD99.2 211.2,54.99 210.09,56.1 v2(210.09,57.03) ; QE1.4 356.36,41.5 CE8.2 v2(357.23,40.76) ; CE6.2 v2(365.33,39.44) ; CD56.2 v2(232.87,97.08) ; CD75.2 230.09,73.3 v2(230.02,73.24) ; CD59.2 v2(231.95,96.5) ; PCS54.1 v2(147.33,148.08) ; CD20.2 v2(253.21,95.43) ; CD89.2 v2(218.59,96.5)
  TOP w0.356: v2(26.95,37.26) 26.95,37.67 RT3.2 ; CD118.2 205,94.6 CD120.2 ; CE7.2 CE9.2 366.55,28.06 v2(367,27.61) ; C2501.2 C2508.2 92.73,20.91 v2(92.61,21.04) ; CH231.2 263.88,51.62 263.88,52.02 CH188.2 ; v2(192.62,168.99) 191.77,169.84 CL93.2 CL123.2 ; CH187.2 CH184.2 264.71,41.06 v2(264.69,41.04) ; v2(48.48,33.49) RT230.1 ; RT227.1 42.54,19.42 v2(42.61,19.48) ; CH185.2 263.64,53.18 CH190.2 ; v2(58.68,10.15) 58.65,10.17 CT213.2 CT219.2 ; v2(192.08,168.68) CL122.2 CL92.2 ; DU13.3 379.48,22.5 v2(379.86,22.12) ; v2(362.36,25.98) 361.9,26.44 CE170.2 CE177.2 ; v2(192.62,172.11) 192.55,172.04 CL94.2 CL124.2 ; CD16.2 256.3,29.02 256.06,28.78 255.58,28.78 v2(255.45,28.64) ; v2(188.1,178.29) 188.1,177.89 188.39,177.6 CL96.2 188.4,177.3 CL126.2 ; RT238.1 50.7,17.62 v2(50.35,17.27) ; RH26.2 287.22,67.51 v2(287.5,67.23) ; v2(44.48,17.3) 44.92,17.74 RT234.1 ; v2(20.97,43.87) 21.11,43.72 CT63.2 ; RT223.2 46.96,17.9 v2(46.96,17.3) 47.7,17.3 RT243.1 ; v2(76.8,20.42) 77.44,21.05 C2521.2 77.99,21.12 C4.2 77.99,21.83 C5.2 ; v2(33.42,49.07) 33.42,48.85 32.48,47.91 RT39.2 ; v2(192.41,167.28) 192.38,167.26 CL121.2 CL91.2
  TOP w0.381: v2(234.97,62.13) 234.97,62.51 234.4,63.08 CH238.2 ; 23.57,45.04 23.21,44.68 CT48.2 ; 23.57,45.04 23.57,45.01 23.82,44.76 CT59.2 ; 23.57,45.04 v2(23.57,45.17) ; v2(229.12,52.81) 229.12,52.52 228.82,52.22 227.33,52.22 CH236.2 ; v2(18.89,42.89) 18.94,42.94 19.48,42.94 CT67.2 CT66.2 ; CT78.2 25.59,43.79 v2(25.52,43.87) ; v2(20.97,45.17) 20.78,45.36 CT47.2 ; v2(168.05,171.98) 168.4,172.34 168.4,172.59 168.29,172.7 UL4.5 ; v2(22.92,43.22) 22.92,42.95 22.69,42.72 CT83.2 ; UT7.15 55.07,13.03 v2(53.98,14.12) ; v2(20.99,41.92) 20.92,41.85 20.5,41.85 CT69.2 ; CT104.2 44.76,46.82 45.27,46.82 v2(45.31,46.78) ; RT238.1 RT239.1 ; CC46.1 153.76,75.65 v2(153.69,75.72) ; PQS29.4 121.93,153.72 121.19,152.98 PC19.2 ; CH239.2 241.53,67.41 242.2,68.08 v2(242.2,68.4) ; CD86.1 216.88,94.73 v2(216.88,94) ; v2(358.93,13.08) 358.95,13.08 358.92,13.11 U16.5 ; CT54.2 24.01,42.42 23.57,41.98 v2(23.57,41.92) ; v2(125.09,153.24) 125.09,152.78 124.73,152.42 PQS29.1 ; v2(24.79,51.27) 24.54,51.02 RT41.2 ; CT70.2 25.58,42.51 CT60.2 25.63,42.02 v2(25.53,41.92) ; CT58.2 25.21,45.64 25.39,45.82 v2(25.52,45.82) ; v2(26.17,47.1) 25.29,47.1 CT57.2 ; RT229.1 v2(50.89,32.7) ; DU2.3 20.4,22.83 20.02,23.21 v2(19.2,23.21) ; CD29.2 253.54,66.03 253.07,65.56 252.32,65.56 251.94,65.94 v2(251.94,66.19) ; CH237.2 222.58,66.27 222.91,65.94 v2(222.91,65.22) ; UT7.6 49.71,13.03 49.16,12.48 v2(49.16,12.39) ; v2(140.06,71.12) 140.1,71.09 140.71,71.09 RH637.2 ; UM7.3 v2(183.28,189.76)
  TOP w0.406: v2(237.27,11.82) 237.52,11.57 QE5.4 ; QT2.1 84.95,8.06 85.37,7.64 v2(85.81,7.64) ; PQ202.1 216.34,108.85 PC217.2 ; v2(311.75,19.71) 312.62,20.58 QE64.4 ; Q9.1 210.3,103.49 210.65,103.84 212.97,103.84 v2(213.06,103.75) ; DU12.3 v2(377.7,43.23) ; PQS30.4 157.64,147.13 157.4,147.38 v2(157.4,147.76) ; v2(207.61,104.85) 207.61,102.83 Q9.4
  TOP w0.432: v2(158.58,167.99) 158.82,168.23 QE13.1 ; QE22.1 v2(152.44,172.38) ; v2(315.37,21.56) 315.37,21.99 314.48,22.88 QE64.1
  TOP w0.457: SW2.5 291.59,93.4 v2(292.51,94.32) ; v2(301.52,29.36) 301.53,29.35 CE40.1 ; CE34.2 286.65,19.05 v2(286.57,19.13) ; CE32.1 293.35,7.95 v2(293.38,7.92)
  TOP w0.508: v2(119.09,86.45) CC1.2 ; v2(167.71,177.21) 168.5,178.01 JPWR.12 JPWR.11 ; v2(176.31,176.25) 176.34,176.25 176.34,176.27 176.35,176.27 176.43,176.19 176.43,176.12 CL2.2 ; CD54.2 CD55.1 v2(230.91,97.08) ; PC210.2 213,116.76 212.5,116.25 v2(212.5,115.86) ; RH135.1 v2(274.37,71.24) ; v2(111.47,116.81) 112.93,118.27 CV1076.2 114.31,118.27 CV1078.2 ; PR307.2 331.14,34.04 331.15,34.05 PR306.1 331.32,34.05 v2(331.82,33.55) ; v2(299.62,2.82) 299.12,3.31 JWDB.5 ; CT82.2 19.84,37.66 v2(20.18,37.32) ; PC109.2 v2(266.85,5.8) ; v2(255.36,6.88) 255.36,6.65 254.9,6.2 CS16.2 ; C256.2 337.98,27.9 v2(337.34,28.53) ; CL118.2 161.15,168.02 v2(160.98,167.85) ; PCS56.2 v2(153.95,143.02) ; PC319.2 327.55,12.91 v2(327.96,12.5) ; CV1073.2 253.29,10.74 v2(253.87,11.33) ; RE75.2 289.79,9.09 290.3,9.6 290.3,10.75 v2(290.55,11) ; v2(138.82,155.03) 138.9,154.94 PC6.2 ; CD117.1 203.58,91.84 CD116.2 203.56,91.13 v2(203.49,91.07) ; v2(312.76,25.8) 312.14,25.18 RE699.2 ; v2(242.57,93.19) 242.59,93.19 242.59,93.36 242.7,93.47 CD23.1 CD22.2 ; CT210.2 48.48,11.87 48.48,11.03 v2(48.48,11.02) ; CH56.2 298.45,45.81 297.46,46.8 v2(297.46,47.32) 297.46,47.4 297.06,47.8 RH590.1 ; PCZ09.2 65.6,23.49 v2(65.37,23.26) ; v2(109.96,169.12) 110.08,169.25 110.65,169.25 111.22,169.82 CS17.2 ; CH45.2 263.6,63.54 v2(263.26,63.19) ; PC793.2 206.98,134.07 206.81,134.24 v2(206.51,134.24) ; PC757.1 202.23,141.67 202.04,141.67 v2(201.57,142.14) ; v2(171.72,66.94) 171.73,66.95 CC24.2 ; v2(127.6,25.04) 127.03,25.61 PCI120.2 ; v2(372.01,41.81) 372.49,41.32 CU16.2 ; PC751.1 210.02,143.97 v2(210.77,143.97) ; CE43.2 299.39,30.71 v2(299.87,30.71) ; PR108.2 259.09,5.93 258.58,6.44 v2(258.58,7.39) ; PC752.1 v2(211.67,146.52) ; C269.2 281.77,85.56 v2(282.03,85.3) 283.65,83.68 CT5361.2 ; v2(224.75,112.8) 224.75,113.05 223.93,113.88 PC207.1 223.61,115.16 PD200.2 ; C268.2 281.27,84.35 v2(281.46,84.54) ; v2(310.95,28.72) 310.79,28.87 PC317.2 ; v2(60.72,20.23) 60.56,20.39 CT123.2 ; PCS49.2 143,144.68 v2(142.36,144.04) ; v2(295.74,30.5) 295.25,30.01 CE38.1 ; CE29.2 286.94,23.72 CE41.2 286.79,23.57 v2(286.79,22.58) ; UE2.4 370.97,31.83 371.47,31.32 v2(371.89,31.32) ; v2(32.69,29.78) 32.69,30.55 32,31.24 R404.1 ; PR216.2 216.61,111.46 217.06,111.91 v2(217.06,112.1) 217.06,112.4 216.88,112.58 PC214.2 ; v2(61.05,24.92) 61.05,25.37 61.13,25.45 PCZ05.1 ; RC687.2 v2(53.44,42.26) ; RE5.2 365.66,36.03 365.47,36.22 v2(365.47,36.6) ; C267.2 272.39,91.41 C266.2 270.43,91.41 v2(269.9,90.89) ; v2(26.45,18.44) 25.99,18.9 R411.1 CU109.1 ; CT209.2 47.52,11.87 v2(47.52,11.08) ; CE202.1 287.04,8.28 v2(287.32,8) ; PR727.2 v2(213.26,144.8) ; v2(153.19,183.67) 152.9,183.37 RE42.2 RE44.2 ; RU2.1 v2(35.56,9.12) ; v2(43.92,43.41) 43.41,43.91 RT108.2 ; v2(213.97,143.01) PC749.1 PC748.2 ; RL51.1 184.94,177.7 184.74,177.9 184.74,178.6 v2(184.62,178.71) ; v2(53.19,48.77) 53.91,48.04 RC35.2 RC348.2 ; v2(297.46,66.23) 297.36,66.13 RH213.2 ; v2(158.33,179.91) 158.51,179.91 159.29,179.14 CE86.2 ; R407.1 30.58,16.7 v2(30.68,16.61) ; CM70.2 v2(186.51,187.75) ; v2(170.46,175.54) 170.41,175.49 CL100.2 ; RH216.2 295.94,68.73 v2(295.28,68.73) 295.04,68.49 CH36.2 ; v2(275.11,75.97) 275.56,75.52 CH244.2 ; CN8.2 340.5,49.76 CN9.2 339.34,49.96 v2(339.34,50.44) ; CN4.2 339.09,33.58 339.32,33.81 v2(339.62,33.81) ; v2(105.19,32.77) 105.5,32.46 PCI06.2 ; RH88.1 261.87,68.55 261.56,68.55 261.45,68.67 v2(261.33,68.67) ; PC5.2 v2(150.47,153.77) ; RE693.2 235.84,11.13 236.53,11.82 v2(237.27,11.82) ; CV1084.2 v2(112,126.86) ; CD6.2 269.87,75.91 270.37,76.41 v2(270.37,76.54) ; PR755.1 PC753.1 207.9,145.74 v2(208.4,146.24) ; v2(311.94,7.92) CE28.2 310.84,7.9 RE66.1 ; PR304.2 333.54,37.22 v2(333.73,37.41) 333.73,37.92 333.15,38.5 PC302.2 ; CT81.2 18.91,40.22 v2(18.82,40.13) ; v2(210.21,65.22) 210.21,64.84 CH235.2 ; RE650.2 240.82,12.72 240.31,13.23 239.58,13.23 v2(239.02,13.79) ; CU29.2 v2(10.49,34.59) ; v2(161.44,171.63) 162.08,170.99 CL119.2 ; CE45.2 288.57,17.12 v2(288.01,17.12) ; CL120.2 167.57,168.7 UL14.2 165.74,168.7 v2(165.51,168.93) ; JWDB.6 291.93,4.38 291.8,4.25 v2(291.69,4.25) ; v2(75.28,9.02) 75.46,9.2 PD4.1 ; CT122.2 v2(63.31,22.25) ; v2(113.69,136.6) 113.46,136.83 PCS79.2 ; v2(151.1,150.79) 151.08,150.77 PC24.2 ; RL22.2 196.63,166.08 v2(196.89,166.34) ; LE2.1 v2(312.7,10.92) ; v2(16.99,48.5) 16.63,48.86 UT10.2 ; v2(186.84,178.27) 186.84,177.63 CL43.2 ; CC22.2 173.97,58.29 v2(173.96,58.28) ; v2(63.67,23.92) 63.67,24.56 PCZ08.1 63.83,24.75 63.83,24.75 PCZ07.1 ; PC213.2 217.77,112.58 218.09,112.26 v2(218.09,112.1) ; PR37.2 151.74,151.58 v2(151.85,151.47) 151.85,150.83 PRS78.2 ; PRZ40.1 72.99,28.48 v2(72.99,28.48) ; PCA22.2 124.17,99.08 v2(124.17,99.78) ; v2(181.23,132.4) CV956.2 CV903.2 ; v2(311.83,12.42) 312.75,12.42 313.26,12.93 RE685.2 ; v2(384.23,12.98) 383.9,13.31 C638.2 ; v2(181.89,178.97) 180.81,178.97 180.3,178.46 CL1.2 ; v2(181.89,135.53) 181.89,135.81 181.38,136.32 CV21.2 180.69,136.32 CV19.2 ; R369.2 26.71,27.39 v2(26.19,27.39) ; v2(133.51,102.32) 134.1,102.32 CC51.2 ; CC50.2 131.25,100.48 v2(130.59,100.48) ; v2(108.67,59.26) 107.76,60.17 PCI35.2 ; RE83.2 241.27,7.85 QE58.3 243.11,6.97 v2(243.11,6.97) ; CC25.2 172.52,54.79 v2(172.49,54.76) ; UE13.2 270.32,82.31 270.81,81.82 CE203.2 271.48,81.6 v2(271.48,81.13) ; CU11.2 v2(379.73,36.26) ; v2(28.45,31.24) R402.1 R403.1 ; CV1081.2 v2(110.26,122.9) ; v2(379.75,40.79) 379.5,41.04 CU17.2 378.62,40.89 CU102.2 377.68,39.95 CU45.2 ; DT15.1 v2(52.29,50.82) ; PCA23.2 125.69,98.11 PCA24.2 127.32,97.26 v2(127.79,96.8) ; v2(345.22,28.2) 345.22,28.2 C257.2 ; CV1079.2 v2(115.2,126.07) ; v2(160.86,165.48) 161.18,165.16 RL43.2 ; PRZ18.2 58.83,35.27 v2(58.51,35.58) 58.95,36.03 PRZ17.2 ; C1.2 290.68,95.92 v2(291.55,96.8) ; PQS30.1 155.96,144.98 155.81,144.83 v2(155.52,144.83) ; PRS76.2 127.67,152.15 127.67,153 v2(128.11,153.44) 127.67,153.88 PQS18.3 ; PRZ39.2 70.99,28.12 v2(70.98,28.11) ; CE63.1 250.72,8.96 251.23,9.47 251.23,9.83 v2(251.27,9.87) ; v2(44.82,43.18) 44.83,43.18 45.16,42.86 45.88,42.86 DT1.2 ; PCI74.1 106.08,50.95 v2(106.66,50.37) ; CV1082.2 v2(116.39,126.03) ; CV1108.2 CV1102.2 106.73,124.53 107.01,124.25 UV65.2 ; v2(181.51,129.12) 181.32,128.93 CV806.2 ; RT247.2 v2(61.11,13.37) ; v2(93.45,21.04) 93.45,21.72 93.04,22.13 C29.2 ; C262.2 337.27,23.78 C263.2 337.34,24.92 337.34,25.84 v2(337.34,25.84) ; CD125.2 254.73,51.61 v2(254.96,51.84) ; CV1074.2 48.94,44 v2(49.33,43.61) ; PC1202.2 v2(357.05,48.49) ; v2(147.72,13.79) 147.71,13.78 PCG13.1 ; PQ710.3 203.33,132.14 v2(202.85,131.66) ; CV902.2 181.1,130.99 v2(181.57,130.52) ; PR303.1 PR305.1 332.98,40.99 332.98,41.28 v2(332.52,41.74) ; CC52.2 131.25,102.26 v2(130.59,102.26) ; CE30.2 CE42.1 310.49,23.47 v2(310.74,23.21) ; v2(73.66,29.97) PCZ30.1 72.98,29.98 PCZ31.2 ; PC22.2 PC21.2 154.77,155.04 v2(154.4,155.41) ; PC316.2 309.67,46.65 v2(310.6,46.65) ; v2(263.35,5.18) 262.92,5.61 PR106.2 ; PC1803.2 298.49,37.06 298.05,36.62 v2(297.26,36.62) ; PRS79.2 v2(153.75,146.66) ; CH234.2 212.52,53.16 CD133.2 213.79,53.19 v2(214.6,52.37) ; v2(309.08,3.44) 306.48,6.04 PR26.2 307.31,6.52 PC13.2 ; PCA26.2 133.07,118.59 v2(133.52,119.03) ; CU10.2 v2(376.59,35.01) ; CH243.2 291.55,70.07 292.1,70.07 v2(292.71,70.69) ; PCI62.2 105.31,41.91 v2(105.22,42) ; RH1025.2 272.77,67.35 RH11.2 v2(272.11,67.99) ; R399.1 R400.1 v2(31.62,16.61) ; v2(247.07,5.87) 247.07,5.51 246.56,5 RE662.2 ; PC792.2 209.91,134.11 210.41,134.62 210.41,134.64 210.97,135.2 PR732.2 211.51,135.58 v2(211.61,135.68) ; v2(176.68,28.34) 176.06,28.34 CH197.2 ; v2(341.43,14.68) C260.2 342.91,14.18 C261.2 ; RH581.2 RH109.2 RH580.2 296.65,39.37 v2(296.63,39.35) ; v2(298.67,7.71) 298.67,7.58 299.05,7.2 RE645.2 ; PC211.2 235.94,112.43 v2(235.93,112.44) ; PQ202.4 v2(214.44,110.15) ; C2519.2 v2(169.7,100.64) 169.72,100.61 C2518.2 ; PC318.2 v2(325.12,39.14) ; RT249.2 59.59,10.81 v2(59.58,10.8) ; PQS19.3 v2(151.31,148.71) ; v2(260.7,57.79) 261.32,57.79 CH246.2 261.48,57.95 RH636.1 ; CL117.2 161.61,167.56 v2(161.33,167.28) ; PCI73.2 107.02,49.24 107.85,48.41 v2(107.85,48.16) ; CE24.2 v2(156.16,182.95) 156.08,183.03 RE31.2 ; v2(296.46,3.51) 296.55,3.51 297.82,4.78 JWDB.4 ; PCS27.2 v2(131.35,145.53) ; v2(62.71,23.58) 62.62,23.68 62.12,23.68 PHZ01.1 61.99,23.58 CT121.2 ; QE5.1 v2(238.74,10.27) ; PCG01.1 128.44,11.49 v2(128.56,11.49) ; v2(44.63,14.17) 43.64,14.17 42.98,14.83 QE65.3 ; C258.2 337.01,22.67 336.83,22.49 336.81,22.49 336.59,22.27 336.59,22.25 336.5,22.16 v2(336.5,21.84) ; v2(39.52,13.48) 39.35,13.65 CU7.2 ; CC23.2 174.49,64.36 v2(174.47,64.34) ; Q2410.3 88.54,18.91 88.04,18.4 88.04,17.38 v3(86.66,16.01) 86.66,15.48 86.09,14.91 v2(86.09,14.49) ; v2(79.98,8.85) 79.98,9.35 80.48,9.85 CT115.2 81.38,9.85 81.73,9.51 QT2.4 ; v2(305.21,30.63) 305.55,30.28 QE2.3 ; CT88.2 CT101.2 38.17,49.58 37.79,49.95 37.79,50.9 37.72,50.98 v2(37.72,51.31) ; CU26.2 15.37,31.7 v2(16.03,31.7) ; CL42.2 v2(187.73,160.55) 187.73,161.24 CL98.2 ; PR731.2 PC711.1 212.11,137.31 v2(212.24,137.18) ; R405.1 27.18,31.66 v2(26.66,32.18) ; v2(374.12,40.21) 374.27,40.05 UU3.2 ; CL102.2 CL104.2 166.27,165.71 166.54,165.44 167.29,165.44 v2(167.73,165) ; CE169.2 v2(367.08,26.67) ; v2(188.69,178.2) 189.55,177.35 CL95.2 ; v2(154.38,167.15) 155.22,167.15 155.34,167.03 PQ2.3 ; RN30.2 v2(341.41,41.03) ; RU3.1 v2(36.35,9.12) ; C270.2 v2(280.71,87.39) ; CV957.2 180.4,130.16 CV805.2 180.97,130.11 v2(181.17,129.91) ; CC4.2 CC3.2 118.77,84.03 118.45,84.35 v2(118.45,84.7) ; UT3.3 281.17,83.27 RT693.2 280.33,83.3 v2(279.66,83.3) ; PC7.2 PC8.2 141.94,149.98 v2(141.94,149.5) ; v2(279.57,81.54) 280.31,80.8 CS20.2 280.29,80.59 CS19.2 ; v2(265.24,82.84) 266.02,82.07 CE204.2 ; CD85.2 CD86.1 ; PCZ02.2 56.64,29.02 v2(56.42,29.23) ; PR751.1 202.6,142.66 201.94,142.66 201.76,142.83 v2(201.58,142.83) ; v2(136.11,29.3) 136.11,29.48 136.02,29.57 136.02,29.58 135.91,29.68 RC690.2 ; v2(303.37,31.14) 303.02,30.79 CE51.2 ; v2(300.89,61.11) 300.19,61.11 299.55,61.75 RH9.2 ; v2(359.25,4.47) 358.88,4.84 C623.2 ; PRS77.2 v2(130.59,152.68) ; v2(128.16,24.57) 128.16,24.76 128.59,25.19 RC686.2 ; PRZ20.2 58.94,33.69 v2(58.57,34.06) 58.98,34.46 PRZ19.2 ; v2(255.03,55.28) 254.88,55.44 254.19,55.44 254.16,55.47 CH240.2 ; PR35.2 118.01,173.51 v2(118.14,173.63) ; v2(105.39,23.8) 105.31,23.71 PCI18.2 ; v2(30.31,40.19) 30.3,40.19 29.82,39.71 RT19.2 ; v2(257.45,64.74) CH52.2 ; CE46.2 311.4,15.01 311.91,14.5 v2(311.91,14.22) ; v2(376.83,19.39) 376.83,19.38 377.14,19.38 377.86,18.65 CU245.2 CU244.2 ; v2(250.82,4.9) 252.15,6.22 CS5.2 252.25,6.2 CS6.2 ; v2(298.09,29.67) 298.09,29.48 297.91,29.3 CE171.2 ; CT97.2 v2(11.33,44.19) ; C635.2 359.64,24.25 C636.2 359.97,24.59 v2(360.78,24.59) ; DU9.1 v2(26.09,14.45) ; CU101.2 v2(380.34,39.95) ; R406.1 v2(29.11,17.19) ; CL63.2 175.99,171.92 176.05,171.98 v2(176.43,171.98) 176.62,171.8 CL62.2 ; CU28.2 v2(11.28,31.75) ; C637.2 381.89,13.31 v2(381.82,13.38) ; PR752.1 v2(210.77,146.4) ; v2(109.5,120.1) 109.95,120.55 CV1080.2 ; CH186.2 v2(268.22,71.98) ; v2(257.09,85.01) 257.23,85.01 257.73,85.52 RD4.1 ; RD5.1 v2(257.73,88.98) ; CE205.2 v2(268.28,83.88) ; v2(63.33,14.2) 63.08,13.95 RT712.2 ; CL103.2 v2(160.96,161.63) ; v2(359.66,21.18) 359.66,19.26 C2516.2 ; CE174.2 287.15,20.72 286.88,20.46 v2(286.44,20.46) ; v2(29.52,13.82) 29.52,14.06 30.02,14.56 CU47.2 ; v2(325.68,12.49) PR317.2 ; CH175.2 v2(295.19,65.12) ; PQS28.3 v2(155.55,151.61) ; RM42.2 v2(186.54,188.5) ; v2(212.21,110.42) PC218.2 212.83,110.42 PR217.2 ; v2(373.15,36.6) 373.16,36.6 373.59,37.03 CU48.2 CU46.2 ; CH190.2 263,53.5 v2(262.89,53.39) ; v2(52.07,47.85) 51.26,47.85 50.57,47.17 49.73,47.17 49.51,47.39 CT106.2 ; CL29.2 CL28.2 188.55,162.53 188.31,162.77 v2(188.31,162.84) ; PC19.2 121,153.05 v2(119.6,153.05) ; CE44.2 288.81,11.89 v2(288.38,11.45) 287.38,12.46 287.38,14.91 CE31.1 ; C2522.2 277.6,88.28 v2(277.14,88.73) ; CV1085.2 v2(113.07,126.07) ; PRZ45.1 v2(73.52,32.61) ; PCF02.2 v2(155.38,119.5) ; v2(57.37,22.76) 56.67,23.45 UT8.2 ; CV1101.2 v2(111.09,126.86) ; PC4.2 v2(117.23,169.89) ; C624.2 C628.2 387.65,13.81 v2(387.58,13.88) ; CE201.2 282.21,4.32 v2(280.97,3.08) ; CN1.2 CN5.2 336.88,36.47 v2(336.89,36.46) ; v2(211.54,143.91) 211.54,143.46 PR753.1 ; CE59.2 362.66,26.29 v2(362.36,25.98) ; CN3.2 339.18,34.82 339.47,35.11 v2(339.47,35.71) ; CE19.2 v2(366.39,42.47) ; PC3.2 v2(118.44,169.95) ; CV1083.2 v2(114.13,126.9) ; v2(153.55,165.44) 153.65,165.34 PR2.2 ; v2(154.49,119.5) 154.49,118.05 PCF01.2 ; CH174.2 272.16,75.7 v2(271.3,76.55) ; v2(216.62,107.88) PC217.2 ; v2(199.42,140.42) 199.86,140.86 PC768.1 PC769.1 ; v2(259.07,9.51) 259.44,9.14 PC108.2 259.68,9.98 PR103.1 ; CC49.2 134.1,100.54 v2(133.51,100.54) ; PCF05.2 v2(156.1,116.27) ; CS1.2 251.6,10.93 v2(251.31,10.64) ; PD3.1 v2(71.21,9.04) ; CD134.2 244.09,53.52 v2(244.25,53.36) ; v2(69.3,20.59) PCZ15.2 ; PC212.2 v2(221.07,111.97) ; RH186.2 121.8,83.08 121.32,83.56 v2(121.32,84.56) ; U18.2 275.68,85.62 v2(275.36,85.3) ; v2(290.92,36.28) 290.79,36.28 290.77,36.26 290.68,36.26 290.33,35.91 290.33,35.82 290.28,35.77 290.28,34.95 291.17,34.06 PC1802.2 ; CH264.1 269.27,68.32 v2(268.71,68.88) ; CE62.2 249.16,4.98 v2(249.27,5.1) ; CL44.2 v2(192.83,172.93) ; RT711.2 v2(62.32,10.81) ; CH245.1 CH231.2 263.47,51.43 v2(262.89,52.02) ; PD1.1 v2(153.09,159.38) ; CT124.2 v2(57.94,26.59)
  GND1 w0.203: H50.1 93.63,12 ; H50.1 91.7,13.93 ; H50.1 89.77,12 ; H50.1 91.7,10.07 ; H50.1 93.12,10.58 ; H50.1 93.12,13.42 ; H50.1 90.28,13.42 ; H50.1 90.28,10.58 ; JPCMC.36 64.27,44.91 ; JPCMC.36 61.8,47.38 ; JPCMC.36 63.6,43.1 ; JPCMC.36 60,43.1 ; JPCMC.36 63.6,46.71 ; JPCMC.36 59.32,44.91 ; JCDRA.50 154.7,198.46 ; JCDRA.50 155.7,198.46 ; JCDRA.50 153.7,198.46 ; JCDRA.50 153.7,195.34 ; JCDRA.50 155.7,196.9 ; JCDRA.50 154.7,195.34 ; JCDRA.50 155.7,195.34 ; JCDRA.50 153.7,196.9 ; 329.78,18.16 H57.1 ; H57.1 329.78,15.12 ; H57.1 329.22,16.64 ; H57.1 333.38,16.64 ; H57.1 332.82,18.16 ; H57.1 331.3,14.56 ; H57.1 331.3,18.72 ; H57.1 332.82,15.12 ; 384.15,41.67 JUSB2.7 ; JUSB2.7 384.79,43.14 ; JUSB2.7 383.32,42.5 ; JUSB2.7 384.79,41.87 ; JUSB2.7 383.52,41.87 ; JUSB2.7 384.15,43.33 ; JUSB2.7 383.52,43.14 ; 5.62,49.92 JUSBC.2 ; JUSBC.2 8.08,50.7 ; JUSBC.2 8.08,49.92 ; JUSBC.2 6.85,50.7 ; JUSBC.2 8.08,49.14 ; JUSBC.2 5.62,49.14 ; JUSBC.2 5.62,50.7 ; 16.42,19 JUSB1.4 ; JUSB1.4 16.59,18.41 ; JUSB1.4 17.77,18.41 ; JUSB1.4 17.18,18.24 ; JUSB1.4 17.94,19 ; JUSB1.4 17.18,19.76 ; JUSB1.4 16.59,19.59 ; JUSB1.4 17.77,19.59 ; H5.1 180.19,103 ; H5.1 175.51,103 ; H5.1 176.15,104.7 ; H5.1 177.85,100.66 ; H5.1 179.55,104.7 ; H5.1 179.55,101.3 ; H5.1 176.15,101.3 ; H5.1 177.85,105.34 ; 4.58,53.68 H45.1 ; H45.1 7.42,53.68 ; H45.1 4.07,55.1 ; H45.1 6,53.17 ; H45.1 7.42,56.52 ; H45.1 6,57.03 ; H45.1 7.93,55.1 ; H45.1 4.58,56.52 ; JUSB3.11 391.6,31.03 ; JUSB3.11 392.78,30.2 ; JUSB3.11 390.42,30.2 ; JUSB3.11 390.42,31.03 ; JUSB3.11 392.78,31.03 ; JUSB2.10 382.35,49.73 ; JUSB2.10 383.68,48.9 ; JUSB2.10 381.02,49.73 ; JUSB2.10 381.02,48.9 ; JUSB2.10 381.02,48.07 ; JUSB2.10 383.68,49.73 ; JUSB2.10 383.68,48.07 ; JUSB2.10 382.35,48.07 ; JUSB2.4 383.28,45.37 ; JUSB2.4 382.01,46.64 ; JUSB2.4 382.65,45.17 ; JUSB2.4 382.65,46.83 ; JUSB2.4 382.01,45.37 ; JUSB2.4 381.82,46 ; JUSBC.3 3.22,40.45 ; JUSBC.3 3.22,42.11 ; JUSBC.3 1.8,40.45 ; JUSBC.3 0.38,41.28 ; JUSBC.3 0.38,42.11 ; JUSBC.3 1.8,42.11 ; JUSBC.3 0.38,40.45 ; JUSBC.3 3.22,41.28 ; 389.78,56.52 H54.1 ; H54.1 392.62,56.52 ; H54.1 392.62,53.68 ; H54.1 389.78,53.68 ; H54.1 391.2,57.03 ; H54.1 391.2,53.17 ; H54.1 389.27,55.1 ; H54.1 393.13,55.1 ; H53.1 291.62,108.12 ; H53.1 290.2,104.77 ; H53.1 290.2,108.63 ; H53.1 288.78,105.28 ; H53.1 292.13,106.7 ; H53.1 288.27,106.7 ; H53.1 291.62,105.28 ; H53.1 288.78,108.12 ; 381.02,28.9 JUSB3.10 ; JUSB3.10 383.68,29.73 ; JUSB3.10 382.35,29.73 ; JUSB3.10 381.02,29.73 ; JUSB3.10 383.68,28.9 ; JUSB3.10 381.02,28.07 ; JUSB3.10 382.35,28.07 ; JUSB3.10 383.68,28.07 ; JUSB3.7 384.15,23.33 ; JUSB3.7 383.52,21.87 ; JUSB3.7 384.15,21.67 ; JUSB3.7 384.79,21.87 ; JUSB3.7 384.79,23.14 ; JUSB3.7 383.52,23.14 ; JUSB3.7 383.32,22.5 ; 391.6,13.97 JUSB3.13 ; JUSB3.13 390.42,14.8 ; JUSB3.13 392.78,13.97 ; JUSB3.13 392.78,14.8 ; JUSB3.13 390.42,13.97 ; H46.1 9.62,5.08 ; H46.1 10.13,6.5 ; H46.1 9.62,7.92 ; H46.1 6.78,7.92 ; H46.1 8.2,8.43 ; H46.1 6.27,6.5 ; H46.1 6.78,5.08 ; H46.1 8.2,4.57 ; H58.1 309.25,44.13 ; H58.1 310.74,40.61 ; H58.1 307.76,40.61 ; H58.1 309.25,40.07 ; H58.1 307.76,43.59 ; H58.1 311.28,42.1 ; H58.1 310.74,43.59 ; H58.1 307.22,42.1 ; 154.7,190.74 JCDRA.49 ; JCDRA.49 154.7,193.86 ; JCDRA.49 153.7,193.86 ; JCDRA.49 153.7,192.3 ; JCDRA.49 155.7,190.74 ; JCDRA.49 155.7,192.3 ; JCDRA.49 155.7,193.86 ; JCDRA.49 153.7,190.74 ; 366.83,7.31 JSSD2.77 ; JSSD2.77 366.83,6.05 ; JSSD2.77 367.45,7.31 ; JSSD2.77 366.83,4.79 ; JSSD2.77 367.45,4.79 ; H56.1 293.13,116 ; H56.1 292.59,114.51 ; H56.1 291.1,113.97 ; H56.1 289.07,116 ; H56.1 292.59,117.49 ; H56.1 289.61,114.51 ; H56.1 291.1,118.03 ; H56.1 289.61,117.49 ; 2.57,36.1 H47.1 ; H47.1 4.5,38.03 ; H47.1 6.43,36.1 ; H47.1 3.08,34.68 ; H47.1 4.5,34.17 ; H47.1 5.92,37.52 ; H47.1 5.92,34.68 ; H47.1 3.08,37.52 ; 381.82,26 JUSB3.4 ; JUSB3.4 382.01,26.64 ; JUSB3.4 382.65,25.17 ; JUSB3.4 382.65,26.83 ; JUSB3.4 382.01,25.37 ; JUSB3.4 383.28,25.37 ; 393.78,7.92 H55.1 ; H55.1 393.78,5.08 ; H55.1 395.2,4.57 ; H55.1 393.27,6.5 ; H55.1 396.62,5.08 ; H55.1 397.13,6.5 ; H55.1 396.62,7.92 ; H55.1 395.2,8.43 ; 190,194.4 H63.1 ; H63.1 189.36,196.1 ; H63.1 191.7,193.76 ; H63.1 191.7,198.44 ; H63.1 190,197.8 ; H63.1 193.4,197.8 ; H63.1 194.04,196.1 ; H63.1 193.4,194.4 ; H8.1 151.09,98.96 ; H8.1 146.41,98.96 ; H8.1 150.45,100.66 ; H8.1 147.05,100.66 ; H8.1 150.45,97.25 ; H8.1 148.75,101.3 ; H8.1 147.05,97.25 ; H8.1 148.75,96.62 ; 15.09,23.09 JUSB1.7 ; JUSB1.7 15.68,21.74 ; JUSB1.7 15.68,23.26 ; JUSB1.7 14.92,22.5 ; JUSB1.7 15.09,21.91 ; JUSB1.7 16.44,22.5 ; JUSB1.7 16.27,21.91 ; JUSB1.7 16.27,23.09 ; JLAN.15 196.68,196.44 ; JLAN.15 196.68,194.76 ; JLAN.15 195.02,196.44 ; JLAN.15 195.02,198.11 ; JLAN.15 195.02,194.76 ; JLAN.15 195.85,194.76 ; JLAN.15 195.85,198.11 ; JLAN.15 196.68,198.11 ; JCDRA.48 187.2,198.46 ; JCDRA.48 188.2,196.9 ; JCDRA.48 186.2,196.9 ; JCDRA.48 186.2,195.34 ; JCDRA.48 188.2,195.34 ; JCDRA.48 188.2,198.46 ; JCDRA.48 186.2,198.46 ; JCDRA.48 187.2,195.34 ; H4.1 121.55,101.3 ; H4.1 118.15,104.7 ; H4.1 122.19,103 ; H4.1 119.85,105.34 ; H4.1 119.85,100.66 ; H4.1 117.51,103 ; H4.1 118.15,101.3 ; H4.1 121.55,104.7 ; 211.2,151.07 H44.1 ; H44.1 212.62,151.58 ; H44.1 209.78,151.58 ; H44.1 209.27,153 ; H44.1 213.13,153 ; H44.1 209.78,154.42 ; H44.1 211.2,154.93 ; H44.1 212.62,154.42 ; H65.1 130.75,40.24 ; H65.1 128.41,37.9 ; H65.1 130.75,35.56 ; H65.1 132.45,36.2 ; H65.1 133.09,37.9 ; H65.1 129.05,39.6 ; H65.1 129.05,36.2 ; H65.1 132.45,39.6 ; 13.84,16.1 JUSB1.12 ; JUSB1.12 17.34,16.96 ; JUSB1.12 17.34,15.24 ; JUSB1.12 15.59,15.24 ; JUSB1.12 15.59,16.96 ; JUSB1.12 13.84,15.24 ; JUSB1.12 13.84,16.96 ; JUSB1.12 17.34,16.1 ; 281.3,14.56 H59.1 ; H59.1 281.3,18.72 ; H59.1 282.82,15.12 ; H59.1 279.22,16.64 ; H59.1 279.78,18.16 ; H59.1 283.38,16.64 ; H59.1 282.82,18.16 ; H59.1 279.78,15.12 ; 112.5,20.1 H3.1 ; H3.1 115.9,20.1 ; H3.1 111.86,18.4 ; H3.1 114.2,16.06 ; H3.1 115.9,16.7 ; H3.1 116.54,18.4 ; H3.1 114.2,20.74 ; H3.1 112.5,16.7 ; JUSB2.11 392.78,51.03 ; JUSB2.11 391.6,51.03 ; JUSB2.11 392.78,50.2 ; JUSB2.11 390.42,50.2 ; JUSB2.11 390.42,51.03 ; H42.1 171.05,156 ; H42.1 167.01,157.7 ; H42.1 169.35,160.04 ; H42.1 167.65,159.4 ; H42.1 171.05,159.4 ; H42.1 169.35,155.36 ; H42.1 171.69,157.7 ; H42.1 167.65,156 ; JUSB1.13 8.34,31.26 ; JUSB1.13 8.34,30.4 ; JUSB1.13 5.32,31.26 ; JUSB1.13 6.83,31.26 ; JUSB1.13 5.32,30.4 ; 13.84,29.76 JUSB1.11 ; JUSB1.11 17.34,28.04 ; JUSB1.11 13.84,28.9 ; JUSB1.11 17.34,29.76 ; JUSB1.11 15.59,29.76 ; JUSB1.11 13.84,28.04 ; JUSB1.11 15.59,28.04 ; JUSB1.11 17.34,28.9 ; 106.78,138.92 H43.1 ; H43.1 110.13,137.5 ; H43.1 106.27,137.5 ; H43.1 109.62,136.08 ; H43.1 108.2,135.57 ; H43.1 108.2,139.43 ; H43.1 106.78,136.08 ; H43.1 109.62,138.92 ; JUSB2.13 392.78,33.97 ; JUSB2.13 392.78,34.8 ; JUSB2.13 391.6,33.97 ; JUSB2.13 390.42,34.8 ; JUSB2.13 390.42,33.97 ; H70.1 168.19,120.19 ; H70.1 165.21,117.21 ; H70.1 168.73,118.7 ; H70.1 168.19,117.21 ; H70.1 165.21,120.19 ; H70.1 166.7,116.67 ; H70.1 166.7,120.73 ; H70.1 164.67,118.7 ; JCDRA.47 188.2,190.74 ; JCDRA.47 187.2,193.86 ; JCDRA.47 186.2,192.3 ; JCDRA.47 188.2,192.3 ; JCDRA.47 188.2,193.86 ; JCDRA.47 186.2,193.86 ; JCDRA.47 186.2,190.74 ; JCDRA.47 187.2,190.74 ; 1.8,49.09 JUSBC.1 ; JUSBC.1 3.22,49.92 ; JUSBC.1 0.38,49.09 ; JUSBC.1 0.38,49.92 ; JUSBC.1 3.22,50.75 ; JUSBC.1 3.22,49.09 ; JUSBC.1 0.38,50.75 ; JUSBC.1 1.8,50.75 ; 270.87,6.5 H48.1 ; H48.1 272.8,4.57 ; H48.1 272.8,8.43 ; H48.1 274.22,5.08 ; H48.1 271.38,7.92 ; H48.1 274.73,6.5 ; H48.1 271.38,5.08 ; H48.1 274.22,7.92 ; JUSBC.4 8.08,41.28 ; JUSBC.4 8.08,40.5 ; JUSBC.4 8.08,42.06 ; JUSBC.4 6.85,40.5 ; JUSBC.4 5.62,41.28 ; JUSBC.4 5.62,42.06 ; JUSBC.4 5.62,40.5 ; JLAN.14 215.35,198.11 ; JLAN.14 216.18,198.11 ; JLAN.14 216.18,196.44 ; JLAN.14 216.18,194.76 ; JLAN.14 215.35,194.76 ; JLAN.14 214.52,196.44 ; JLAN.14 214.52,194.76 ; JLAN.14 214.52,198.11 ; JUSBC.5 7.07,48.69 ; JUSBC.5 5.63,49.6 ; JUSBC.5 6.35,50.7 ; JUSBC.5 5.63,50.7 ; JUSBC.5 6.35,48.69 ; JUSBC.5 5.63,48.69 ; JUSBC.5 7.07,50.7 ; 307.2,61.57 H51.1 ; H51.1 305.78,64.92 ; H51.1 305.78,62.08 ; H51.1 308.62,64.92 ; H51.1 309.13,63.5 ; H51.1 307.2,65.43 ; H51.1 305.27,63.5 ; H51.1 308.62,62.08 ; 5.32,14.6 JUSB1.14 ; JUSB1.14 6.83,13.74 ; JUSB1.14 5.32,13.74 ; JUSB1.14 8.34,13.74 ; JUSB1.14 8.34,14.6 ; 94.78,70.92 H52.1 ; H52.1 94.27,69.5 ; H52.1 96.2,71.43 ; H52.1 98.13,69.5 ; H52.1 96.2,67.57 ; H52.1 94.78,68.08 ; H52.1 97.62,68.08 ; H52.1 97.62,70.92 ; JUSB3.12 382.35,16.93 ; JUSB3.12 381.02,16.93 ; JUSB3.12 383.68,16.93 ; JUSB3.12 382.35,15.27 ; JUSB3.12 383.68,15.27 ; JUSB3.12 383.68,16.1 ; JUSB3.12 381.02,16.1 ; 166.75,35.56 H1.1 ; H1.1 169.09,37.9 ; H1.1 165.05,39.6 ; H1.1 168.45,36.2 ; H1.1 168.45,39.6 ; H1.1 165.05,36.2 ; H1.1 164.41,37.9 ; H1.1 166.75,40.24 ; 381.02,36.1 JUSB2.12 ; JUSB2.12 382.35,35.27 ; JUSB2.12 382.35,36.93 ; JUSB2.12 383.68,36.93 ; JUSB2.12 383.68,36.1 ; JUSB2.12 381.02,36.93 ; JUSB2.12 383.68,35.27 ; JUSB2.12 381.02,35.27 ; 219,193.97 H60.1 ; H60.1 219,198.03 ; H60.1 216.97,196 ; H60.1 221.03,196 ; H60.1 217.51,194.51 ; H60.1 220.49,194.51 ; H60.1 217.51,197.49 ; H60.1 220.49,197.49 ; 192.2,4.57 H49.1 ; H49.1 193.62,7.92 ; H49.1 190.78,7.92 ; H49.1 190.27,6.5 ; H49.1 192.2,8.43 ; H49.1 193.62,5.08 ; H49.1 190.78,5.08 ; H49.1 194.13,6.5 ; JSSD2.76 390.57,7.31 ; JSSD2.76 390.57,6.05 ; JSSD2.76 389.95,4.79 ; JSSD2.76 390.57,4.79 ; JSSD2.76 389.95,7.31 ; H2.1 184.76,20.1 ; H2.1 180.72,18.4 ; H2.1 183.06,20.74 ; H2.1 183.06,16.06 ; H2.1 181.36,16.7 ; H2.1 181.36,20.1 ; H2.1 184.76,16.7 ; H2.1 185.4,18.4 ; JUSBC.6 7.07,42.51 ; JUSBC.6 6.35,42.51 ; JUSBC.6 7.07,40.5 ; JUSBC.6 5.63,42.51 ; JUSBC.6 5.63,40.5 ; JUSBC.6 5.63,41.61 ; JUSBC.6 6.35,40.5
  GND2 w0.254: H46.1 9.62,5.08 ; H46.1 6.78,5.08 ; H46.1 8.2,4.57 ; H46.1 9.62,7.92 ; H46.1 6.27,6.5 ; H46.1 6.78,7.92 ; H46.1 10.13,6.5 ; H46.1 8.2,8.43 ; H1.1 169.09,37.9 ; H1.1 166.75,40.24 ; H1.1 168.45,39.6 ; H1.1 165.05,36.2 ; H1.1 168.45,36.2 ; H1.1 164.41,37.9 ; H1.1 165.05,39.6 ; H1.1 166.75,35.56 ; 195.02,196.44 JLAN.15 ; JLAN.15 195.02,198.11 ; JLAN.15 195.85,194.76 ; JLAN.15 196.68,196.44 ; JLAN.15 196.68,194.76 ; JLAN.15 196.68,198.11 ; JLAN.15 195.85,198.11 ; JLAN.15 195.02,194.76 ; JUSB3.7 384.15,23.33 ; JUSB3.7 383.52,23.14 ; JUSB3.7 383.52,21.87 ; JUSB3.7 384.79,21.87 ; JUSB3.7 384.15,21.67 ; JUSB3.7 383.32,22.5 ; JUSB3.7 384.79,23.14 ; 153.7,195.34 JCDRA.50 ; JCDRA.50 153.7,198.46 ; JCDRA.50 154.7,198.46 ; JCDRA.50 155.7,198.46 ; JCDRA.50 154.7,195.34 ; JCDRA.50 153.7,196.9 ; JCDRA.50 155.7,195.34 ; JCDRA.50 155.7,196.9 ; 291.1,113.97 H56.1 ; H56.1 289.61,114.51 ; H56.1 292.59,117.49 ; H56.1 292.59,114.51 ; H56.1 289.07,116 ; H56.1 293.13,116 ; H56.1 289.61,117.49 ; H56.1 291.1,118.03 ; H63.1 193.4,197.8 ; H63.1 190,197.8 ; H63.1 194.04,196.1 ; H63.1 191.7,198.44 ; H63.1 191.7,193.76 ; H63.1 190,194.4 ; H63.1 193.4,194.4 ; H63.1 189.36,196.1 ; 166.7,116.67 H70.1 ; H70.1 168.73,118.7 ; H70.1 168.19,120.19 ; H70.1 168.19,117.21 ; H70.1 165.21,117.21 ; H70.1 166.7,120.73 ; H70.1 165.21,120.19 ; H70.1 164.67,118.7 ; H4.1 119.85,105.34 ; H4.1 119.85,100.66 ; H4.1 121.55,101.3 ; H4.1 122.19,103 ; H4.1 117.51,103 ; H4.1 118.15,101.3 ; H4.1 121.55,104.7 ; H4.1 118.15,104.7 ; 148.75,96.62 H8.1 ; H8.1 146.41,98.96 ; H8.1 147.05,100.66 ; H8.1 147.05,97.25 ; H8.1 148.75,101.3 ; H8.1 151.09,98.96 ; H8.1 150.45,100.66 ; H8.1 150.45,97.25 ; 129.05,39.6 H65.1 ; H65.1 133.09,37.9 ; H65.1 132.45,39.6 ; H65.1 132.45,36.2 ; H65.1 130.75,35.56 ; H65.1 130.75,40.24 ; H65.1 129.05,36.2 ; JUSB1.4 17.94,19 ; JUSB1.4 17.18,18.24 ; JUSB1.4 17.77,18.41 ; JUSB1.4 16.59,19.59 ; JUSB1.4 16.42,19 ; JUSB1.4 16.59,18.41 ; JUSB1.4 17.18,19.76 ; JUSB1.4 17.77,19.59 ; 393.78,5.08 H55.1 ; H55.1 397.13,6.5 ; H55.1 396.62,7.92 ; H55.1 396.62,5.08 ; H55.1 395.2,8.43 ; H55.1 393.78,7.92 ; H55.1 395.2,4.57 ; H55.1 393.27,6.5 ; JUSB2.4 383.28,45.37 ; JUSB2.4 382.65,45.17 ; JUSB2.4 382.01,46.64 ; JUSB2.4 381.82,46 ; JUSB2.4 382.65,46.83 ; JUSB2.4 382.01,45.37 ; 384.15,41.67 JUSB2.7 ; JUSB2.7 384.79,41.87 ; JUSB2.7 383.52,43.14 ; JUSB2.7 384.15,43.33 ; JUSB2.7 383.52,41.87 ; JUSB2.7 383.32,42.5 ; JUSB2.7 384.79,43.14 ; 217.51,197.49 H60.1 ; H60.1 216.97,196 ; H60.1 219,198.03 ; H60.1 220.49,194.51 ; H60.1 221.03,196 ; H60.1 219,193.97 ; H60.1 220.49,197.49 ; H60.1 217.51,194.51 ; JUSBC.2 8.08,49.92 ; JUSBC.2 6.85,50.7 ; JUSBC.2 8.08,49.14 ; JUSBC.2 5.62,49.92 ; JUSBC.2 5.62,49.14 ; JUSBC.2 8.08,50.7 ; JUSBC.2 5.62,50.7 ; 381.02,36.1 JUSB2.12 ; JUSB2.12 382.35,35.27 ; JUSB2.12 382.35,36.93 ; JUSB2.12 383.68,36.1 ; JUSB2.12 383.68,35.27 ; JUSB2.12 381.02,36.93 ; JUSB2.12 381.02,35.27 ; JUSB2.12 383.68,36.93 ; H3.1 114.2,20.74 ; H3.1 115.9,16.7 ; H3.1 111.86,18.4 ; H3.1 114.2,16.06 ; H3.1 115.9,20.1 ; H3.1 116.54,18.4 ; H3.1 112.5,16.7 ; H3.1 112.5,20.1 ; 14.92,22.5 JUSB1.7 ; JUSB1.7 15.09,23.09 ; JUSB1.7 15.09,21.91 ; JUSB1.7 16.44,22.5 ; JUSB1.7 16.27,23.09 ; JUSB1.7 15.68,23.26 ; JUSB1.7 16.27,21.91 ; JUSB1.7 15.68,21.74 ; 6,53.17 H45.1 ; H45.1 6,57.03 ; H45.1 4.07,55.1 ; H45.1 7.93,55.1 ; H45.1 4.58,53.68 ; H45.1 7.42,56.52 ; H45.1 7.42,53.68 ; H45.1 4.58,56.52 ; 209.78,154.42 H44.1 ; H44.1 212.62,154.42 ; H44.1 209.78,151.58 ; H44.1 213.13,153 ; H44.1 209.27,153 ; H44.1 211.2,154.93 ; H44.1 212.62,151.58 ; H44.1 211.2,151.07 ; 106.78,138.92 H43.1 ; H43.1 106.78,136.08 ; H43.1 109.62,138.92 ; H43.1 108.2,139.43 ; H43.1 110.13,137.5 ; H43.1 108.2,135.57 ; H43.1 106.27,137.5 ; H43.1 109.62,136.08 ; 3.08,34.68 H47.1 ; H47.1 4.5,38.03 ; H47.1 5.92,37.52 ; H47.1 2.57,36.1 ; H47.1 3.08,37.52 ; H47.1 5.92,34.68 ; H47.1 6.43,36.1 ; H47.1 4.5,34.17 ; 382.65,25.17 JUSB3.4 ; JUSB3.4 382.65,26.83 ; JUSB3.4 381.82,26 ; JUSB3.4 382.01,26.64 ; JUSB3.4 383.28,25.37 ; JUSB3.4 382.01,25.37 ; JUSBC.1 3.22,49.92 ; JUSBC.1 1.8,49.09 ; JUSBC.1 0.38,50.75 ; JUSBC.1 0.38,49.09 ; JUSBC.1 3.22,50.75 ; JUSBC.1 0.38,49.92 ; JUSBC.1 1.8,50.75 ; JUSBC.1 3.22,49.09 ; 6.35,48.69 JUSBC.5 ; JUSBC.5 7.07,50.7 ; JUSBC.5 5.63,50.7 ; JUSBC.5 5.63,49.6 ; JUSBC.5 5.63,48.69 ; JUSBC.5 7.07,48.69 ; JUSBC.5 6.35,50.7 ; 186.2,196.9 JCDRA.48 ; JCDRA.48 187.2,198.46 ; JCDRA.48 188.2,196.9 ; JCDRA.48 188.2,195.34 ; JCDRA.48 186.2,198.46 ; JCDRA.48 187.2,195.34 ; JCDRA.48 186.2,195.34 ; JCDRA.48 188.2,198.46 ; 389.95,4.79 JSSD2.76 ; JSSD2.76 389.95,7.31 ; JSSD2.76 390.57,6.05 ; JSSD2.76 390.57,4.79 ; JSSD2.76 390.57,7.31 ; JCDRA.49 155.7,193.86 ; JCDRA.49 155.7,192.3 ; JCDRA.49 153.7,190.74 ; JCDRA.49 154.7,190.74 ; JCDRA.49 153.7,193.86 ; JCDRA.49 155.7,190.74 ; JCDRA.49 154.7,193.86 ; JCDRA.49 153.7,192.3 ; 89.77,12 H50.1 ; H50.1 93.12,13.42 ; H50.1 90.28,10.58 ; H50.1 93.12,10.58 ; H50.1 91.7,10.07 ; H50.1 93.63,12 ; H50.1 91.7,13.93 ; H50.1 90.28,13.42 ; 0.38,41.28 JUSBC.3 ; JUSBC.3 3.22,40.45 ; JUSBC.3 1.8,42.11 ; JUSBC.3 0.38,42.11 ; JUSBC.3 3.22,41.28 ; JUSBC.3 0.38,40.45 ; JUSBC.3 1.8,40.45 ; JUSBC.3 3.22,42.11 ; 13.84,28.04 JUSB1.11 ; JUSB1.11 17.34,28.04 ; JUSB1.11 13.84,29.76 ; JUSB1.11 17.34,29.76 ; JUSB1.11 15.59,28.04 ; JUSB1.11 13.84,28.9 ; JUSB1.11 17.34,28.9 ; JUSB1.11 15.59,29.76 ; JUSB1.14 8.34,13.74 ; JUSB1.14 5.32,14.6 ; JUSB1.14 6.83,13.74 ; JUSB1.14 8.34,14.6 ; JUSB1.14 5.32,13.74 ; JUSB2.11 391.6,51.03 ; JUSB2.11 392.78,50.2 ; JUSB2.11 390.42,50.2 ; JUSB2.11 392.78,51.03 ; JUSB2.11 390.42,51.03 ; JUSBC.6 7.07,40.5 ; JUSBC.6 5.63,41.61 ; JUSBC.6 6.35,42.51 ; JUSBC.6 6.35,40.5 ; JUSBC.6 7.07,42.51 ; JUSBC.6 5.63,40.5 ; JUSBC.6 5.63,42.51 ; 272.8,4.57 H48.1 ; H48.1 274.73,6.5 ; H48.1 272.8,8.43 ; H48.1 274.22,7.92 ; H48.1 271.38,5.08 ; H48.1 274.22,5.08 ; H48.1 270.87,6.5 ; H48.1 271.38,7.92 ; H53.1 291.62,108.12 ; H53.1 288.78,105.28 ; H53.1 291.62,105.28 ; H53.1 288.27,106.7 ; H53.1 288.78,108.12 ; H53.1 292.13,106.7 ; H53.1 290.2,108.63 ; H53.1 290.2,104.77 ; JUSB2.13 392.78,34.8 ; JUSB2.13 391.6,33.97 ; JUSB2.13 390.42,34.8 ; JUSB2.13 390.42,33.97 ; JUSB2.13 392.78,33.97 ; 180.72,18.4 H2.1 ; H2.1 183.06,16.06 ; H2.1 183.06,20.74 ; H2.1 184.76,20.1 ; H2.1 181.36,16.7 ; H2.1 185.4,18.4 ; H2.1 184.76,16.7 ; H2.1 181.36,20.1 ; JLAN.14 215.35,198.11 ; JLAN.14 215.35,194.76 ; JLAN.14 216.18,198.11 ; JLAN.14 214.52,198.11 ; JLAN.14 216.18,196.44 ; JLAN.14 214.52,194.76 ; JLAN.14 216.18,194.76 ; JLAN.14 214.52,196.44 ; 5.32,31.26 JUSB1.13 ; JUSB1.13 6.83,31.26 ; JUSB1.13 8.34,31.26 ; JUSB1.13 5.32,30.4 ; JUSB1.13 8.34,30.4 ; 382.35,15.27 JUSB3.12 ; JUSB3.12 381.02,16.93 ; JUSB3.12 381.02,16.1 ; JUSB3.12 383.68,16.1 ; JUSB3.12 383.68,16.93 ; JUSB3.12 382.35,16.93 ; JUSB3.12 383.68,15.27 ; 176.15,104.7 H5.1 ; H5.1 176.15,101.3 ; H5.1 175.51,103 ; H5.1 177.85,100.66 ; H5.1 179.55,101.3 ; H5.1 180.19,103 ; H5.1 177.85,105.34 ; H5.1 179.55,104.7 ; H51.1 307.2,65.43 ; H51.1 305.78,64.92 ; H51.1 308.62,62.08 ; H51.1 305.78,62.08 ; H51.1 307.2,61.57 ; H51.1 305.27,63.5 ; H51.1 308.62,64.92 ; H51.1 309.13,63.5 ; JSSD2.77 367.45,7.31 ; JSSD2.77 366.83,7.31 ; JSSD2.77 366.83,6.05 ; JSSD2.77 367.45,4.79 ; JSSD2.77 366.83,4.79 ; JUSB3.10 383.68,28.9 ; JUSB3.10 381.02,29.73 ; JUSB3.10 381.02,28.07 ; JUSB3.10 382.35,28.07 ; JUSB3.10 382.35,29.73 ; JUSB3.10 383.68,29.73 ; JUSB3.10 381.02,28.9 ; JUSB3.10 383.68,28.07 ; H49.1 193.62,7.92 ; H49.1 190.78,7.92 ; H49.1 190.27,6.5 ; H49.1 192.2,8.43 ; H49.1 194.13,6.5 ; H49.1 192.2,4.57 ; H49.1 190.78,5.08 ; H49.1 193.62,5.08 ; 60,43.1 JPCMC.36 ; JPCMC.36 63.6,46.71 ; JPCMC.36 63.6,43.1 ; JPCMC.36 59.32,44.91 ; JPCMC.36 64.27,44.91 ; JPCMC.36 61.8,47.38 ; 309.25,40.07 H58.1 ; H58.1 310.74,43.59 ; H58.1 311.28,42.1 ; H58.1 307.76,43.59 ; H58.1 310.74,40.61 ; H58.1 307.76,40.61 ; H58.1 307.22,42.1 ; H58.1 309.25,44.13 ; JUSBC.4 8.08,42.06 ; JUSBC.4 8.08,41.28 ; JUSBC.4 5.62,40.5 ; JUSBC.4 6.85,40.5 ; JUSBC.4 8.08,40.5 ; JUSBC.4 5.62,41.28 ; 169.35,155.36 H42.1 ; H42.1 167.65,159.4 ; H42.1 167.01,157.7 ; H42.1 171.69,157.7 ; H42.1 169.35,160.04 ; H42.1 167.65,156 ; H42.1 171.05,156 ; H42.1 171.05,159.4 ; 390.42,31.03 JUSB3.11 ; JUSB3.11 390.42,30.2 ; JUSB3.11 392.78,30.2 ; JUSB3.11 391.6,31.03 ; JUSB3.11 392.78,31.03 ; 381.02,48.9 JUSB2.10 ; JUSB2.10 382.35,48.07 ; JUSB2.10 383.68,48.07 ; JUSB2.10 383.68,48.9 ; JUSB2.10 381.02,48.07 ; JUSB2.10 382.35,49.73 ; JUSB2.10 381.02,49.73 ; JUSB2.10 383.68,49.73 ; 390.42,14.8 JUSB3.13 ; JUSB3.13 391.6,13.97 ; JUSB3.13 390.42,13.97 ; JUSB3.13 392.78,13.97 ; JUSB3.13 392.78,14.8 ; H57.1 332.82,18.16 ; H57.1 329.22,16.64 ; H57.1 331.3,14.56 ; H57.1 329.78,15.12 ; H57.1 331.3,18.72 ; H57.1 333.38,16.64 ; H57.1 332.82,15.12 ; H57.1 329.78,18.16 ; JCDRA.47 187.2,193.86 ; JCDRA.47 186.2,193.86 ; JCDRA.47 188.2,192.3 ; JCDRA.47 188.2,190.74 ; JCDRA.47 186.2,190.74 ; JCDRA.47 186.2,192.3 ; JCDRA.47 187.2,190.74 ; JCDRA.47 188.2,193.86 ; 389.78,56.52 H54.1 ; H54.1 391.2,53.17 ; H54.1 393.13,55.1 ; H54.1 392.62,56.52 ; H54.1 391.2,57.03 ; H54.1 389.78,53.68 ; H54.1 389.27,55.1 ; H54.1 392.62,53.68 ; JUSB1.12 17.34,15.24 ; JUSB1.12 13.84,16.96 ; JUSB1.12 17.34,16.96 ; JUSB1.12 13.84,16.1 ; JUSB1.12 15.59,15.24 ; JUSB1.12 17.34,16.1 ; JUSB1.12 13.84,15.24 ; JUSB1.12 15.59,16.96 ; H59.1 282.82,18.16 ; H59.1 279.22,16.64 ; H59.1 281.3,18.72 ; H59.1 283.38,16.64 ; H59.1 279.78,15.12 ; H59.1 281.3,14.56 ; H59.1 282.82,15.12 ; H59.1 279.78,18.16
  GND3 w0.203: JCDRA.47 188.2,192.3 ; JCDRA.47 187.2,190.74 ; JCDRA.47 186.2,190.74 ; JCDRA.47 188.2,190.74 ; JCDRA.47 186.2,193.86 ; JCDRA.47 186.2,192.3 ; JCDRA.47 188.2,193.86 ; JCDRA.47 187.2,193.86 ; 391.6,33.97 JUSB2.13 ; JUSB2.13 392.78,34.8 ; JUSB2.13 390.42,34.8 ; JUSB2.13 390.42,33.97 ; JUSB2.13 392.78,33.97 ; JUSB1.11 17.34,29.76 ; JUSB1.11 15.59,29.76 ; JUSB1.11 17.34,28.04 ; JUSB1.11 17.34,28.9 ; JUSB1.11 13.84,28.9 ; JUSB1.11 13.84,29.76 ; JUSB1.11 13.84,28.04 ; JUSB1.11 15.59,28.04 ; JUSBC.2 8.08,50.7 ; JUSBC.2 5.62,49.14 ; JUSBC.2 6.85,50.7 ; JUSBC.2 8.08,49.14 ; JUSBC.2 5.62,49.92 ; JUSBC.2 5.62,50.7 ; JUSBC.2 8.08,49.92 ; H43.1 109.62,138.92 ; H43.1 106.78,136.08 ; H43.1 108.2,139.43 ; H43.1 109.62,136.08 ; H43.1 106.27,137.5 ; H43.1 110.13,137.5 ; H43.1 106.78,138.92 ; H43.1 108.2,135.57 ; 5.62,41.28 JUSBC.4 ; JUSBC.4 8.08,42.06 ; JUSBC.4 5.62,40.5 ; JUSBC.4 8.08,40.5 ; JUSBC.4 5.62,42.06 ; JUSBC.4 6.85,40.5 ; JUSBC.4 8.08,41.28 ; 5.63,50.7 JUSBC.5 ; JUSBC.5 7.07,50.7 ; JUSBC.5 5.63,48.69 ; JUSBC.5 6.35,48.69 ; JUSBC.5 6.35,50.7 ; JUSBC.5 5.63,49.6 ; JUSBC.5 7.07,48.69 ; 217.51,197.49 H60.1 ; H60.1 219,198.03 ; H60.1 216.97,196 ; H60.1 220.49,194.51 ; H60.1 220.49,197.49 ; H60.1 217.51,194.51 ; H60.1 219,193.97 ; H60.1 221.03,196 ; 382.35,28.07 JUSB3.10 ; JUSB3.10 383.68,29.73 ; JUSB3.10 382.35,29.73 ; JUSB3.10 381.02,28.9 ; JUSB3.10 381.02,29.73 ; JUSB3.10 381.02,28.07 ; JUSB3.10 383.68,28.9 ; JUSB3.10 383.68,28.07 ; H59.1 281.3,18.72 ; H59.1 281.3,14.56 ; H59.1 283.38,16.64 ; H59.1 279.22,16.64 ; H59.1 279.78,18.16 ; H59.1 282.82,15.12 ; H59.1 282.82,18.16 ; H59.1 279.78,15.12 ; 8.2,4.57 H46.1 ; H46.1 8.2,8.43 ; H46.1 6.78,5.08 ; H46.1 6.78,7.92 ; H46.1 6.27,6.5 ; H46.1 9.62,7.92 ; H46.1 10.13,6.5 ; H46.1 9.62,5.08 ; JSSD2.76 389.95,7.31 ; JSSD2.76 390.57,4.79 ; JSSD2.76 390.57,6.05 ; JSSD2.76 389.95,4.79 ; JSSD2.76 390.57,7.31 ; H56.1 292.59,117.49 ; H56.1 289.61,114.51 ; H56.1 291.1,113.97 ; H56.1 291.1,118.03 ; H56.1 289.61,117.49 ; H56.1 292.59,114.51 ; H56.1 293.13,116 ; H56.1 289.07,116 ; 329.78,15.12 H57.1 ; H57.1 329.78,18.16 ; H57.1 331.3,18.72 ; H57.1 329.22,16.64 ; H57.1 332.82,18.16 ; H57.1 332.82,15.12 ; H57.1 333.38,16.64 ; H57.1 331.3,14.56 ; 305.78,64.92 H51.1 ; H51.1 305.78,62.08 ; H51.1 308.62,62.08 ; H51.1 308.62,64.92 ; H51.1 305.27,63.5 ; H51.1 307.2,61.57 ; H51.1 309.13,63.5 ; H51.1 307.2,65.43 ; 270.87,6.5 H48.1 ; H48.1 272.8,4.57 ; H48.1 274.73,6.5 ; H48.1 271.38,5.08 ; H48.1 271.38,7.92 ; H48.1 272.8,8.43 ; H48.1 274.22,7.92 ; H48.1 274.22,5.08 ; H49.1 193.62,5.08 ; H49.1 190.78,7.92 ; H49.1 192.2,4.57 ; H49.1 194.13,6.5 ; H49.1 192.2,8.43 ; H49.1 193.62,7.92 ; H49.1 190.78,5.08 ; H49.1 190.27,6.5 ; H70.1 168.19,120.19 ; H70.1 165.21,117.21 ; H70.1 166.7,116.67 ; H70.1 164.67,118.7 ; H70.1 168.73,118.7 ; H70.1 168.19,117.21 ; H70.1 165.21,120.19 ; H70.1 166.7,120.73 ; JUSBC.6 7.07,42.51 ; JUSBC.6 5.63,41.61 ; JUSBC.6 7.07,40.5 ; JUSBC.6 6.35,40.5 ; JUSBC.6 5.63,40.5 ; JUSBC.6 5.63,42.51 ; JUSBC.6 6.35,42.51 ; 390.42,31.03 JUSB3.11 ; JUSB3.11 390.42,30.2 ; JUSB3.11 391.6,31.03 ; JUSB3.11 392.78,30.2 ; JUSB3.11 392.78,31.03 ; JUSB1.12 15.59,16.96 ; JUSB1.12 13.84,16.96 ; JUSB1.12 17.34,16.1 ; JUSB1.12 13.84,16.1 ; JUSB1.12 17.34,16.96 ; JUSB1.12 13.84,15.24 ; JUSB1.12 17.34,15.24 ; JUSB1.12 15.59,15.24 ; 1.8,40.45 JUSBC.3 ; JUSBC.3 3.22,42.11 ; JUSBC.3 0.38,42.11 ; JUSBC.3 1.8,42.11 ; JUSBC.3 3.22,41.28 ; JUSBC.3 0.38,40.45 ; JUSBC.3 0.38,41.28 ; JUSBC.3 3.22,40.45 ; 14.92,22.5 JUSB1.7 ; JUSB1.7 16.44,22.5 ; JUSB1.7 15.68,21.74 ; JUSB1.7 15.09,21.91 ; JUSB1.7 15.09,23.09 ; JUSB1.7 15.68,23.26 ; JUSB1.7 16.27,23.09 ; JUSB1.7 16.27,21.91 ; H3.1 115.9,20.1 ; H3.1 114.2,16.06 ; H3.1 115.9,16.7 ; H3.1 114.2,20.74 ; H3.1 112.5,20.1 ; H3.1 116.54,18.4 ; H3.1 112.5,16.7 ; H3.1 111.86,18.4 ; 16.59,19.59 JUSB1.4 ; JUSB1.4 17.18,18.24 ; JUSB1.4 17.94,19 ; JUSB1.4 16.42,19 ; JUSB1.4 17.77,18.41 ; JUSB1.4 17.77,19.59 ; JUSB1.4 16.59,18.41 ; JUSB1.4 17.18,19.76 ; H4.1 121.55,101.3 ; H4.1 121.55,104.7 ; H4.1 117.51,103 ; H4.1 119.85,100.66 ; H4.1 118.15,101.3 ; H4.1 119.85,105.34 ; H4.1 118.15,104.7 ; H4.1 122.19,103 ; 186.2,195.34 JCDRA.48 ; JCDRA.48 186.2,196.9 ; JCDRA.48 186.2,198.46 ; JCDRA.48 187.2,198.46 ; JCDRA.48 188.2,195.34 ; JCDRA.48 188.2,198.46 ; JCDRA.48 187.2,195.34 ; JCDRA.48 188.2,196.9 ; H53.1 291.62,105.28 ; H53.1 290.2,104.77 ; H53.1 288.78,108.12 ; H53.1 290.2,108.63 ; H53.1 288.27,106.7 ; H53.1 288.78,105.28 ; H53.1 292.13,106.7 ; H53.1 291.62,108.12 ; H55.1 395.2,8.43 ; H55.1 393.27,6.5 ; H55.1 393.78,5.08 ; H55.1 396.62,5.08 ; H55.1 396.62,7.92 ; H55.1 397.13,6.5 ; H55.1 393.78,7.92 ; H55.1 395.2,4.57 ; JPCMC.36 63.6,43.1 ; JPCMC.36 63.6,46.71 ; JPCMC.36 59.32,44.91 ; JPCMC.36 60,43.1 ; JPCMC.36 64.27,44.91 ; JPCMC.36 61.8,47.38 ; JLAN.15 196.68,198.11 ; JLAN.15 195.85,194.76 ; JLAN.15 196.68,196.44 ; JLAN.15 196.68,194.76 ; JLAN.15 195.85,198.11 ; JLAN.15 195.02,198.11 ; JLAN.15 195.02,196.44 ; JLAN.15 195.02,194.76 ; 180.72,18.4 H2.1 ; H2.1 181.36,16.7 ; H2.1 183.06,20.74 ; H2.1 184.76,16.7 ; H2.1 183.06,16.06 ; H2.1 181.36,20.1 ; H2.1 184.76,20.1 ; H2.1 185.4,18.4 ; H58.1 309.25,44.13 ; H58.1 307.76,40.61 ; H58.1 311.28,42.1 ; H58.1 310.74,43.59 ; H58.1 310.74,40.61 ; H58.1 307.22,42.1 ; H58.1 307.76,43.59 ; H58.1 309.25,40.07 ; 382.01,25.37 JUSB3.4 ; JUSB3.4 382.65,26.83 ; JUSB3.4 381.82,26 ; JUSB3.4 382.65,25.17 ; JUSB3.4 382.01,26.64 ; JUSB3.4 383.28,25.37 ; H65.1 133.09,37.9 ; H65.1 129.05,39.6 ; H65.1 132.45,36.2 ; H65.1 130.75,35.56 ; H65.1 130.75,40.24 ; H65.1 128.41,37.9 ; H65.1 129.05,36.2 ; H65.1 132.45,39.6 ; 381.02,16.1 JUSB3.12 ; JUSB3.12 383.68,16.93 ; JUSB3.12 382.35,16.93 ; JUSB3.12 382.35,15.27 ; JUSB3.12 383.68,16.1 ; JUSB3.12 381.02,16.93 ; JUSB3.12 383.68,15.27 ; 175.51,103 H5.1 ; H5.1 176.15,101.3 ; H5.1 179.55,101.3 ; H5.1 177.85,100.66 ; H5.1 177.85,105.34 ; H5.1 180.19,103 ; H5.1 179.55,104.7 ; H5.1 176.15,104.7 ; JUSB2.11 392.78,51.03 ; JUSB2.11 392.78,50.2 ; JUSB2.11 390.42,51.03 ; JUSB2.11 390.42,50.2 ; JUSB2.11 391.6,51.03 ; H52.1 96.2,71.43 ; H52.1 94.78,70.92 ; H52.1 97.62,68.08 ; H52.1 97.62,70.92 ; H52.1 98.13,69.5 ; H52.1 94.78,68.08 ; H52.1 96.2,67.57 ; H52.1 94.27,69.5 ; 383.52,41.87 JUSB2.7 ; JUSB2.7 383.32,42.5 ; JUSB2.7 384.79,43.14 ; JUSB2.7 383.52,43.14 ; JUSB2.7 384.15,43.33 ; JUSB2.7 384.79,41.87 ; JUSB2.7 384.15,41.67 ; JUSB2.12 383.68,36.93 ; JUSB2.12 383.68,35.27 ; JUSB2.12 382.35,36.93 ; JUSB2.12 381.02,35.27 ; JUSB2.12 381.02,36.1 ; JUSB2.12 382.35,35.27 ; JUSB2.12 381.02,36.93 ; JUSB2.12 383.68,36.1 ; 165.05,39.6 H1.1 ; H1.1 169.09,37.9 ; H1.1 165.05,36.2 ; H1.1 166.75,35.56 ; H1.1 164.41,37.9 ; H1.1 168.45,36.2 ; H1.1 166.75,40.24 ; H1.1 168.45,39.6 ; JCDRA.49 155.7,192.3 ; JCDRA.49 154.7,193.86 ; JCDRA.49 155.7,193.86 ; JCDRA.49 155.7,190.74 ; JCDRA.49 154.7,190.74 ; JCDRA.49 153.7,192.3 ; JCDRA.49 153.7,193.86 ; JCDRA.49 153.7,190.74 ; H45.1 7.93,55.1 ; H45.1 7.42,53.68 ; H45.1 4.58,56.52 ; H45.1 6,57.03 ; H45.1 6,53.17 ; H45.1 4.07,55.1 ; H45.1 7.42,56.52 ; H45.1 4.58,53.68 ; 389.27,55.1 H54.1 ; H54.1 392.62,53.68 ; H54.1 389.78,53.68 ; H54.1 389.78,56.52 ; H54.1 392.62,56.52 ; H54.1 391.2,53.17 ; H54.1 393.13,55.1 ; H54.1 391.2,57.03 ; 382.65,45.17 JUSB2.4 ; JUSB2.4 382.01,46.64 ; JUSB2.4 382.01,45.37 ; JUSB2.4 382.65,46.83 ; JUSB2.4 383.28,45.37 ; JUSB2.4 381.82,46 ; JUSB2.10 383.68,48.9 ; JUSB2.10 382.35,49.73 ; JUSB2.10 381.02,48.07 ; JUSB2.10 381.02,48.9 ; JUSB2.10 381.02,49.73 ; JUSB2.10 382.35,48.07 ; JUSB2.10 383.68,48.07 ; JUSB2.10 383.68,49.73 ; 89.77,12 H50.1 ; H50.1 93.12,10.58 ; H50.1 90.28,10.58 ; H50.1 91.7,10.07 ; H50.1 93.12,13.42 ; H50.1 91.7,13.93 ; H50.1 90.28,13.42 ; H50.1 93.63,12 ; 5.32,14.6 JUSB1.14 ; JUSB1.14 5.32,13.74 ; JUSB1.14 8.34,13.74 ; JUSB1.14 6.83,13.74 ; JUSB1.14 8.34,14.6 ; 146.41,98.96 H8.1 ; H8.1 150.45,97.25 ; H8.1 147.05,100.66 ; H8.1 151.09,98.96 ; H8.1 150.45,100.66 ; H8.1 147.05,97.25 ; H8.1 148.75,96.62 ; H8.1 148.75,101.3 ; JUSB1.13 8.34,31.26 ; JUSB1.13 6.83,31.26 ; JUSB1.13 5.32,30.4 ; JUSB1.13 8.34,30.4 ; JUSB1.13 5.32,31.26 ; 2.57,36.1 H47.1 ; H47.1 4.5,34.17 ; H47.1 6.43,36.1 ; H47.1 5.92,34.68 ; H47.1 3.08,34.68 ; H47.1 4.5,38.03 ; H47.1 3.08,37.52 ; H47.1 5.92,37.52 ; 211.2,151.07 H44.1 ; H44.1 209.78,154.42 ; H44.1 209.78,151.58 ; H44.1 212.62,154.42 ; H44.1 211.2,154.93 ; H44.1 213.13,153 ; H44.1 209.27,153 ; H44.1 212.62,151.58 ; 367.45,4.79 JSSD2.77 ; JSSD2.77 367.45,7.31 ; JSSD2.77 366.83,7.31 ; JSSD2.77 366.83,6.05 ; JSSD2.77 366.83,4.79 ; 0.38,49.09 JUSBC.1 ; JUSBC.1 1.8,49.09 ; JUSBC.1 3.22,50.75 ; JUSBC.1 1.8,50.75 ; JUSBC.1 3.22,49.92 ; JUSBC.1 3.22,49.09 ; JUSBC.1 0.38,50.75 ; JUSBC.1 0.38,49.92 ; 153.7,196.9 JCDRA.50 ; JCDRA.50 154.7,195.34 ; JCDRA.50 153.7,198.46 ; JCDRA.50 153.7,195.34 ; JCDRA.50 154.7,198.46 ; JCDRA.50 155.7,195.34 ; JCDRA.50 155.7,196.9 ; JCDRA.50 155.7,198.46 ; H63.1 193.4,197.8 ; H63.1 189.36,196.1 ; H63.1 191.7,193.76 ; H63.1 191.7,198.44 ; H63.1 193.4,194.4 ; H63.1 190,197.8 ; H63.1 190,194.4 ; H63.1 194.04,196.1 ; JUSB3.7 384.79,21.87 ; JUSB3.7 383.52,23.14 ; JUSB3.7 384.79,23.14 ; JUSB3.7 384.15,23.33 ; JUSB3.7 383.32,22.5 ; JUSB3.7 383.52,21.87 ; JUSB3.7 384.15,21.67 ; JLAN.14 216.18,194.76 ; JLAN.14 214.52,196.44 ; JLAN.14 215.35,198.11 ; JLAN.14 216.18,196.44 ; JLAN.14 214.52,194.76 ; JLAN.14 214.52,198.11 ; JLAN.14 215.35,194.76 ; JLAN.14 216.18,198.11 ; JUSB3.13 392.78,14.8 ; JUSB3.13 392.78,13.97 ; JUSB3.13 390.42,13.97 ; JUSB3.13 390.42,14.8 ; JUSB3.13 391.6,13.97
  IN4 w0.508: v2(20.18,37.32) 21.19,37.32 v2(21.28,37.23)
  GND4 w0.203: 389.78,56.52 H54.1 ; H54.1 389.27,55.1 ; H54.1 393.13,55.1 ; H54.1 392.62,56.52 ; H54.1 391.2,57.03 ; H54.1 389.78,53.68 ; H54.1 391.2,53.17 ; H54.1 392.62,53.68 ; H44.1 212.62,154.42 ; H44.1 209.27,153 ; H44.1 211.2,151.07 ; H44.1 209.78,154.42 ; H44.1 212.62,151.58 ; H44.1 211.2,154.93 ; H44.1 213.13,153 ; H44.1 209.78,151.58 ; H59.1 282.82,18.16 ; H59.1 279.78,18.16 ; H59.1 283.38,16.64 ; H59.1 282.82,15.12 ; H59.1 279.22,16.64 ; H59.1 279.78,15.12 ; H59.1 281.3,14.56 ; H59.1 281.3,18.72 ; 153.7,192.3 JCDRA.49 ; JCDRA.49 154.7,193.86 ; JCDRA.49 154.7,190.74 ; JCDRA.49 155.7,193.86 ; JCDRA.49 153.7,190.74 ; JCDRA.49 153.7,193.86 ; JCDRA.49 155.7,192.3 ; JCDRA.49 155.7,190.74 ; JCDRA.50 155.7,195.34 ; JCDRA.50 154.7,195.34 ; JCDRA.50 155.7,198.46 ; JCDRA.50 155.7,196.9 ; JCDRA.50 153.7,196.9 ; JCDRA.50 153.7,198.46 ; JCDRA.50 154.7,198.46 ; JCDRA.50 153.7,195.34 ; 382.35,35.27 JUSB2.12 ; JUSB2.12 383.68,35.27 ; JUSB2.12 381.02,36.1 ; JUSB2.12 383.68,36.93 ; JUSB2.12 381.02,36.93 ; JUSB2.12 382.35,36.93 ; JUSB2.12 381.02,35.27 ; JUSB2.12 383.68,36.1 ; 390.42,34.8 JUSB2.13 ; JUSB2.13 392.78,33.97 ; JUSB2.13 392.78,34.8 ; JUSB2.13 391.6,33.97 ; JUSB2.13 390.42,33.97 ; 383.52,23.14 JUSB3.7 ; JUSB3.7 383.52,21.87 ; JUSB3.7 383.32,22.5 ; JUSB3.7 384.15,21.67 ; JUSB3.7 384.79,21.87 ; JUSB3.7 384.15,23.33 ; JUSB3.7 384.79,23.14 ; H52.1 97.62,68.08 ; H52.1 98.13,69.5 ; H52.1 97.62,70.92 ; H52.1 96.2,71.43 ; H52.1 96.2,67.57 ; H52.1 94.78,70.92 ; H52.1 94.27,69.5 ; H52.1 94.78,68.08 ; H3.1 116.54,18.4 ; H3.1 115.9,20.1 ; H3.1 111.86,18.4 ; H3.1 112.5,16.7 ; H3.1 115.9,16.7 ; H3.1 112.5,20.1 ; H3.1 114.2,16.06 ; H3.1 114.2,20.74 ; H2.1 185.4,18.4 ; H2.1 181.36,20.1 ; H2.1 180.72,18.4 ; H2.1 181.36,16.7 ; H2.1 183.06,20.74 ; H2.1 183.06,16.06 ; H2.1 184.76,20.1 ; H2.1 184.76,16.7 ; H55.1 397.13,6.5 ; H55.1 395.2,8.43 ; H55.1 396.62,7.92 ; H55.1 395.2,4.57 ; H55.1 393.27,6.5 ; H55.1 393.78,5.08 ; H55.1 396.62,5.08 ; H55.1 393.78,7.92 ; JUSB1.4 17.77,19.59 ; JUSB1.4 16.42,19 ; JUSB1.4 17.77,18.41 ; JUSB1.4 16.59,19.59 ; JUSB1.4 17.18,19.76 ; JUSB1.4 17.18,18.24 ; JUSB1.4 16.59,18.41 ; JUSB1.4 17.94,19 ; 5.32,31.26 JUSB1.13 ; JUSB1.13 5.32,30.4 ; JUSB1.13 8.34,31.26 ; JUSB1.13 8.34,30.4 ; JUSB1.13 6.83,31.26 ; 6.78,5.08 H46.1 ; H46.1 10.13,6.5 ; H46.1 9.62,5.08 ; H46.1 8.2,8.43 ; H46.1 6.27,6.5 ; H46.1 6.78,7.92 ; H46.1 8.2,4.57 ; H46.1 9.62,7.92 ; 15.68,21.74 JUSB1.7 ; JUSB1.7 16.27,23.09 ; JUSB1.7 15.68,23.26 ; JUSB1.7 15.09,21.91 ; JUSB1.7 15.09,23.09 ; JUSB1.7 16.44,22.5 ; JUSB1.7 14.92,22.5 ; JUSB1.7 16.27,21.91 ; 15.59,15.24 JUSB1.12 ; JUSB1.12 13.84,15.24 ; JUSB1.12 17.34,16.96 ; JUSB1.12 15.59,16.96 ; JUSB1.12 13.84,16.1 ; JUSB1.12 17.34,15.24 ; JUSB1.12 17.34,16.1 ; JUSB1.12 13.84,16.96 ; 381.02,48.07 JUSB2.10 ; JUSB2.10 383.68,49.73 ; JUSB2.10 383.68,48.9 ; JUSB2.10 381.02,49.73 ; JUSB2.10 383.68,48.07 ; JUSB2.10 381.02,48.9 ; JUSB2.10 382.35,49.73 ; JUSB2.10 382.35,48.07 ; H42.1 171.05,159.4 ; H42.1 169.35,160.04 ; H42.1 167.65,156 ; H42.1 171.05,156 ; H42.1 167.65,159.4 ; H42.1 167.01,157.7 ; H42.1 171.69,157.7 ; H42.1 169.35,155.36 ; H45.1 7.42,56.52 ; H45.1 4.58,56.52 ; H45.1 7.42,53.68 ; H45.1 4.58,53.68 ; H45.1 4.07,55.1 ; H45.1 6,53.17 ; H45.1 7.93,55.1 ; H45.1 6,57.03 ; 381.02,28.07 JUSB3.10 ; JUSB3.10 383.68,28.07 ; JUSB3.10 382.35,28.07 ; JUSB3.10 381.02,28.9 ; JUSB3.10 381.02,29.73 ; JUSB3.10 383.68,28.9 ; JUSB3.10 382.35,29.73 ; JUSB3.10 383.68,29.73 ; 3.08,34.68 H47.1 ; H47.1 3.08,37.52 ; H47.1 5.92,34.68 ; H47.1 4.5,34.17 ; H47.1 2.57,36.1 ; H47.1 4.5,38.03 ; H47.1 6.43,36.1 ; H47.1 5.92,37.52 ; 91.7,10.07 H50.1 ; H50.1 93.12,13.42 ; H50.1 89.77,12 ; H50.1 93.12,10.58 ; H50.1 91.7,13.93 ; H50.1 90.28,13.42 ; H50.1 90.28,10.58 ; H50.1 93.63,12 ; H1.1 168.45,36.2 ; H1.1 164.41,37.9 ; H1.1 166.75,40.24 ; H1.1 168.45,39.6 ; H1.1 166.75,35.56 ; H1.1 165.05,36.2 ; H1.1 165.05,39.6 ; H1.1 169.09,37.9 ; 165.21,120.19 H70.1 ; H70.1 168.73,118.7 ; H70.1 165.21,117.21 ; H70.1 166.7,120.73 ; H70.1 168.19,117.21 ; H70.1 164.67,118.7 ; H70.1 168.19,120.19 ; H70.1 166.7,116.67 ; JUSB2.11 391.6,51.03 ; JUSB2.11 390.42,50.2 ; JUSB2.11 392.78,51.03 ; JUSB2.11 392.78,50.2 ; JUSB2.11 390.42,51.03 ; H43.1 109.62,138.92 ; H43.1 110.13,137.5 ; H43.1 108.2,139.43 ; H43.1 108.2,135.57 ; H43.1 109.62,136.08 ; H43.1 106.27,137.5 ; H43.1 106.78,138.92 ; H43.1 106.78,136.08 ; H5.1 179.55,101.3 ; H5.1 176.15,104.7 ; H5.1 176.15,101.3 ; H5.1 177.85,100.66 ; H5.1 175.51,103 ; H5.1 179.55,104.7 ; H5.1 180.19,103 ; H5.1 177.85,105.34 ; 288.78,105.28 H53.1 ; H53.1 288.78,108.12 ; H53.1 288.27,106.7 ; H53.1 292.13,106.7 ; H53.1 291.62,108.12 ; H53.1 290.2,108.63 ; H53.1 291.62,105.28 ; H53.1 290.2,104.77 ; 390.42,31.03 JUSB3.11 ; JUSB3.11 392.78,31.03 ; JUSB3.11 390.42,30.2 ; JUSB3.11 392.78,30.2 ; JUSB3.11 391.6,31.03 ; H63.1 193.4,194.4 ; H63.1 189.36,196.1 ; H63.1 194.04,196.1 ; H63.1 193.4,197.8 ; H63.1 190,197.8 ; H63.1 191.7,193.76 ; H63.1 190,194.4 ; H63.1 191.7,198.44 ; H60.1 220.49,197.49 ; H60.1 220.49,194.51 ; H60.1 221.03,196 ; H60.1 217.51,194.51 ; H60.1 216.97,196 ; H60.1 217.51,197.49 ; H60.1 219,198.03 ; H60.1 219,193.97 ; H49.1 192.2,8.43 ; H49.1 190.78,5.08 ; H49.1 194.13,6.5 ; H49.1 193.62,5.08 ; H49.1 193.62,7.92 ; H49.1 192.2,4.57 ; H49.1 190.27,6.5 ; H49.1 190.78,7.92 ; 307.76,40.61 H58.1 ; H58.1 307.76,43.59 ; H58.1 309.25,44.13 ; H58.1 311.28,42.1 ; H58.1 309.25,40.07 ; H58.1 310.74,43.59 ; H58.1 310.74,40.61 ; H58.1 307.22,42.1 ; H56.1 291.1,118.03 ; H56.1 292.59,114.51 ; H56.1 292.59,117.49 ; H56.1 289.61,114.51 ; H56.1 291.1,113.97 ; H56.1 289.07,116 ; H56.1 293.13,116 ; H56.1 289.61,117.49 ; H51.1 307.2,65.43 ; H51.1 307.2,61.57 ; H51.1 305.78,64.92 ; H51.1 309.13,63.5 ; H51.1 308.62,64.92 ; H51.1 305.27,63.5 ; H51.1 308.62,62.08 ; H51.1 305.78,62.08 ; JUSB1.14 8.34,13.74 ; JUSB1.14 5.32,13.74 ; JUSB1.14 8.34,14.6 ; JUSB1.14 6.83,13.74 ; JUSB1.14 5.32,14.6 ; 187.2,190.74 JCDRA.47 ; JCDRA.47 188.2,190.74 ; JCDRA.47 186.2,193.86 ; JCDRA.47 187.2,193.86 ; JCDRA.47 188.2,192.3 ; JCDRA.47 186.2,190.74 ; JCDRA.47 186.2,192.3 ; JCDRA.47 188.2,193.86 ; JLAN.15 196.68,194.76 ; JLAN.15 196.68,196.44 ; JLAN.15 195.85,194.76 ; JLAN.15 195.02,198.11 ; JLAN.15 195.85,198.11 ; JLAN.15 195.02,194.76 ; JLAN.15 195.02,196.44 ; JLAN.15 196.68,198.11 ; 271.38,5.08 H48.1 ; H48.1 272.8,4.57 ; H48.1 271.38,7.92 ; H48.1 274.22,5.08 ; H48.1 274.22,7.92 ; H48.1 274.73,6.5 ; H48.1 270.87,6.5 ; H48.1 272.8,8.43 ; 383.52,43.14 JUSB2.7 ; JUSB2.7 383.32,42.5 ; JUSB2.7 384.79,43.14 ; JUSB2.7 384.79,41.87 ; JUSB2.7 384.15,41.67 ; JUSB2.7 384.15,43.33 ; JUSB2.7 383.52,41.87 ; H4.1 121.55,101.3 ; H4.1 117.51,103 ; H4.1 119.85,105.34 ; H4.1 121.55,104.7 ; H4.1 119.85,100.66 ; H4.1 122.19,103 ; H4.1 118.15,104.7 ; H4.1 118.15,101.3 ; JUSBC.3 3.22,40.45 ; JUSBC.3 3.22,42.11 ; JUSBC.3 1.8,40.45 ; JUSBC.3 0.38,41.28 ; JUSBC.3 3.22,41.28 ; JUSBC.3 0.38,40.45 ; JUSBC.3 0.38,42.11 ; JUSBC.3 1.8,42.11 ; JCDRA.48 188.2,198.46 ; JCDRA.48 186.2,195.34 ; JCDRA.48 186.2,198.46 ; JCDRA.48 186.2,196.9 ; JCDRA.48 187.2,195.34 ; JCDRA.48 188.2,195.34 ; JCDRA.48 187.2,198.46 ; JCDRA.48 188.2,196.9 ; 390.42,13.97 JUSB3.13 ; JUSB3.13 392.78,13.97 ; JUSB3.13 392.78,14.8 ; JUSB3.13 391.6,13.97 ; JUSB3.13 390.42,14.8 ; JSSD2.76 390.57,7.31 ; JSSD2.76 389.95,7.31 ; JSSD2.76 390.57,4.79 ; JSSD2.76 389.95,4.79 ; JSSD2.76 390.57,6.05 ; 0.38,50.75 JUSBC.1 ; JUSBC.1 3.22,50.75 ; JUSBC.1 0.38,49.92 ; JUSBC.1 3.22,49.09 ; JUSBC.1 0.38,49.09 ; JUSBC.1 1.8,50.75 ; JUSBC.1 3.22,49.92 ; JUSBC.1 1.8,49.09 ; JSSD2.77 367.45,7.31 ; JSSD2.77 366.83,7.31 ; JSSD2.77 366.83,6.05 ; JSSD2.77 367.45,4.79 ; JSSD2.77 366.83,4.79 ; JLAN.14 215.35,198.11 ; JLAN.14 214.52,194.76 ; JLAN.14 216.18,198.11 ; JLAN.14 215.35,194.76 ; JLAN.14 216.18,196.44 ; JLAN.14 214.52,198.11 ; JLAN.14 214.52,196.44 ; JLAN.14 216.18,194.76 ; JUSBC.6 7.07,40.5 ; JUSBC.6 6.35,40.5 ; JUSBC.6 5.63,40.5 ; JUSBC.6 6.35,42.51 ; JUSBC.6 5.63,41.61 ; JUSBC.6 7.07,42.51 ; JUSBC.6 5.63,42.51 ; 5.62,41.28 JUSBC.4 ; JUSBC.4 5.62,42.06 ; JUSBC.4 6.85,40.5 ; JUSBC.4 5.62,40.5 ; JUSBC.4 8.08,40.5 ; JUSBC.4 8.08,42.06 ; JUSBC.4 8.08,41.28 ; 329.78,15.12 H57.1 ; H57.1 331.3,14.56 ; H57.1 331.3,18.72 ; H57.1 332.82,15.12 ; H57.1 333.38,16.64 ; H57.1 329.78,18.16 ; H57.1 332.82,18.16 ; H57.1 329.22,16.64 ; 382.65,45.17 JUSB2.4 ; JUSB2.4 381.82,46 ; JUSB2.4 382.01,46.64 ; JUSB2.4 383.28,45.37 ; JUSB2.4 382.65,46.83 ; JUSB2.4 382.01,45.37 ; JPCMC.36 64.27,44.91 ; JPCMC.36 60,43.1 ; JPCMC.36 59.32,44.91 ; JPCMC.36 63.6,43.1 ; JPCMC.36 61.8,47.38 ; JPCMC.36 63.6,46.71 ; 148.75,96.62 H8.1 ; H8.1 147.05,100.66 ; H8.1 150.45,100.66 ; H8.1 146.41,98.96 ; H8.1 150.45,97.25 ; H8.1 148.75,101.3 ; H8.1 147.05,97.25 ; H8.1 151.09,98.96 ; 15.59,28.04 JUSB1.11 ; JUSB1.11 13.84,28.9 ; JUSB1.11 17.34,29.76 ; JUSB1.11 13.84,28.04 ; JUSB1.11 15.59,29.76 ; JUSB1.11 17.34,28.04 ; JUSB1.11 13.84,29.76 ; JUSB1.11 17.34,28.9 ; JUSB3.12 383.68,15.27 ; JUSB3.12 381.02,16.93 ; JUSB3.12 382.35,16.93 ; JUSB3.12 383.68,16.93 ; JUSB3.12 381.02,16.1 ; JUSB3.12 383.68,16.1 ; JUSB3.12 382.35,15.27 ; 5.63,48.69 JUSBC.5 ; JUSBC.5 7.07,50.7 ; JUSBC.5 6.35,48.69 ; JUSBC.5 5.63,50.7 ; JUSBC.5 6.35,50.7 ; JUSBC.5 7.07,48.69 ; JUSBC.5 5.63,49.6 ; JUSBC.2 8.08,49.14 ; JUSBC.2 5.62,50.7 ; JUSBC.2 5.62,49.14 ; JUSBC.2 8.08,50.7 ; JUSBC.2 6.85,50.7 ; JUSBC.2 8.08,49.92 ; JUSBC.2 5.62,49.92 ; H65.1 130.75,40.24 ; H65.1 132.45,36.2 ; H65.1 132.45,39.6 ; H65.1 129.05,36.2 ; H65.1 130.75,35.56 ; H65.1 128.41,37.9 ; H65.1 133.09,37.9 ; H65.1 129.05,39.6 ; JUSB3.4 382.65,26.83 ; JUSB3.4 382.01,26.64 ; JUSB3.4 382.65,25.17 ; JUSB3.4 382.01,25.37 ; JUSB3.4 383.28,25.37 ; JUSB3.4 381.82,26
  BOTTOM w0.076: v2(45.07,44.06) 45.05,44.08 45.05,44.91 44.9,45.07 UT4.B8 ; UT4.L11 46.36,49.57 v2(46.74,49.2)
  BOTTOM w0.127: v2(18.95,39.21) UT1.A20 UT1.B20 ; v2(31.19,38.07) 30.4,38.07 30.19,38.29 UT1.AC22 ; v2(185.2,160.81) 185.2,161.6 183.9,162.9 183,162.9 182.74,162.64 182.74,162.29 183.01,162.03 v2(183.01,161.38)
  BOTTOM w0.178: UT1.P2 UT1.P1 25.47,47.98 24.98,48.47 v2(24.89,48.47) ; v2(30.31,40.19) 30.3,40.19 30.24,40.13 UT1.AC18 UT1.AB18 ; UT1.AC20 30.18,39.21 30.24,39.15 v2(30.31,39.15) ; v2(30.81,43) 30.79,43 30.67,42.89 UT1.AC12 UT1.AB12 ; v2(30.19,48.53) 30.02,48.53 29.74,48.26 29.46,48.26 UT1.AB1 UT1.AB2 ; UT1.W22 UT1.W23 27.77,37.59 27.77,37.58 27.77,37.39 v2(27.84,37.32) ; UT1.AA22 UT1.AA23 28.69,37.71 29.05,37.35 v2(29.13,37.35) ; v2(18.89,42.89) UT1.A12 UT1.B12 ; UT1.R22 UT1.R23 25.93,37.6 25.98,37.55 v2(25.98,37.35) ; v2(26.95,37.26) 26.85,37.36 UT1.U23 UT1.U22 ; UT1.N22 UT1.N23 25.01,37.41 25.07,37.35 v2(25.07,37.29) ; UT1.T2 UT1.T1 ; UT1.E22 UT1.E23 21.33,37.28 v2(21.28,37.23) ; v2(20.18,37.32) 20.41,37.55 UT1.C23 UT1.C22 ; UT1.AB8 UT1.AC8 30.25,44.73 30.34,44.83 31.14,44.83 v2(31.15,44.83) ; UT1.AC16 UT1.AB16 ; UT1.AB14 UT1.AC14 30.06,41.97 30.09,42 v2(30.23,42) ; v2(30.44,45.74) 30.32,45.62 29.64,45.62 UT1.AC6 UT1.AB6 ; UT1.G22 UT1.G23 22.25,37.4 v2(22.18,37.33) ; v2(18.97,45.39) 19.23,45.65 UT1.A6 UT1.B6 ; v2(24.05,48.46) 24,48.46 23.63,48.09 UT1.K1 ; UT1.AC1 UT1.AC2 29.65,47.49 30.08,47.93 v2(30.08,47.93) ; v2(18.95,42.19) 19.17,41.97 UT1.A14 UT1.B14 ; v2(30.22,43.92) 30.15,43.84 29.91,43.84 29.8,43.81 UT1.AC10 UT1.AB10 ; UT1.L22 UT1.L23 24.09,37.36 v2(24.05,37.32) ; v2(18.93,41.05) UT1.A16 UT1.B16 ; UT1.B22 UT1.A22 19.45,38.25 19.07,38.25 v2(18.95,38.12) ; UT1.B18 UT1.A18 v2(18.82,40.13) ; UT1.J22 UT1.J23 23.17,37.27 v2(23.09,37.2) ; UT1.H2 UT1.H1 ; UT1.B10 UT1.A10 ; UT1.M2 UT1.M1
  BOTTOM w0.203: v2(30.79,41.3) 30.54,41.05 UT1.AC16 ; UT1.H2 22.71,47.49 22.93,47.26 v2(22.93,47.1) ; PUS1.20 125.99,145.48 v2(126.19,145.28) ; UT4.H8 44.79,48.17 45.18,48.56 v2(45.23,48.56) ; UT1.R18 v2(26.17,39.96) ; UT1.B18 20.36,40.13 ; v2(148.39,145.69) 148.37,145.69 PUS2.20 ; UC1.AK28 UC1.AK29 UC1.AK30 ; PUS2.32 151.3,141.37 v2(151.4,141.27) ; PUS1.32 v2(129.05,143.88)
  BOTTOM w0.254: v2(26.19,27.39) 26.09,27.29 CT37.2 ; v2(151.03,50.7) 150.77,50.7 150.76,50.7 150.39,50.7 150.39,50.7 150.14,50.7 UC1.AA33 ; v2(151.03,50.7) 151.49,51.16 UC1.AC33 ; v2(151.03,50.7) 151.47,50.26 UC1.AC34 ; v2(12.53,48.78) DT6.2 ; DT6.2 v2(13.08,49.3) ; DT6.2 v2(13.6,48.78) ; UT1.W8 v2(27.47,44.52) ; v2(27.47,44.52) 27.54,44.52 27.8,44.26 UT1.W9 ; v2(27.47,44.52) UT1.V8 ; v2(27.47,44.52) UT1.V9 ; UC1.J10 v2(137.34,73.96) ; U2407.6 218.97,105.2 219.23,104.94 219.23,104.74 v2(219.23,104.74) ; RT127.2 RT126.2 v2(32.94,51.59) ; v2(20.97,45.17) UT1.E6 UT1.E5 ; v2(20.97,45.17) UT1.D8 ; v2(20.97,45.17) UT1.E8 ; v2(343.95,34.45) 343.83,34.45 343.72,34.35 JWLAN.7 ; RT46.2 16.64,43.1 v2(15.87,43.86) ; UT1.R5 v2(26.17,45.82) ; v2(26.17,45.82) UT1.T5 ; v2(26.17,45.82) UT1.T6 ; UT1.J15 v2(22.92,41.92) ; v2(22.92,41.92) UT1.H13 ; v2(22.92,41.92) UT1.H15 ; v2(22.92,41.92) UT1.J13 v2(23.57,41.92) ; JWLAN.19 343.74,37.35 v2(343.88,37.49) ; v2(336.96,37.17) 336.75,37.17 336.59,37.01 336.19,37.01 336.09,37.1 JWLAN.18 ; v2(301.19,52.98) 301.53,52.98 302,53.46 302.45,53.46 303.3,54.3 308.19,54.3 308.96,55.06 309.8,55.06 310.13,54.73 310.13,54.16 v2(309.91,53.93) 309.66,53.68 303.55,53.68 302.67,52.8 v2(302.67,51.92) ; PUI04.4 110.01,71.27 v2(110.8,70.48) ; v2(109.88,57.05) 109.86,57.05 109.6,57.3 PUI03.23 ; UC1.AW38 166.19,46.6 166.43,46.35 v2(166.65,46.35) ; v2(242.57,93.19) 242.59,93.19 242.47,93.07 242.47,91.84 243.04,91.28 JDIMM1.251 ; UC1.F36 135.98,48.43 v2(136.39,48.84) ; v2(40.52,43.73) 40.52,43.76 41.29,44.54 UT4.A1 ; DT12.2 10.92,46.77 v2(10.92,46.78) ; CT102.2 38.26,48.73 37.97,49.02 37.61,49.02 37.59,49 v2(37.59,49) ; CT154.2 31.88,35.8 CT153.2 ; RT4.2 22.52,50.42 22.91,50.42 22.92,50.41 RT47.2 23.11,50.42 23.78,51.08 RT5.2 ; UT1.L5 v2(23.57,45.82) UT1.J5 22.92,45.82 UT1.H5 22.59,46.14 v2(22.27,45.82) ; UT1.F6 21.95,45.5 v2(22.27,45.82) ; PCI46.2 111.74,67.78 PUI04.23 ; PUI02.4 v2(103.3,24.59) ; UC1.AK12 157.89,70.3 v2(157.51,69.92) ; UT1.N13 25.21,42.24 v2(25.53,41.92) 25.2,41.59 UT1.N15 ; UC1.R3 143.13,80.8 142.83,80.51 v2(142.8,80.51) ; v2(48.05,53.47) CT113.2 RT65.2 ; JWLAN.13 v2(344.05,35.85) ; 161.09,54.37 UC1.AP30 ; v2(160.17,58.95) 160.17,59.85 UC1.AN23 UC1.AN22 ; v2(286.3,42.99) 286.3,42.93 287.1,42.14 v2(287.22,42.14) 288.82,40.54 v2(288.82,40.43) 289.13,40.12 289.13,33.98 290.92,32.19 290.92,29.91 291.89,28.95 297.17,28.95 297.88,29.67 v2(298.09,29.67) 298.25,29.82 299.37,29.82 299.96,29.23 301.4,29.23 v2(301.52,29.36) 302.66,29.36 302.99,29.69 307.24,29.69 308.74,28.19 308.74,27.51 310.49,25.76 310.49,25.06 310.74,24.81 v2(310.74,23.21) 311.04,23.21 314.63,19.62 314.63,18.61 322.45,10.79 333.29,10.79 338.91,16.4 338.91,20.63 338.28,21.26 338.28,22.66 339.12,23.51 ; v2(286.3,42.99) 286.3,42.99 283.99,42.99 v2(283.86,43.12) 281.61,43.12 v2(281.57,43.16) 279.66,43.16 v2(279.51,43.31) 277.29,43.31 v2(277.1,43.12) 275.24,43.12 v2(275.14,43.02) 274.24,43.02 273.69,43.57 273.69,44.46 273.96,44.73 273.96,46.68 v2(273.84,46.81) 274.22,47.19 v2(274.22,47.94) 273.81,48.35 272.84,48.35 272.16,47.67 271.02,47.67 v2(270.71,47.36) 270.71,46.46 v2(270.92,46.25) 270.7,46.04 270.7,44.96 270.99,44.67 271.46,44.67 271.68,44.45 271.68,44.04 272.61,43.12 v2(272.81,43.12) 272.81,42.43 272.44,42.06 272.44,40.41 272.88,39.96 274.28,39.96 274.59,40.28 v2(274.59,41) 274.93,41.34 278.47,41.34 278.73,41.08 v2(279.63,41.08) 279.89,41.34 284.03,41.34 v2(284.82,40.56) 286.34,40.56 287.45,39.45 287.45,33.46 289.37,31.54 289.37,29.27 291.26,27.37 292.39,27.37 v2(292.71,27.05) 293.27,27.05 293.59,27.37 297.55,27.37 298.17,26.74 v2(299.09,26.74) 299.09,27.07 299.39,27.37 303.72,27.37 304.01,27.08 305.52,27.08 307.23,25.37 307.23,25.09 307.51,24.81 307.79,24.81 308.46,24.14 v2(308.46,23.09) 310.97,20.57 311.12,20.57 311.75,19.95 v2(311.75,19.71) v3(312.32,19.13) 312.42,19.03 312.42,17.65 313.21,16.86 314.18,16.86 321.81,9.23 334.43,9.23 v2(339.93,14.73) 339.93,14.87 340.56,15.5 v3(340.56,18.5) v2(340.56,21.46) 340.77,21.67 340.77,22.96 341.48,23.67 341.48,28.27 340.23,29.52 340.23,33.08 341.75,34.6 341.75,39.55 342,39.8 348.07,39.8 v3(348.83,40.57) 348.83,41.71 348.07,42.48 344.74,42.48 344.61,42.35 v2(343.88,42.35) ; v2(286.3,42.99) 286.62,43.31 v3(286.62,45.4) v2(286.62,46.75) 286.62,47.17 v2(285.85,47.93) 285.85,48.15 285.85,48.15 285.85,50.76 285.85,50.77 285.85,50.96 286.53,51.65 v2(286.98,51.65) 290.56,51.65 v2(290.57,51.64) 291.55,51.64 292.51,52.6 v2(293.93,52.6) 293.97,52.6 294.6,51.97 294.6,51.07 294.29,50.76 v3(292.13,50.76) 291.88,50.51 288.76,50.51 288.42,50.17 288.42,50.15 v2(288.33,50.06) 287.85,50.06 v2(287.72,50.19) v2(287.07,50.19) 286.98,50.1 v2(286.98,48.98) 286.98,48.21 287.56,47.63 287.56,44.08 v2(288.27,43.36) 290.03,41.61 290.03,34.27 291.13,33.17 PR1802.2 PC1805.2 292.24,32.27 291.76,31.79 291.76,30.26 292.24,29.79 296.82,29.79 298.56,31.53 PU1801.8 ; UC1.H1 136.86,83.53 136.74,83.65 v2(136.74,83.97) ; v2(29.52,13.82) 29.56,13.86 JAUDIO.27 ; v2(131.7,45.23) 131.7,46.01 UC1.B38 ; JAUDIO.26 30.06,13.66 29.6,13.21 v2(29.49,13.21) ; JHDD.3 v2(261.05,4.56) ; v2(26.83,41.92) 27.15,41.6 UT1.V15 ; v2(26.83,41.92) 26.5,41.59 UT1.T15 ; v2(26.83,41.92) 26.51,42.24 UT1.T13 ; v2(345.6,30.97) 344.87,30.97 344.45,31.39 344.45,31.9 343.5,32.85 JWLAN.1 ; CT112.2 46.88,53.15 v2(47.18,53.45) 47.47,53.17 RT64.2 ; DT4.2 v2(10.37,41.53) ; DT4.2 v2(11.02,40.97) ; DT4.2 v2(11.68,41.53) ; JSSD2.27 381.45,13.02 v2(381.82,13.38) 382.09,13.38 382.95,12.53 JSSD2.21 ; UT1.L20 v2(23.57,39.32) UT1.J19 ; v2(23.77,27.32) 23.77,27.11 24.02,26.85 CT38.2 ; DT7.2 v2(13.69,47.28) ; DT7.2 v2(12.51,47.28) ; DT7.2 v2(13.08,46.81) ; v2(23.57,45.17) UT1.J8 23.13,44.72 22.72,44.72 UT1.H8 ; UC1.AW3 164.98,80.8 164.52,80.35 v2(163.84,80.35) 163.84,81.05 164.29,81.51 UC1.AV2 ; v2(339.26,41.66) 340.17,40.75 340.17,36.44 v2(340.02,36.28) 340.02,36.23 339.53,35.74 339.47,35.74 v2(339.47,35.71) ; v2(339.26,41.66) v2(341.45,43.85) ; v2(339.26,41.66) 338.28,40.68 338.28,36.9 v2(339.47,35.71) ; PUS1.25 v2(129.16,146.68) ; 297.46,47.08 297.78,46.76 301.15,46.76 301.27,46.89 301.27,47.61 v2(301.45,47.79) v2(301.45,48.73) 301.45,49.25 301.27,49.43 ; 297.46,47.08 297.46,47.01 297.08,46.63 295.11,46.63 294.22,47.52 294.22,49.3 295.04,50.11 CH48.2 296.61,50.59 297.15,51.14 v2(299.05,51.14) 300.89,51.14 301.09,50.94 301.11,50.94 301.18,50.87 301.18,49.59 301.27,49.5 301.27,49.43 ; 297.46,47.08 v2(297.46,47.32) ; UC1.AJ31 UC1.AJ30 ; PUI06.4 105.87,51.16 v2(106.66,50.37) ; UC1.AK28 v2(158.35,56.2) UC1.AK27 158.36,57.12 v2(158.36,57.16) 157.94,57.57 UC1.AK26 157.89,57.65 v2(158.29,58.05) 157.89,58.45 UC1.AK25 UC1.AJ24 ; UT1.E4 21.65,47.14 22.9,47.14 v2(22.93,47.1) ; JSSD2.33 379.95,12.94 v2(380.06,13.05) ; PCG12.2 151.54,16.28 v2(152.07,16.81) ; v2(41.11,50.1) 41.11,50.02 41.17,49.86 UT4.L1 ; UT1.W6 v2(27.47,45.82) UT1.W5 ; v2(222.09,87.16) 222.09,86.95 220.42,85.27 JDIMM2.227 ; UT1.M1 24.55,48.12 v2(24.89,48.47) ; v2(24.23,39.31) 24.55,39.64 UT1.M19 ; v2(26.17,47.1) 26.39,47.32 UT1.T2 ; v2(32.64,13.74) 32.56,13.82 JAUDIO.21 ; v2(22.27,45.82) UT1.F5 ; UT1.H16 UT1.J18 ; UT1.H16 v2(22.27,41.27) 22.27,41.27 UT1.F16 ; UT1.H16 v2(22.27,40.62) ; UT1.T18 v2(26.82,39.97) ; UT1.V16 v2(26.82,41.27) UT1.T16 ; RT69.2 41.9,52.23 41.6,52.53 ; JSSD2.9 385.95,12.72 v2(386.1,12.88) ; UT1.M5 UT1.N5 v2(25.52,45.82) ; v2(139.09,77.62) 139.09,77.7 139.45,78.06 UC1.L6 ; JHDD.6 v2(259.55,4.56) ; UT1.N8 UT1.N9 v2(25.52,43.87) UT1.N11 ; US1.16 225.45,17.51 225.7,17.25 225.7,16.52 v2(225.77,16.46) 225.81,16.46 226.21,16.86 226.21,17.55 225.75,18.01 US1.15 ; UM8.25 v2(166.62,181.8) ; 41.6,52.53 41.32,52.24 RT71.2 ; 41.6,52.53 v2(41.6,52.54) ; v2(147.72,13.79) PUG02.4 ; UT1.V5 v2(26.82,45.82) UT1.V6 ; CT45.2 46.67,31.63 46.62,31.58 v2(46.62,31.35) ; 338.54,28.73 338.31,28.5 338.31,24.33 339.12,23.51 ; 338.54,28.73 339.88,27.39 339.88,24.27 339.12,23.51 ; 338.54,28.73 338.54,34.31 339.47,35.24 v2(339.47,35.71) ; UC1.M10 UC1.L9 ; v2(165.67,55.31) 165.23,55.74 UC1.AV28 ; v2(52.07,47.85) 51.29,47.85 50.68,47.24 50.18,47.24 50.06,47.37 RT131.1 ; v2(103.13,42.7) 103.21,42.7 103.31,42.79 PUI05.4 ; UC1.AV38 164.96,46.6 164.51,47.06 v2(163.84,47.06) ; v2(11.02,43.56) DT5.2 ; DT5.2 v2(11.56,43.02) ; DT5.2 v2(10.39,43.02) ; RT72.2 40.76,52.45 40.67,52.54 v2(40.67,52.54) ; v2(141.88,50.57) 142.35,51.03 UC1.N33 ; 25.85,38.99 UT1.R20 25.85,38.99 v2(26.16,38.67) 25.93,38.44 UT1.R22 ; v2(106.32,30.57) 106.12,30.77 PUI01.23 ; 301.27,49.43 v2(301.28,49.43) ; v2(106.26,39.77) 106.15,39.88 PUI05.23 ; v2(164.9,44.87) 164.4,44.87 UC1.AU40 ; PUI02.23 106.33,21.52 v2(106.3,21.49) ; v2(11.9,44.66) 11.7,44.66 DT14.2 ; JHDD.10 v2(257.55,4.56) ; UC1.E21 v2(133.66,63.89) ; JSSD2.15 384.45,12.76 v2(384.23,12.98) ; v2(27.46,39.95) UT1.W18 ; v2(130.01,80.6) 130.01,80.4 130.46,79.95 UC1.A4 ; v2(131.62,16.91) 131.24,16.52 PUG01.23 ; v2(139.92,62.06) 139.98,62.06 140.43,62.51 UC1.M23 ; UC1.AU39 UC1.AV39 165.26,45.68 165.43,45.51 v2(165.78,45.51) ; v2(155.09,75.54) 155.09,75.65 155.15,75.71 UC1.AH8 ; UC1.H9 136.41,75.77 136.41,76.59 136.39,76.61 v2(136.39,76.66) ; v2(103.09,33.44) 103.09,33.42 103.15,33.42 103.28,33.56 PUI01.4 ; PUG02.23 v2(150.87,16.82) ; CT49.2 v2(16.99,48.5) ; CE2.2 361.68,42.89 362.51,43.71 v2(362.51,44.35) 362.55,44.38 v2(362.55,45.92) 362.55,46.44 362.08,46.91 360.15,46.91 v2(360.11,46.95) 360.04,46.89 358.16,46.89 v2(357.81,46.53) 357.89,46.45 v2(357.89,43.53) 357.89,43.23 358.16,42.95 358.16,42.7 358.8,42.06 v2(358.8,40.16) ; UC1.AR14 UC1.AP14 ; UT1.J12 v2(22.92,43.22) UT1.H12 ; v2(183.01,161.38) 182.59,161.38 181.57,160.36 181.57,157.38 181.83,157.12 185.72,157.12 185.98,157.38 v2(185.98,159.69) 185.98,160.21 185.39,160.81 v2(185.2,160.81) 185.14,160.75 CL3.2 ; v2(364.73,9.71) 364.41,9.4 JSSD1.9 ; v2(23.57,41.92) UT1.L13 ; v2(23.57,41.92) UT1.L15 ; UC1.F1 135.03,83.58 v2(134.9,83.72) ; PUI06.23 107.6,48.41 v2(107.85,48.16) ; v2(106.02,59.59) 106.15,59.71 106.24,59.71 106.24,59.72 106.35,59.72 106.56,59.93 106.56,59.93 106.68,60.05 PUI03.4 ; UT1.N12 UT1.M12 v2(24.22,43.22) UT1.M11 ; v2(20.18,37.32) 20.03,37.32 19.51,36.8 19.51,36.4 19.71,36.2 20.9,36.2 21.13,36.43 21.13,36.51 21.15,36.53 21.15,36.81 21.28,36.93 v2(21.28,37.23) ; v2(341.67,45.35) 341.05,45.35 339.56,43.86 339.56,43.32 337.44,41.2 337.44,34.03 336.11,32.7 336.11,30.15 337.34,28.93 337.34,28.54 v2(337.34,28.53) 337.34,28.53 v2(337.34,25.84) 337.38,25.79 337.38,20.69 338.02,20.06 338.02,16.7 333.28,11.96 328.5,11.96 v2(327.96,12.5) 325.68,12.5 v2(325.68,12.49) 321.93,12.49 315.47,18.95 315.47,19.98 312.78,22.67 312.78,23.96 311.33,25.41 311.33,26.11 309.58,27.86 309.58,28.54 307.49,30.63 v2(305.21,30.63) 303.88,30.63 v2(303.37,31.14) 303.22,31.29 303.17,31.29 303.12,31.34 PR1805.2 ; JHDD.8 v2(258.55,4.56) ; UT1.T9 v2(26.82,44.52) 26.82,44.52 UT1.T8 ; UT1.E16 v2(21.62,41.27) ; v2(130.92,77.45) 130.92,77.6 UC1.B6 ; v2(38.4,50.21) RT73.2 ; v2(139.15,80.35) UC1.L3 ; v2(26.65,25.55) 26.47,25.37 26.47,24.39 26.22,24.14 v2(26,24.14) 25.19,24.14 v2(25.18,24.15) 24.75,23.73 24.39,23.73 23.27,24.85 v2(23.27,25.04) 23.27,28.28 v2(24.09,29.11) 24.6,29.61 25.62,29.61 26.06,29.17 v2(26.06,29.11) 26.65,28.52 v2(26.65,25.55)
  BOTTOM w0.279: UT1.K2 UT1.K1
  BOTTOM w0.305: v2(140.99,61.05) 140.88,61.05 UC1.M25 ; v2(141.89,47.97) UC1.M37 ; JSSD1.45 365.45,18.4 365.76,18.08 365.76,16.9 ; UC1.E37 134.97,47.45 134.18,47.45 UC1.D37 134.12,47.57 v2(134.55,48) ; v2(156.54,74.88) 156.98,74.44 UC1.AK10 v2(157.44,73.94) ; 231.6,74.78 JDIMM3.185 230.22,74.78 229.89,74.45 229.89,73.37 v2(230.02,73.24) 230.56,73.78 JDIMM3.181 231.6,73.78 ; 231.6,90.28 JDIMM3.247 230.27,90.28 v2(230.06,90.48) ; v2(228.68,34.19) 228.68,32.79 227.91,32.03 JDIMM2.22 ; JDIMM2.60 227.76,41.53 228.07,41.22 228.07,40.79 227.76,40.48 226.94,40.48 JDIMM2.56 224.06,40.53 223.61,40.98 v2(223.61,41.87) ; v2(131.4,63.53) 131.5,63.43 UC1.C22 ; JDIMM1.15 244.09,30.28 243.79,30.58 v2(242.57,30.58) 242.57,29.51 243.31,28.78 JDIMM1.9 ; v2(374.09,13.13) 373.95,12.99 JSSD2.57 ; JDIMM2.252 228.05,91.53 v2(228.14,91.44) 228.29,91.29 228.29,90.83 227.99,90.53 JDIMM2.248 ; UC1.M17 141.06,67.46 v2(141.06,67.33) ; JDIMM4.77 203.55,45.78 203.02,46.3 203.02,46.71 v2(202.97,46.76) 202.99,46.78 JDIMM4.81 ; UC1.G22 v2(136.41,63.89) ; v2(216.05,44.23) 216.05,43.87 216.18,43.75 216.18,42.44 216.84,41.78 JDIMM2.61 ; JDIMM4.231 203.16,86.28 v2(203.1,86.22) 203.02,86.29 203.02,87.12 203.18,87.28 JDIMM4.235 ; JDIMM2.14 228.16,30.03 228.27,29.91 v2(228.27,29.03) 226.9,29.03 JDIMM2.10 ; UC1.AM33 v2(160.21,51.63) 159.75,52.08 UC1.AM32 ; UC1.J12 v2(137.32,72.12) UC1.H12 ; v2(157.44,65.34) UC1.AK18 ; JDIMM1.167 248.74,70.28 249.07,70.61 v2(249.07,70.76) ; JDIMM1.214 253.8,82.03 v2(255.03,82.03) 255.12,82.11 255.12,82.72 254.81,83.03 JDIMM1.218 ; UC1.AC3 150.83,80.8 151.49,80.14 UC1.AD4 UC1.AE5 v2(152.86,79.43) UC1.AF5 ; v2(237.62,85.03) 237.62,85.03 JDIMM3.226 ; JDIMM4.247 203.99,90.28 203.54,90.28 ; v2(202.15,44.23) 202.15,43.62 202.99,42.78 JDIMM4.65 ; JDIMM1.99 244.56,51.28 v2(244.36,51.08) 244.3,51.02 244.3,50.06 244.58,49.78 JDIMM1.93 ; UC1.E17 134.46,67.66 v2(134.55,67.66) ; UC1.AP37 v2(162.01,47.06) ; UC1.AM24 v2(159.27,58.94) ; JDIMM3.244 238.97,89.53 238.53,89.96 238.53,90.35 v2(238.5,90.38) 238.64,90.53 JDIMM3.248 ; UC1.AW5 v2(164.75,79.43) UC1.AV5 ; JDIMM1.210 253.8,81.03 v2(255.03,81.03) 255.03,80.29 254.77,80.03 JDIMM1.206 ; UC1.H7 v2(137.27,77.56) UC1.J6 ; v2(140.77,83.38) 140.52,83.13 UC1.M1 ; JDIMM1.39 243.45,36.28 242.8,36.93 242.8,37.55 v2(242.86,37.62) 243.48,37.62 243.82,37.28 JDIMM1.43 ; JDIMM3.180 240.98,73.53 v2(241.07,73.61) 241.03,73.65 241.03,74.2 240.71,74.53 JDIMM3.184 ; UC1.AT34 UC1.AU34 164.32,50.26 v2(164.75,49.82) 165.18,50.26 UC1.AV34 UC1.AW34 v2(166.79,50.26) ; UC1.AM38 v2(160.21,46.13) UC1.AM39 ; v2(241.78,76.56) 241.78,76.55 241.78,75.74 241.57,75.53 JDIMM3.188 ; JDIMM3.18 240.63,31.03 v2(241.08,30.58) 241.08,30.25 240.85,30.03 JDIMM3.14 ; JDIMM3.189 229.29,75.78 228.98,76.08 v2(228.98,76.17) 229.58,76.78 JDIMM3.193 ; UC1.AT5 v2(162.01,79.43) UC1.AR5 ; JDIMM2.78 224.89,46.03 224.5,46.42 v2(224.5,46.76) ; v2(208.99,80.95) 208.95,80.85 209.78,80.03 JDIMM4.206 ; v2(229.3,34.2) 229.51,34.41 230.2,34.41 230.34,34.28 JDIMM3.31 ; JDIMM1.261 259.59,26.35 v2(258.91,25.68) ; JDIMM4.52 214.01,39.53 214.3,39.24 214.3,39.02 v2(214.3,39.02) 214.3,38.73 214.09,38.53 JDIMM4.48 ; UC1.AL24 v2(158.35,58.94) ; v2(156.52,76.69) UC1.AK8 ; v2(220.7,46.76) 220.7,46.23 220.25,45.78 JDIMM2.77 ; JDIMM2.167 217.7,70.27 217.5,70.08 v2(217.19,70.08) 217.19,70.91 217.56,71.27 JDIMM2.171 ; v2(214.86,70.08) 214.9,70.12 214.9,70.57 214.68,70.79 214.02,70.79 213.76,70.53 JDIMM4.168 ; JDIMM1.56 253.8,40.53 v2(255.01,40.53) ; JDIMM2.205 217.02,79.78 216.57,79.32 v2(216.57,78.51) 216.83,78.78 218.7,78.78 JDIMM2.201 ; v2(251.41,47.5) 251.41,47.32 251.82,46.91 252.45,46.91 252.56,47.03 253.8,47.03 JDIMM1.82 ; v2(217.47,50.05) 217.47,49.05 217.74,48.78 JDIMM2.89 ; JDIMM2.226 228.37,85.02 228.68,85.33 v2(228.68,85.7) 228.68,86.69 228.35,87.03 226.9,87.03 JDIMM2.234 ; 149.96,78.56 150.46,78.06 UC1.AC6 150.58,77.94 v2(150.92,77.6) ; v2(147.38,49.8) UC1.V35 ; UC1.AR33 162.49,51.17 v2(162.95,51.63) 163.38,52.06 UC1.AT32 v2(163.85,51.6) ; UC1.AH39 UC1.AH40 156.06,44.14 v2(156.1,44.1) ; v2(159.16,71.7) 159.16,71.64 UC1.AL11 ; JDIMM2.39 217.4,36.28 217.33,36.2 v2(217.33,35.39) 217.44,35.28 JDIMM2.35 ; UC1.AM40 159.72,44.07 v2(159.75,44.04) ; JDIMM2.217 217.55,82.78 217.44,82.67 v2(217.44,82.07) 217.74,81.78 JDIMM2.213 ; v2(153.69,75.72) 153.32,76.09 UC1.AF8 ; UC1.C12 132.61,72.25 v2(132.73,72.25) ; JDIMM2.247 217.16,90.28 216.61,90.83 ; JDIMM1.188 254.73,75.53 255.03,75.83 v2(255.03,76.53) 253.8,76.53 JDIMM1.192 ; v2(153.21,83.18) 153.21,83.06 153.32,82.95 UC1.AF1 ; v2(141.89,46.14) UC1.M39 ; JDIMM3.223 230.2,84.28 229.92,84.55 ; UC1.K4 v2(139.15,80.35) ; UC1.V1 145.96,82.79 145.96,83.29 v2(146.46,83.79) ; v2(243.56,25.5) 243.56,26.62 244.72,27.78 JDIMM1.5 ; JDIMM3.60 240.76,41.53 v2(241.29,41) 240.81,40.53 JDIMM3.56 ; JDIMM3.230 237.92,86.03 v2(237.2,86.75) ; JDIMM2.214 228.1,82.02 v2(228.12,82.04) 228.19,81.97 228.19,81.25 227.97,81.03 226.9,81.03 JDIMM2.210 ; JDIMM1.18 253.8,31.03 254.64,31.03 254.94,31.33 254.94,31.35 254.98,31.35 254.98,31.35 v2(254.97,31.35) ; v2(132.7,70.34) UC1.C14 ; v2(224.18,39.96) 224.73,39.41 225.16,39.41 225.28,39.53 JDIMM2.52 226.93,39.49 228.04,39.49 228.3,39.23 228.3,38.74 228.09,38.53 JDIMM2.48 ; JDIMM2.73 217.5,44.78 217.37,44.65 217.37,44.25 v2(217.35,44.23) 217.81,43.78 JDIMM2.69 ; v2(243.86,41.55) 243.86,42.47 244.17,42.78 JDIMM1.65 ; v2(243.86,41.55) 244.37,41.55 244.6,41.78 JDIMM1.61 ; v2(243.86,41.55) 243.86,41.04 244.13,40.78 JDIMM1.57 ; UC1.AT26 163.38,57.6 v2(163.84,58.07) 163.35,58.49 UC1.AT25 163.48,58.59 163.48,59.3 UC1.AT24 ; UC1.AA3 148.75,81.39 v2(148.69,81.45) ; JDIMM2.26 227.92,33.03 228.19,33.3 228.19,34.11 v2(228.12,34.19) 227.96,34.03 JDIMM2.30 ; v2(162.92,52.53) UC1.AR31 ; v2(162.92,52.53) 163.38,52.99 UC1.AT31 ; v2(162.92,52.53) UC1.AR32 ; UC1.AF37 v2(154.69,47.97) ; v2(154.69,47.97) UC1.AG36 ; v2(154.69,47.97) 154.64,48.03 UC1.AF36 ; RT42.2 17.03,46.46 v2(16.31,46.46) ; v2(234.85,46.24) 234.85,46.18 234.42,45.74 233.83,45.74 232.86,44.78 JDIMM3.73 ; JDIMM1.243 244.58,89.28 244.27,89.58 v2(244.27,89.92) 244.63,90.28 JDIMM1.247 ; UC1.AT37 v2(163.84,47.06) UC1.AT38 163.35,46.6 v2(163.81,46.14) 163.38,45.71 UC1.AT39 ; JSSD2.1 387.95,12.51 388.28,12.84 v2(388.28,12.99) 388.14,13.13 387.65,13.13 387.45,12.93 JSSD2.3 ; JDIMM4.56 213.96,40.53 214.12,40.68 v2(214.12,41.82) ; UC1.AV26 164.75,58.03 v2(164.75,58.07) 164.32,58.49 UC1.AU25 ; v2(144.73,80.39) 144.68,80.39 UC1.T4 ; v2(216.03,91.53) 216.03,90.24 213.81,88.03 JDIMM4.238 ; JDIMM2.102 228.12,52.03 228.53,52.43 v2(228.53,52.81) 228.32,53.03 JDIMM2.106 ; v2(163.84,55.29) 163.39,54.83 UC1.AT29 UC1.AT30 ; v2(139.15,66.63) UC1.K19 ; UC1.AD40 152.41,44.21 v2(152.44,44.18) ; v2(128.88,150.34) 128.54,149.99 PRS53.2 ; CT156.2 48.17,35.23 v2(48.79,35.85) ; UC1.AK13 157.89,69.53 v2(157.51,69.92) ; v2(156.52,80.35) UC1.AJ4 ; UC1.AN11 v2(160.18,71.74) UC1.AM11 ; UC1.AN4 159.72,79.91 v2(160.21,80.35) ; v2(215.44,91.53) 215.44,90.55 214.42,89.53 JDIMM4.244 ; JDIMM2.168 225.88,70.53 225.62,70.79 224.84,70.79 224.71,70.66 v2(224.71,70.11) ; v2(255,43.57) 254.96,43.53 JDIMM1.68 ; QE4.1 349.11,34.97 348.45,34.32 348.45,34.26 v2(348.42,34.26) ; v2(131.6,65.25) 131.6,65.26 UC1.C20 ; JDIMM4.36 214.05,35.53 v2(214.18,35.39) 214.3,35.51 214.3,36.37 214.14,36.53 JDIMM4.40 ; UC1.AD6 v2(151.95,77.6) UC1.AD7 ; JDIMM3.72 240.95,44.53 v2(241.07,44.4) ; v2(144.63,81.26) UC1.U3 ; JDIMM3.202 238.61,79.03 v2(238.3,79.34) 238.38,79.42 238.38,79.8 238.6,80.03 JDIMM3.206 ; JDIMM1.230 254.84,86.03 255.14,86.33 255.14,86.92 v2(255.03,87.03) 253.8,87.03 JDIMM1.234 ; JDIMM3.102 240.88,52.03 241.19,51.72 241.19,51.45 v2(241.03,51.29) 240.77,51.03 JDIMM3.98 ; UC1.AP5 v2(160.21,79.43) UC1.AN5 ; JDIMM4.69 203.24,43.78 v2(202.78,44.23) ; v2(131.83,59.31) UC1.B26 ; v2(135.95,44.13) UC1.F40 ; v2(139.15,60.23) UC1.K26 ; JDIMM3.27 230.67,33.28 v2(230.15,33.79) ; JDIMM1.252 253.8,91.53 254.8,91.53 v2(254.99,91.34) 255.03,91.3 255.03,90.87 254.68,90.53 JDIMM1.248 ; v2(140.98,66.63) UC1.M19 ; v2(163.84,77.6) UC1.AU7 ; UC1.AU7 UC1.AT6 ; UC1.AU7 163.1,76.87 162.74,76.87 UC1.AT7 UC1.AT8 v2(162.92,75.77) UC1.AT9 ; UC1.AR35 162.35,49.34 v2(161.92,49.77) 162.4,50.26 UC1.AR34 ; JDIMM3.209 229.79,80.78 228.7,81.86 v2(228.7,82.04) ; v2(365.11,10.71) 364.98,10.83 ; 364.98,10.83 364.98,12.18 364.77,12.4 ; 364.98,10.83 364.92,10.9 JSSD1.15 ; v2(229.26,44.73) 229.26,42.97 228.81,42.53 JDIMM2.64 ; v2(131.83,61.14) UC1.C24 ; v2(145.55,46.14) UC1.T39 ; JDIMM2.172 228.1,71.53 228.32,71.74 228.32,72.34 v2(228.24,72.41) 228.13,72.53 JDIMM2.176 ; v2(141.03,77.67) 141.43,78.06 UC1.N6 ; UC1.T1 144.18,83.08 v2(144.36,83.27) ; v2(133.66,47.97) UC1.C37 ; UC1.E6 134.51,77.67 v2(134.51,77.63) ; JDIMM2.19 217.75,31.28 v2(217.35,30.88) 217.27,30.96 217.27,32.03 217.52,32.28 JDIMM2.23 ; v2(139.93,59.33) 140.04,59.33 UC1.M27 ; RT68.2 v2(42.49,52.51) ; JDIMM4.188 211.21,75.53 210.98,75.29 v2(210.98,74.31) ; v2(203.3,27.53) 203.55,27.78 JDIMM4.5 ; JDIMM2.93 219.85,49.78 v2(220.12,50.05) ; JDIMM1.102 253.8,52.03 254.77,52.03 v2(254.96,51.84) ; JDIMM3.176 240.7,72.53 241.03,72.19 v2(241.03,71.65) 240.91,71.53 JDIMM3.172 ; v2(249.31,86.51) 249.31,86.65 248.92,87.04 247.8,87.04 247.04,86.28 JDIMM1.231 ; v2(140.06,47.97) UC1.K37 ; 231.6,72.28 JDIMM3.175 230.13,72.28 229.58,71.72 229.58,70.67 229.72,70.53 v2(229.72,70.1) ; JDIMM4.15 203.33,30.28 203.02,29.97 203.02,29.48 v2(202.94,29.4) ; v2(158.33,79.43) UC1.AM5 ; v2(158.33,79.43) 157.89,79.86 UC1.AL4 ; v2(158.33,79.43) UC1.AL5 ; 364.77,12.4 JSSD1.21 ; 364.77,12.4 364.9,12.52 364.9,13.46 364.46,13.9 JSSD1.27 ; JDIMM1.227 242.68,85.28 242.24,84.83 v2(242.24,84.2) ; CH233.2 285.76,62.68 v2(286.06,62.39) ; v2(200.76,27.53) 199.59,26.35 JDIMM4.262 ; v2(211.1,34.31) 211.39,34.03 JDIMM4.30 213.87,34.03 214.09,33.81 214.09,33.24 213.87,33.03 JDIMM4.26 ; v2(128.06,13.55) 128.09,13.58 128.09,13.7 128.27,13.87 PUG01.4 ; v2(377.16,13.1) 376.95,12.89 JSSD2.45 ; JDIMM4.60 213.83,41.53 v2(214.12,41.82) ; v2(350.59,33.99) 350.59,33.98 350.41,33.79 QE4.4 ; UC1.AN9 159.75,75.32 v2(160.21,75.77) UC1.AN8 ; v2(210.38,76.77) 210.38,76.55 210.68,76.24 211.45,76.24 211.74,76.53 JDIMM4.192 ; JDIMM4.181 203.77,73.78 203.47,74.08 v2(203.47,74.31) 203.5,74.35 203.5,74.47 203.81,74.78 JDIMM4.185 ; v2(199.77,95.13) 199.77,94.8 198.92,93.95 JDIMM4.261 ; JDIMM1.85 243.65,47.78 243.35,47.47 v2(243.35,46.89) 243.35,46.08 243.65,45.78 JDIMM1.77 ; UC1.AR3 v2(162.01,81.26) UC1.AR2 ; v2(255.04,36.47) 254.99,36.53 JDIMM1.40 ; JDIMM4.252 214.27,91.53 v2(214.27,91.53) ; PCF14.2 v2(152.35,104.75) ; v2(200.88,44.23) 200.88,44.61 201.04,44.78 JDIMM4.73 ; v2(203.49,91.07) 203.54,91.07 203.75,91.28 JDIMM4.251 ; v2(163.86,47.97) 163.41,48.43 UC1.AT36 ; UC1.L32 UC1.K33 UC1.J34 v2(138.23,49.8) UC1.H35 ; UC1.N8 v2(141.89,76.69) ; UC1.AK5 v2(156.52,79.43) UC1.AJ5 ; v2(362.08,15.19) 362.28,15.4 JSSD1.33 ; JDIMM2.231 217.56,86.27 v2(217.07,86.76) 217.07,86.97 217.38,87.28 218.7,87.28 JDIMM2.235 ; US1.13 224.42,19.84 224.65,20.08 v2(224.65,20.59) ; v2(216.69,30.88) 216.69,30.33 216.74,30.28 JDIMM2.15 ; JDIMM3.1 230.09,26.78 229.67,27.2 v2(229.67,28.52) 229.67,29.84 230.1,30.28 JDIMM3.15 ; 244.24,79.78 JDIMM1.205 ; JDIMM4.10 214.63,29.03 214.91,28.75 v2(214.91,26.58) ; JDIMM3.238 241.69,88.03 v2(241.83,87.88) 241.83,87.6 241.26,87.03 JDIMM3.234 ; UC1.J18 137.78,67.08 v2(138.22,66.64) ; JDIMM3.218 238.48,83.03 v2(237.71,82.26) 237.94,82.03 JDIMM3.214 ; JDIMM1.223 245.6,84.28 248.67,84.28 v2(249.38,83.56) ; JDIMM2.43 216.9,37.28 216.15,38.02 v2(216.15,39.04) 216.64,39.04 217.4,38.28 JDIMM2.47 ; JDIMM1.202 253.8,79.03 v2(255.03,79.03) 255.07,78.99 255.07,77.83 254.76,77.53 JDIMM1.196 ; 214.35,90.96 213.92,90.53 JDIMM4.248 ; UC1.F10 UC1.G11 135.95,73.53 v2(136.37,73.94) 136.82,73.49 UC1.H11 ; v2(152.81,75.72) 152.41,76.11 UC1.AE8 152.17,75.99 151.73,75.99 UC1.AD8 ; JDIMM3.103 230.45,52.28 v2(229.91,52.81) 230.38,53.28 JDIMM3.107 ; US1.12 223.92,20.08 224.09,20.26 v2(224.09,20.54) ; v2(142.77,77.56) 142.77,77.62 143.21,78.06 UC1.R6 ; v2(133.66,60.23) UC1.D26 ; JDIMM1.185 243.84,74.78 243.41,74.34 243.41,73.05 243.37,73.01 243.37,72.5 v2(243.45,72.41) ; JTP.3 99.95,14.57 101.43,13.08 v2(101.43,11.19) ; 203.34,89.4 203.46,89.28 JDIMM4.243 ; UC1.J20 v2(137.32,64.8) ; JWLAN.75 v2(343.88,51.35) ; JDIMM3.40 241.3,36.53 v2(242.31,37.53) ; v2(138.69,83.27) UC1.K1 ; v2(158.35,61.69) UC1.AL21 158.81,62.15 158.36,62.6 v2(158.35,62.6) ; 216.69,29.49 217.4,28.78 JDIMM2.9 ; UC1.Y37 149.09,47.85 v2(149.23,47.85) ; JDIMM2.180 225.97,73.53 225.83,73.67 224.75,73.67 v2(223.34,75.08) ; v2(202,39.02) 202,36.58 202.3,36.28 JDIMM4.39 ; v2(201.51,44.23) 201.51,43.17 202.9,41.78 JDIMM4.61 ; JDIMM1.78 254.98,46.03 v2(255,46.05) ; v2(137.32,58.4) UC1.H28 ; UC1.AP40 v2(161.55,44.11) ; v2(248.54,35.58) 248.56,35.56 248.56,35.08 247.76,34.28 JDIMM1.31 ; v2(139.15,58.4) UC1.K28 ; JDIMM2.218 226.01,83.02 225.52,83.52 v2(225.52,84.12) 225.61,84.02 JDIMM2.222 ; JDIMM1.235 243.81,87.28 v2(243.2,87.88) ; v2(139.92,70.28) 140.07,70.28 UC1.M15 ; UC1.AM36 159.75,48.43 v2(160.21,47.97) UC1.AN36 ; v2(159.27,53.46) 159.66,53.06 UC1.AM31 ; JDIMM1.26 254.57,33.03 v2(255.06,33.51) 255.07,33.51 255.23,33.36 255.23,32.47 254.78,32.03 JDIMM1.22 ; JWLAN.57 v2(343.97,46.85) ; v2(242.95,79.06) 242.95,78.15 242.32,77.53 JDIMM3.196 ; JDIMM4.184 214.55,74.53 214.86,74.22 v2(214.86,73.87) 214.86,72.83 214.55,72.53 JDIMM4.176 ; UC1.AW36 166.71,48.43 v2(166.75,48.39) ; UC1.C18 131.85,67.52 v2(131.85,67.52) ; US1.5 222.35,16.46 v2(221.89,16.46) ; UC1.AR23 UC1.AR22 162.47,61.25 v2(162.92,61.71) UC1.AR21 ; JDIMM4.2 213.64,27.03 v2(214.08,26.58) 214.17,26.67 214.17,27.72 213.87,28.03 JDIMM4.6 ; JDIMM3.6 241.41,28.03 v2(241.45,27.98) 241.53,28.06 241.53,28.75 241.25,29.03 JDIMM3.10 ; JDIMM4.14 215.2,30.03 215.42,30.24 v2(215.42,30.88) ; v2(207.11,79.02) 207.11,77.52 206.37,76.78 JDIMM4.193 ; JDIMM4.180 211.93,73.53 211.81,73.4 211.12,73.4 210.93,73.2 v2(210.93,72.83) 210.93,72.13 211.53,71.53 JDIMM4.172 ; JDIMM4.230 214,86.03 215.87,84.15 v2(215.87,82.07) ; UC1.A11 130.41,73.49 129.82,74.08 v2(129.71,74.08) ; v2(225.45,89.55) 225.48,89.53 JDIMM2.244 ; v2(216.18,73.87) 216.18,75.91 217.05,76.78 JDIMM2.193 ; v2(153.76,50.76) 153.83,50.76 UC1.AF33 ; v2(131.83,55.66) UC1.B30 ; UC1.R8 142.75,75.72 v2(142.71,75.72) ; v2(230.06,90.48) 230.06,90.57 230.76,91.28 JDIMM3.251 ; v2(230.06,90.48) 230.06,89.9 230.69,89.28 JDIMM3.243 231.6,89.28 ; v2(229.26,85.7) 229.26,86.13 229.41,86.28 JDIMM3.231 ; v2(133.66,44.23) 134.12,44.68 UC1.D40 ; v2(242.07,27.98) 242.07,27.33 241.77,27.03 JDIMM3.2 ; JDIMM3.64 241.87,42.53 242.09,42.75 ; v2(210.59,86.15) 210.59,85.34 210.97,84.96 211.78,84.96 211.85,85.03 JDIMM4.226 ; JDIMM4.202 213.77,79.03 214.13,78.66 v2(214.13,78.54) ; v2(228.42,31.35) 228.09,31.03 JDIMM2.18 ; JDIMM2.251 217.54,91.28 217.3,91.51 216.7,91.51 v2(216.69,91.53) ; v2(202.84,74.31) 202.84,75.47 203.15,75.78 JDIMM4.189 ; UC1.D7 133.2,77.17 132.74,77.64 v2(132.74,77.72) ; UC1.AC34 v2(151.02,49.79) 151.47,49.34 UC1.AC35 ; JDIMM2.86 227.83,48.03 228.24,48.44 228.24,48.68 v2(228.82,49.25) 228.93,49.14 228.93,47.24 228.71,47.03 JDIMM2.82 ; JDIMM3.192 238.28,76.53 237.97,76.83 v2(237.97,77.15) ; JDIMM2.184 225.04,74.53 224.65,74.91 v2(224.65,75.08) ; UC1.J3 v2(137.36,80.39) UC1.H4 ; v2(255,44.57) 254.96,44.53 JDIMM1.72 ; JDIMM1.244 254.95,89.53 v2(255.29,89.18) ; JDIMM2.197 217.63,77.78 217.3,77.44 215.65,77.44 215.39,77.7 215.39,78.5 v2(215.4,78.51) ; v2(135.49,60.23) UC1.F26 ; UC1.AP36 v2(162.01,47.97) UC1.AR36 ; JSSD1.51 365.01,19.9 365.68,20.57 v2(365.68,21.33) ; JDIMM2.239 217.18,88.27 216.43,87.53 v2(216.43,86.76) ; JDIMM3.19 230.71,31.28 v2(230.36,31.28) 230.14,31.49 230.14,31.97 230.45,32.28 JDIMM3.23 ; v2(136.41,66.63) UC1.G19 ; JDIMM1.226 v2(255.03,85.03) 255.07,84.99 255.07,84.28 254.82,84.03 JDIMM1.222 ; JDIMM1.238 254.05,88.03 v2(255.29,88.03) ; v2(156.52,52.54) UC1.AJ31 ; v2(134.56,62.95) UC1.E23 ; UC1.AR20 v2(162.92,63.49) UC1.AR19 ; v2(156.52,49.8) UC1.AJ34 v2(157.44,49.8) ; JDIMM1.209 244.05,80.78 243.53,80.26 ; JDIMM4.89 203.15,48.78 202.84,49.08 v2(202.84,50.05) 203.49,50.05 203.77,49.78 JDIMM4.93 ; JDIMM4.197 202.28,77.78 201.92,78.14 v2(201.92,79.02) ; JDIMM2.243 215.77,89.27 215.77,89.28 215.14,88.64 215.14,86.79 v2(215.16,86.76) ; JDIMM4.210 214.94,81.03 215.29,81.38 v2(215.29,82.07) 215.26,82.1 215.26,83.67 214.9,84.03 JDIMM4.222 ; 217.09,42.78 JDIMM2.65 ; v2(242.83,81.52) 242.83,81.66 243.2,82.03 244.28,82.03 244.54,81.78 245.6,81.78 JDIMM1.213 ; JDIMM3.93 230.57,49.78 v2(230.05,49.25) 229.87,49.43 229.87,51.03 230.12,51.28 JDIMM3.99 ; v2(220.73,32.54) 220.75,32.56 220.75,32.97 220.44,33.28 JDIMM2.27 ; UC1.AL30 158.73,53.91 v2(158.35,53.53) 157.97,53.91 UC1.AK30 ; v2(132.75,61.14) UC1.D24 ; JDIMM3.51 230.62,39.28 230.25,39.65 230.25,40.66 v2(230.15,40.76) 230.17,40.78 JDIMM3.57 ; v2(130.89,72.13) 130.46,71.71 UC1.A13 ; UC1.AH8 UC1.AG8 ; UC1.AT11 v2(162.92,70.83) 163.35,70.37 UC1.AT12 163.47,70.29 163.47,69.54 UC1.AT13 UC1.AT14 ; v2(147.38,78.52) UC1.Y5 ; UC1.AL36 158.78,48.43 v2(158.33,47.97) UC1.AK36 ; UC1.K15 v2(138.23,70.29) UC1.K14 ; JDIMM4.103 201.45,52.28 200.91,51.74 200.91,50.06 v2(200.93,50.05) ; JDIMM4.99 202.51,51.28 202.22,50.99 v2(202.22,50.05) ; JDIMM3.86 240.74,48.03 241.03,47.73 v2(241.03,46.89) 240.9,47.03 JDIMM3.82 ; v2(341.67,45.35) JWLAN.51 ; v2(216.16,35.39) 216.16,34.72 216.6,34.28 JDIMM2.31 221.5,34.28 222.17,34.95 v2(222.17,35.76) ; UC1.AN14 v2(161.09,69) UC1.AP14 ; UC1.AP30 161.55,53.89 v2(161.98,54.37) UC1.AR30 UC1.AT30 ; JDIMM4.23 202.34,32.28 200.94,33.68 v2(200.94,34.31) ; v2(162.01,80.35) UC1.AR4 ; UC1.AJ33 v2(156.52,51.63) UC1.AJ32 ; 230.32,36.28 JDIMM3.39 ; v2(229.77,39.27) 229.77,38.71 229.79,38.68 229.79,38.22 230.17,37.84 230.17,37.74 230.64,37.28 JDIMM3.43 ; UC1.G3 135.95,80.7 135.58,80.33 v2(135.58,80.33) 135.58,80.33 135.14,79.89 UC1.F4 ; UC1.AW9 v2(164.75,75.77) UC1.AV9 v2(163.84,75.77) ; JDIMM3.90 240.7,49.03 v2(241.03,49.36) 241.03,49.69 240.7,50.03 JDIMM3.94 ; v2(154.18,83.55) 154.22,83.51 154.22,82.65 UC1.AG1 ; UC1.E15 v2(133.69,70.26) ; JDIMM1.217 247.35,82.78 247.78,82.34 v2(247.78,82.12) ; JDIMM3.168 240.78,70.53 241.62,71.36 v2(241.62,71.58) ; v2(216.91,50.05) 216.91,48.21 217.35,47.78 JDIMM2.85 ; UC1.AU4 v2(163.84,79.43) UC1.AU5 ; UC1.AH33 v2(155.61,50.71) ; v2(375.26,13.28) 375.26,13.05 375.45,12.86 JSSD2.51 ; v2(157.44,66.26) UC1.AK17 ; v2(152.74,51.66) 152.72,51.64 151.96,51.64 UC1.AC33 ; v2(214.12,41.82) 214.15,41.85 214.15,42.31 213.93,42.53 JDIMM4.64 ; v2(140.03,72.17) 140.09,72.17 140.49,72.57 UC1.M12 ; UC1.AD33 v2(152.86,50.71) UC1.AE33 ; JDIMM4.18 214.67,31.03 v2(214.81,30.88) 214.95,31.02 214.95,31.68 214.61,32.03 JDIMM4.22 ; JDIMM1.47 244.45,38.28 244.12,38.61 v2(244.12,38.89) 244.51,39.28 JDIMM1.51 ; UC1.P39 v2(143.72,46.14) ; JDIMM2.230 226.9,86.03 227.8,86.03 v2(228.12,85.7) ; UC1.G15 135.61,69.49 v2(135.48,69.49) ; UC1.AN24 v2(161.09,58.94) UC1.AP24 v2(162.01,58.94) UC1.AR24 ; v2(133.62,73.07) 133.7,73.07 UC1.E11 ; v2(138.23,47.97) UC1.H37 ; v2(255.01,51.03) 255.01,51.03 JDIMM1.98 ; UC1.AN6 v2(160.21,77.6) ; UC1.AT30 UC1.AU30 164.32,53.91 v2(164.75,53.48) 165.18,53.91 UC1.AV30 UC1.AW30 UC1.AY30 v2(167.5,53.45) ; v2(202.34,86.22) 202.34,85.98 203.04,85.28 JDIMM4.227 ; v2(255.55,31.35) 255.55,31.25 254.91,30.6 254.91,30.36 254.57,30.03 JDIMM1.14 ; v2(378.4,13.7) 378.23,13.53 378.23,13.1 378.45,12.89 JSSD2.39 ; v2(142.8,80.51) 142.8,80.44 142.35,79.99 UC1.P4 ; UC1.AN7 v2(160.21,76.69) ; JDIMM2.98 228.9,51.03 229.12,51.24 v2(229.12,52.81) ; JDIMM2.44 227.9,37.53 228.2,37.22 228.2,36.81 v2(228.15,36.75) ; JDIMM1.30 254.57,34.03 255.04,34.49 v2(255.04,34.95) 255.04,35.08 254.59,35.53 JDIMM1.36 ; UC1.P37 v2(143.72,47.97) ; JDIMM1.172 254.74,71.53 255.04,71.83 v2(255.04,72.16) 254.68,72.53 JDIMM1.176 ; UC1.AK37 v2(158.33,47.06) ; v2(215.24,52.37) 215.24,52.73 214.94,53.03 JDIMM4.106 ; JDIMM1.193 243.93,76.78 v2(243.68,76.53) 244.44,75.78 JDIMM1.189 ; v2(140.98,64.8) UC1.M21 ; v2(139.15,63.89) UC1.K22 ; v2(143.71,51.64) UC1.R33 ; v2(364.9,21.31) 364.82,21.4 JSSD1.57 ; JDIMM4.9 202.77,28.78 202.49,28.5 202.49,27.71 v2(202.67,27.53) 202.67,26.92 202.81,26.78 JDIMM4.1 ; JDIMM4.213 201.94,81.78 201.93,81.77 v2(201.45,81.28) 201.96,80.78 JDIMM4.209 ; JDIMM2.238 226.9,88.03 227.95,88.03 228.25,88.33 v2(228.25,89.47) ; v2(139.1,52.53) 138.69,52.13 UC1.J32 ; v2(130.92,61.14) UC1.B24 ; JDIMM3.205 230.38,79.78 230.07,80.08 228.25,80.08 v2(228.19,80.03) 228.19,80.02 JDIMM2.206 ; v2(237.19,37.98) 237.19,37.56 237.39,37.36 238.05,37.36 238.21,37.53 JDIMM3.44 ; UC1.AH5 155.5,79.32 v2(155.5,79.4) ; v2(157.44,64.43) UC1.AK19 ; JDIMM2.57 215.97,40.78 215.37,41.37 215.37,44.18 v2(215.42,44.23) ; v2(130,61.14) UC1.A24 ; v2(211.43,50.05) 211.45,50.03 JDIMM4.94 ; UC1.AJ36 v2(156.5,47.97) UC1.AH36 ; JDIMM1.239 243.95,88.28 243.64,88.59 243.64,89.87 v2(243.69,89.92) ; v2(140.97,56.58) UC1.M29 ; v2(152.86,47.06) UC1.AD37 ; v2(135.49,62.97) UC1.F22 ; PCF13.2 159.53,109.51 v2(159.59,109.57) ; JDIMM4.201 203.33,78.78 v2(203.09,79.02) 203.85,79.78 JDIMM4.205 ; JDIMM3.48 240.86,38.53 241.07,38.74 v2(241.07,39.39) 240.94,39.53 JDIMM3.52 ; JDIMM2.36 228.24,35.53 228.54,35.83 228.54,36.36 v2(228.15,36.75) ; JDIMM3.78 241.1,46.03 v2(241.96,46.89) ; v2(142.42,83.29) 142.42,83.26 142.35,83.19 UC1.P1 ; UC1.AR11 v2(162.01,71.74) UC1.AP11 ; JDIMM1.197 246.61,77.78 246.81,77.98 246.81,78.38 v2(246.92,78.49) 246.64,78.78 JDIMM1.201 ; v2(131.84,76.54) 131.96,76.54 132.27,76.23 UC1.C8 ; JDIMM2.223 218.7,84.28 217.04,84.28 216.69,83.92 v2(216.69,82.07) 216.69,81.1 217.01,80.78 JDIMM2.209 ; v2(241.66,81.52) 241.17,81.03 JDIMM3.210 ; UC1.AM14 v2(159.27,69) UC1.AL14 v2(158.35,69) ; UC1.P35 v2(143.72,49.8) ; UC1.AJ8 v2(156.52,75.77) ; JDIMM3.213 230.34,81.78 229.01,83.11 v2(229.01,83.94) ; v2(216.51,52.37) 216.51,52.73 216.91,53.13 217.77,53.13 217.92,53.28 JDIMM2.107 ; v2(139.09,77.62) 138.99,77.52 138.99,77.45 UC1.K7 ; v2(225.39,27.56) 225.65,27.82 225.65,27.89 225.79,28.03 JDIMM2.6 ; v2(133.66,71.2) UC1.E13 ; PCS58.2 v2(153.47,145.33) ; v2(200.93,89.82) 202.48,88.28 JDIMM4.239 ; v2(135.49,56.57) UC1.F30 ; JDIMM4.234 211.65,87.03 209.48,89.2 v2(209.48,89.49) ; JDIMM1.35 242.08,35.28 v2(241.63,34.82) ; v2(145.55,49.8) UC1.T35 ; UC1.AN1 v2(159.72,83.29) ; JDIMM1.73 244.29,44.78 v2(243.86,44.35) 244.44,43.78 JDIMM1.69 ; v2(137.32,53.46) UC1.G31 ; JDIMM1.1 246.97,26.78 247.12,26.92 v2(247.12,27.92) ; JDIMM3.235 230.58,87.28 230.28,87.58 v2(230.28,88.09) 230.46,88.28 JDIMM3.239 ; JDIMM4.175 203.24,72.28 v2(202.84,71.88) 203.45,71.28 JDIMM4.171 ; JDIMM2.188 227.8,75.53 228.11,75.83 228.11,76.06 v2(228.22,76.17) 227.87,76.53 JDIMM2.192 ; JDIMM1.81 246.89,46.78 v2(247.63,47.52) ; UC1.AK20 157.5,63.45 157.5,63.52 v2(157.51,63.52) ; JDIMM3.26 242.61,33.03 v2(242.63,33.01) 242.63,32.57 242.08,32.03 JDIMM3.22 ; JDIMM4.72 213.96,44.53 v2(214.25,44.23) 214.3,44.19 214.3,43.66 214.16,43.53 JDIMM4.68 ; v2(236.36,90.43) 236.36,90.89 237.26,91.79 238.43,91.79 238.7,91.53 JDIMM3.252 ; v2(216.81,73.87) 216.81,75.16 217.43,75.78 JDIMM2.189 ; JDIMM4.82 215.79,47.03 v2(216.05,46.76) 215.52,46.23 215.52,46.2 215.34,46.03 JDIMM4.78 ; v2(254.99,70.74) 254.79,70.74 254.57,70.53 JDIMM1.168 ; v2(159.27,56.2) UC1.AM27 159.82,56.76 160.54,56.76 UC1.AN27 160.64,56.63 v2(161.09,56.16) 161.55,56.63 UC1.AP27 161.65,56.76 162.37,56.76 162.46,56.66 UC1.AR27 162.55,56.75 163.29,56.75 163.32,56.71 UC1.AT27 163.41,56.66 v2(163.84,56.16) 163.62,55.95 163.41,55.74 UC1.AT28 ; v2(145.57,78.51) 145.54,78.51 UC1.U6 ; UC1.AY5 v2(166.78,78.97) ; v2(243.8,49.36) 244.39,48.78 JDIMM1.89 ; v2(146.46,78.52) UC1.W6 ; v2(255,42.49) 254.97,42.53 JDIMM1.64 ; v2(133.66,49.8) UC1.C35 ; UC1.AH37 v2(156.5,47.06) ; JDIMM1.6 254.66,28.03 v2(254.97,28.33) 254.93,28.37 254.93,28.38 254.91,28.4 254.91,28.72 254.6,29.03 JDIMM1.10 ; v2(140.06,71.12) 139.61,71.58 UC1.L13 ; v2(341.45,43.85) JWLAN.45 ; JDIMM3.47 230.61,38.28 ; UC1.AB39 v2(149.86,45.44) ; UC1.AA8 148.75,75.83 v2(149.19,75.4) ; JWLAN.69 v2(343.88,49.85) ; UC1.A7 130.76,77.45 v2(130.92,77.45) ; v2(151.49,83.19) UC1.AD1 ; JDIMM3.30 240.86,34.03 241.07,34.24 v2(241.07,34.82) 241.07,35.33 240.87,35.53 JDIMM3.36 ; JDIMM2.2 228.14,27.03 228.57,27.46 v2(228.57,27.89) ; JDIMM4.31 203.69,34.28 203.2,33.78 202.41,33.78 202.21,33.98 v2(202.21,34.31) 202.21,34.85 202.64,35.28 JDIMM4.35 ; UC1.AL3 157.89,80.83 v2(158.33,81.26) 157.89,81.69 UC1.AL2 ; UC1.AY9 v2(165.68,74.87) ; UC1.AN19 160.6,63.97 v2(160.16,63.54) UC1.AM19 ; JDIMM3.106 240.86,53.03 v2(241.2,53.36) ; v2(228.15,36.75) 227.92,36.53 JDIMM2.40 ; JDIMM4.102 213.82,52.03 ; v2(255.01,38.53) 253.8,38.53 JDIMM1.48 ; UC1.E19 134.57,65.73 v2(134.57,65.64) ; v2(229.56,83.94) 229.56,83.64 230.43,82.78 JDIMM3.217 ; UC1.A15 v2(130.9,70.27) ; JDIMM4.43 203.51,37.28 202.63,38.16 v2(202.63,39.02) 202.59,39.07 202.59,40.51 202.85,40.78 JDIMM4.57 ; 230.62,85.28 JDIMM3.227 ; 211.48,49.45 211.91,49.03 JDIMM4.90 214.04,49.03 214.33,48.73 214.33,48.24 214.12,48.03 JDIMM4.86 ; JDIMM1.94 254.93,50.03 v2(255.03,50.12) ; JDIMM1.52 v2(255.01,39.53) ; JDIMM1.184 253.8,74.53 v2(255.03,74.53) 254.99,74.48 254.99,73.84 254.68,73.53 JDIMM1.180 ; UC1.G17 135.65,67.7 135.58,67.7 135.54,67.65 v2(135.53,67.65) ; v2(139.15,62.06) UC1.K24 ; v2(214.69,78.53) 214.69,77.83 214.39,77.53 JDIMM4.196 ; UC1.L11 v2(140.13,74.01) UC1.M10 ; JDIMM1.262 259.26,93.95 v2(258.98,93.67) ; UC1.AU1 163.38,83.14 v2(163.47,83.23) ; v2(254.98,53.1) 254.97,53.1 254.9,53.03 253.8,53.03 JDIMM1.106 ; v2(131.9,79.51) 131.91,79.49 131.92,79.32 UC1.C5 ; UC1.AF40 v2(154.24,44.11) ; v2(133.66,51.63) UC1.C33 ; JDIMM2.68 228.03,43.53 228.4,43.89 228.4,43.94 228.65,44.19 228.65,44.7 v2(228.62,44.73) 228.35,44.73 228.14,44.53 JDIMM2.72 ; v2(135.49,71.2) UC1.G13 ; JDIMM2.181 217.58,73.78 217.48,73.87 v2(217.42,73.87) 217.42,72.6 217.74,72.27 JDIMM2.175 ; JDIMM4.98 214.22,51.03 214.53,51.33 214.53,52.3 v2(214.6,52.37) ; UC1.V8 146.01,75.97 147.09,74.89 v2(147.22,74.89) ; UC1.AG3 v2(154.69,81.26) UC1.AG2 ; UC1.AG33 v2(154.69,50.71) ; RT63.2 v2(50.23,45.71) ; JDIMM1.23 244.53,32.28 244.39,32.13 v2(244.37,32.13) 244.37,31.65 244.74,31.28 JDIMM1.19 ; v2(241.07,84.2) 240.89,84.03 JDIMM3.222 ; JDIMM4.214 214.06,82.03 v2(214.11,82.07) 214.11,82.84 213.92,83.03 JDIMM4.218 ; v2(202.31,29.4) 202.31,30.71 202.88,31.28 JDIMM4.19 ; UC1.E3 134.08,80.8 v2(133.62,81.26) ; 161.09,54.37 160.64,53.89 UC1.AN30 160.59,53.87 159.76,53.87 UC1.AM30 v2(159.27,54.37) ; JDIMM1.27 243.72,33.28 v2(243.48,33.04) ; UC1.H30 v2(137.32,56.57) ; UC1.N3 UC1.M4 140.41,79.89 140.11,80.19 v2(140.11,80.29) ; JDIMM1.181 244.59,73.78 244.2,73.39 v2(244.2,72.28) JDIMM1.175 ; 365.76,16.9 v2(366.64,16.02) ; 365.76,16.9 JSSD1.39 ; v2(220.65,75.08) 220.65,74.7 220.55,74.6 219.76,74.6 219.58,74.78 JDIMM2.185 ; v2(141.89,49.8) UC1.M35 ; v2(137.32,60.23) UC1.H26 ; v2(201.57,34.31) 201.62,34.26 201.62,33.73 202.08,33.28 JDIMM4.27 ; JDIMM1.60 253.8,41.53 v2(255.01,41.53) ; v2(137.33,68.46) 137.78,68.91 UC1.J16 ; UC1.AJ1 v2(156.06,83.19) ; 231.6,78.78 JDIMM3.201 230.52,78.78 229.79,79.51 229.01,79.51 228.7,79.2 v2(228.7,79) 228.7,78.31 229.23,77.78 JDIMM3.197 231.6,77.78 ; JDIMM2.202 228.12,79.02 v2(228.14,79) 228.17,78.97 228.17,77.77 227.92,77.53 JDIMM2.196 ; v2(160.21,48.88) UC1.AM35 ; UC1.C2 132.06,81.95 132.06,82.38 v2(132.03,82.41) ; v2(133.66,58.4) UC1.D28 ; v2(163.38,44.19) UC1.AT40 ; JDIMM2.103 217.24,52.28 v2(217.14,52.37) 217.06,52.29 217.06,51.49 217.28,51.28 JDIMM2.99 ; JDIMM1.90 254.98,49.03 v2(254.98,49.03) 255.06,48.95 255.06,48.31 254.77,48.03 JDIMM1.86 ; UC1.AK16 157.86,66.72 v2(157.44,67.14) ; UC1.AD36 v2(152.86,47.97) UC1.AE36 ; v2(235.51,47.81) 235.51,47.38 234.98,46.84 233.55,46.84 232.49,45.78 JDIMM3.77 230.45,45.78 230.28,45.94 230.28,46.37 230.69,46.78 231.6,46.78 231.59,46.78 JDIMM3.81 ; v2(145.48,51.69) UC1.U33 ; v2(229.66,46.35) 229.66,46.29 229.74,46.2 229.74,44.61 230.58,43.78 JDIMM3.69 231.6,43.78 ; JDIMM4.85 202.03,47.78 201.6,48.21 201.6,50.03 v2(201.58,50.05) ; UC1.AD39 152.41,45.84 v2(152.84,46.27) 152.51,46.6 UC1.AD38 ; JDIMM4.167 203,70.28 202.21,71.07 v2(202.21,71.88) ; v2(138.23,46.14) UC1.H39 ; JDIMM1.171 243.09,71.28 v2(242.79,71.58) ; v2(33.78,34.69) 33.54,34.94 33.54,35.37 CT155.2 ; JDIMM1.44 v2(255.01,37.53) ; UC1.V39 146.89,45.65 146.49,46.05 v2(146.49,46.11) ; JDIMM3.167 230.47,70.28 v2(230.3,70.1) 230.3,70.86 230.72,71.28 JDIMM3.171 ; PRF10.2 159.21,111.55 v2(159.74,111.55) ; v2(224.69,52.37) 224.69,50.7 225.36,50.03 JDIMM2.94 227.98,50.03 228.19,49.81 228.19,49.38 227.84,49.03 JDIMM2.90 ; v2(133.66,45.23) UC1.D39 ; v2(343.96,40.85) JWLAN.33 ; v2(157.55,68.09) 157.89,67.74 UC1.AK15 ; UC1.AN10 159.75,74.4 v2(160.21,73.94) ; v2(158.06,83.41) 157.93,83.27 157.93,82.66 UC1.AL1 ; v2(343.88,42.35) JWLAN.39 ; v2(159.27,66.26) UC1.AM17 ; UC1.AY7 v2(166.78,77.14) ; v2(130.91,68.45) UC1.A17 ; v2(140.06,46.14) UC1.K39 ; v2(133.7,75.67) 133.77,75.67 UC1.E9 ; JWLAN.63 v2(343.88,48.35) ; v2(160.21,49.8) UC1.AM34 ; UC1.AJ35 v2(156.52,48.88) ; v2(201.76,86.22) 201.76,85.24 202.72,84.28 JDIMM4.223 ; JDIMM3.5 230.62,27.78 230.35,28.04 230.35,28.46 v2(230.32,28.5) 230.59,28.78 JDIMM3.9 ; UC1.K30 v2(139.15,56.57) ; JDIMM3.65 230.57,42.78 v2(230.02,42.23) 230.48,41.78 JDIMM3.61 ; v2(147.38,47.97) UC1.V37 ; US1.10 v2(222.92,20.63) ; JDIMM3.35 230.73,35.28 230.3,35.7 ; JDIMM4.44 215.15,37.53 215.49,37.87 215.49,39.02 v2(215.49,39.02) 215.49,39.63 215.71,39.85 217.09,39.85 217.67,39.28 JDIMM2.51 ; v2(140.06,49.8) UC1.K35 ; v2(166.78,51.98) 166.68,52.08 UC1.AW32 ; UC1.W33 v2(148.29,51.63) ; v2(160.21,66.28) UC1.AN16 ; UC1.AE3 v2(151.98,81.26) ; RT40.2 RT46.2 ; JDIMM4.217 202.08,82.78 201.7,82.4 201.68,82.4 v2(200.56,81.28) ; v2(201.45,56.33) 201.45,53.95 202.12,53.28 JDIMM4.107 ; JDIMM4.47 203.48,38.28 203.27,38.49 v2(203.27,39.02) 203.52,39.28 JDIMM4.51 ; v2(133.66,53.46) UC1.C31 ; UC1.AH38 v2(156.5,46.14) ; v2(139.15,68.46) UC1.K17 ; v2(132.7,74.81) UC1.C10 ; UC1.AM37 v2(160.21,47.05) ; v2(131.83,69.37) UC1.C16 ; v2(167.7,56.66) UC1.AY27 ; JDIMM2.5 217.41,27.78 217.11,27.47 217.11,26.75 217.19,26.66 v2(217.19,26.58) 217.39,26.78 JDIMM2.1 ; UC1.AK23 157.89,60.31 157.57,60.64 v2(157.57,60.79) 157.57,60.92 157.87,61.23 UC1.AK22 ; v2(137.32,62.06) UC1.H24 ; v2(154.69,80.37) UC1.AG4 153.99,79.65 153.99,79.21 UC1.AG5 ; UC1.D4 v2(132.76,80.33) ; JDIMM2.81 v2(217.49,46.78) ; v2(137.32,51.63) UC1.G33 ; v2(135.49,51.63) UC1.E33 ; v2(135.49,58.4) UC1.F28 ; UC1.Y35 v2(149.21,49.8) ; v2(141.04,76.68) 140.58,77.14 UC1.M7 ; v2(145.55,47.97) UC1.T37 ; UC1.AL27 v2(158.35,56.2) ; UC1.AK7 v2(156.52,77.6) UC1.AK6 ; v2(133.66,56.57) UC1.D30 ; v2(144.73,138.13) PCS53.1 ; v2(135.49,49.8) UC1.E35 ; UC1.B28 v2(131.83,57.49) ; v2(135.49,53.46) UC1.E31 ; v2(162.93,74.86) UC1.AT10 ; v2(137.3,63.9) UC1.H21 ; UC1.AR1 v2(161.55,83.29) ; UC1.AK40 v2(157.89,44.11) ; UC1.W3 v2(146.46,81.26)
  BOTTOM w0.356: CM21.2 CM22.2 161.43,178.1 v2(161.34,178.19) ; PCF15.2 160.44,110.85 v2(159.74,111.55) ; U2408.5 120.48,9.23 v2(120.86,8.85) ; CT205.2 CT217.2 46.65,29.9 v2(46.91,29.64) ; CT102.2 38.3,48.15 CT103.2 ; v2(34.37,46.1) 34.11,46.36 33.07,46.36 33,46.43 RT18.2 ; v2(281.66,46.93) 281.26,47.33 CH183.2 CH180.2 ; CM30.2 162.58,180.95 CM37.2 162.56,180.72 v2(162.14,180.3) ; CT208.2 44.8,28.28 CT207.2 44.91,28.9 v2(45.01,28.99) ; v2(43.61,30.79) 43.89,30.52 CT218.2 ; RT4.2 22.5,50.41 RT726.2 ; CL4.2 182.87,161.04 183.01,161.18 v2(183.01,161.38) ; JDIMM1.2 252.71,27.03 252.12,26.44 v2(251.55,26.44) ; v2(163.92,179.92) 163.92,180.26 164.29,180.63 CM33.2 164.27,180.95 CM38.2 ; CC31.2 145.6,103.88 v2(144.36,102.64) ; UM4.19 164.02,176.71 v2(163.8,176.93) 163.8,177.1 163.44,177.45 RM70.1 ; CH177.2 CH176.2 284.57,54.91 v2(284.57,55.31) ; v2(29.6,51.57) 29.75,51.42 RT11.2 29.75,50.91 RT725.2 29.13,50.88 RT724.2 ; v2(37.62,46.57) 37.85,46.8 RT83.1 RT62.2 ; RT235.1 CT203.2
  BOTTOM w0.381: v2(160.37,174.61) 160.98,174.61 161.01,174.64 161.04,174.64 161.42,175.02 UM4.15 ; 149.96,78.56 149.66,78.86 UC1.AB5 ; v2(244.25,53.36) 244.33,53.28 JDIMM1.107 ; RT5.2 24.17,51.08 24.35,51.27 v2(24.79,51.27) ; v2(163.8,185.65) 163.44,185.29 163.44,184.17 163.25,183.98 RM72.2 RM87.2 ; v2(160.36,192.87) 160.72,192.52 QM2.4 ; DT10.3 v2(14.27,55.14) ; RT34.2 26.5,51.09 v2(25.87,51.71) ; RM62.1 177.76,176.84 177.69,176.76 177.69,176.68 177.5,176.49 176.86,176.49 176.49,176.85 v2(176.35,176.85) ; v2(160.98,167.85) 161.42,168.29 UM4.6 ; JDGFF1.C6 v2(174.87,127.91) ; DK3.1 228.83,14.62 v2(228.67,14.78) ; v2(30.66,51.52) 30.51,51.37 RT38.2 ; v2(178.53,178.71) 178.53,178.71 RM75.1 ; RT45.2 v2(16.34,45.17) ; RM64.2 v2(179.73,181.76) ; RM23.1 RM82.1 v2(178.59,184.21) ; PQS17.4 v2(146.55,150.23) ; v2(163.92,179.92) 163.92,179.54 163.85,179.47 RM84.1 ; PRS55.2 151.01,146.94 v2(151.4,146.94) ; UM3.3 v2(171.35,196.55) ; QM2.1 v2(158.2,191.22)
  BOTTOM w0.406: UC1.AK9 v2(156.54,74.88) ; JDGFF1.C3 176.67,127.75 v2(176.96,127.46) ; Q7.1 293.16,22.41 292.76,22 v2(292.76,21.98) ; JDGFF2.A3 v2(176.67,139.89) ; v2(228.67,14.78) 228.67,14.99 228.32,15.34 227.46,15.34 227.05,14.93 DK2.1 ; QN8.4 353.38,36.27 353.22,36.11 352.61,36.11 v2(352.51,36.21) ; JDGFF2.H3 176.67,151.98 v2(176.44,152.21) ; JDGFF2.G1 177.87,150.43 178.27,150.02 v2(178.27,149.76) ; Q7.4 294.93,20.84 295.2,21.11 v2(295.6,21.11) ; JDGFF2.B1 177.87,142.1 v2(178.08,142.3) ; v2(176.64,143.26) 176.67,143.29 JDGFF2.C3 ; v2(162.92,65.31) 163.38,65.77 UC1.AT17 ; v2(162.92,65.31) 162.5,64.89 UC1.AR18 ; v2(162.92,65.31) 162.47,65.77 UC1.AR17 162.3,65.97 162.3,66.55 UC1.AR16 UC1.AT15 ; v2(176.07,127.25) JDGFF1.B4 ; JDGFF1.B7 174.27,127.15 v2(174.18,127.24) ; UC1.F7 135.09,77.14 135.58,77.64 v2(135.58,77.64) 135.58,77.64 135.95,78.01 UC1.G6 ; JDGFF1.A3 176.67,124.88 v2(176.75,124.8) ; JDGFF1.H3 176.67,136.76 176.5,136.92 v2(176.5,137.2) ; JDGFF1.G1 178.08,135.75 v2(178.4,135.75) ; JDGFF2.H9 173.07,151.92 173.25,152.11 173.25,153.38 v2(173.06,153.57) ; JDGFF1.G4 v2(176.07,134.85) ; v2(296.65,23.75) 296.65,23.28 296.45,23.08 Q8.1 ; JDGFF1.F6 174.87,134.01 173.98,134.9 v2(173.95,134.9) 174.27,135.22 JDGFF1.G7 ; JDGFF1.H9 v2(173.07,137.15) ; QN9.1 353.74,41.5 353.93,41.69 RN8.2 ; v2(172.12,134.98) 172.47,135.33 JDGFF1.G10 ; JDGFF2.B10 172.47,142.22 172.47,142.23 v2(172.47,142.33) ; v2(177.68,128.06) 177.87,128.24 JDGFF1.C1 ; RN6.2 356.46,37.57 QN8.1 ; JDGFF2.G4 v2(176.07,149.77) ; JDGFF2.A6 v2(174.87,139.94) ; JDGFF2.G10 v2(172.47,149.73) ; v2(351.06,39.01) 351.06,39.92 351.34,40.2 QN9.4 ; JDGFF2.B7 v2(174.27,142.31) ; JDGFF1.A9 v2(173.07,124.95) ; UH3.3 280.88,76.61 v2(280.83,76.67) ; JDGFF1.B1 v2(178.5,126.56) ; v2(172.52,139.91) 172.65,139.91 173.07,140.33 JDGFF2.A9 ; JDGFF2.F6 v2(174.87,149.15) ; JDGFF2.C6 v2(174.87,142.9) ; v2(296.96,21.16) 297.23,21.16 297.25,21.14 297.34,21.14 297.75,20.72 Q8.4 ; JDGFF2.G7 v2(174.27,149.75) ; JDGFF1.F3 v2(176.67,132.47) ; JDGFF1.H6 v2(174.87,137.15) ; JDGFF2.B4 v2(176.07,142.27) ; JDGFF2.H6 174.87,151.81 v2(174.47,152.21) ; v2(172.63,127.22) 172.47,127.07 JDGFF1.B10 ; JDGFF2.F3 v2(176.67,149.1)
  BOTTOM w0.457: v2(282.96,70.58) 282.3,69.92 RH589.1 ; v2(153.75,146.66) 153.75,147.25 PCS85.1 ; RH1024.2 283.17,77.49 283.87,78.19 v2(284.06,78.19) ; SW3.5 291.61,93.43 v2(292.51,94.32) ; JTP.18 105.46,11.47 v2(105.06,11.06)
  BOTTOM w0.508: v2(161.13,178.97) 161.52,179.36 RM38.2 ; v2(116.32,172.91) 116.1,172.69 PRS61.2 ; CH232.2 267.83,109.84 268.69,110.69 v2(268.69,110.73) ; v2(176.31,176.25) 176.31,174.58 RL10.1 ; v2(25.35,13.97) 24.96,13.57 JAUDIO.34 ; JAUDIO.31 43.46,14.43 43.71,14.17 v2(44.63,14.17) ; PRZ14.1 62.62,23.68 v2(62.71,23.58) ; 107.28,75.33 105.57,75.33 105.06,74.83 105.06,73.68 105.37,73.37 PCI48.1 ; v2(159.8,166.9) 159.8,167.25 CM18.2 ; v2(194.4,163.73) 194.67,163.99 CL23.2 ; v2(301.19,52.98) 301.18,53 RH628.1 ; JDIMM3.261 247.68,25.3 v2(248.06,25.68) ; v2(297.46,66.23) 296.91,66.77 RH214.2 RH215.2 ; JFAN2.5 v2(380.2,51.01) ; CT118.2 94.67,17.15 v2(94.9,16.92) 94.9,16.71 94.66,16.47 93.94,16.47 93.55,16.86 CT116.2 ; v2(205.07,166.11) 205.07,165.72 204.73,165.38 CL115.2 ; PCF04.2 v2(154.49,119.5) ; v2(153.95,143.02) 153.95,142.7 153.45,142.2 PCS57.2 ; v2(208.72,97.87) 208.75,97.9 JDIMM2.261 ; v2(161.33,167.28) 161.61,167.56 CM20.2 ; CM34.2 v2(173.13,186.78) ; v2(91.46,66.57) 91.46,65.38 JFAN1.6 ; CL66.2 188.1,177.62 v2(188.1,178.29) ; CL111.2 199.04,165.18 198.66,165.57 198.66,165.88 v2(198.62,165.91) ; v2(190.97,163.82) 190.97,163.09 190.28,162.39 CL69.2 ; JTRON.13 v2(241.8,103.87) ; PQ9.3 56.62,19.6 57.61,18.62 v2(57.61,17.52) ; CF5.2 v2(373.56,46.4) ; CL112.2 203.84,165.59 203.39,166.04 v2(203.39,166.47) ; v2(354.99,48.92) 355.28,49.21 PC1206.2 ; PRZ11.1 61.05,25.38 v2(61.05,24.92) ; v2(167.61,175.54) 168.19,174.95 CM36.2 ; 295.61,45.88 295.88,46.15 CE82.2 ; 295.61,45.88 295.61,45.16 295.45,45 JTOBII.6 ; 295.61,45.88 295.09,45.88 v2(294.6,46.37) ; CL107.2 v2(190.72,183.77) ; v2(107.92,127.07) 107.6,126.76 CE61.2 ; RH220.1 286.69,54.77 v2(286.69,55.34) ; PRA11.1 v2(124.68,114.12) ; YE1.4 362.52,45.9 v2(362.55,45.92) ; v2(126.4,153.53) 126.48,153.45 PQS23.3 ; JTRON.11 v2(242.8,103.87) ; v2(48.06,28.99) 48.51,28.53 CT202.2 ; CS2.2 219.32,19.16 219.63,19.48 v2(219.63,20.03) ; v2(25.18,24.15) 24.49,24.84 YT1.2 ; RM17.1 168.73,193.5 v2(168.81,193.57) ; PC10.2 PC9.2 v2(72.14,20.59) ; v2(125.83,85.93) 124.06,87.7 CC2.2 ; v2(151.91,160.6) 152.64,160.6 152.86,160.82 PQ11.3 ; PCS24.2 123.23,139.96 v2(123.4,139.79) ; CT154.2 32.29,34.32 v2(32.53,34.08) ; CL114.2 202.95,165.59 202.78,165.76 v2(202.78,166.43) ; v2(256.96,108.38) 256.96,107.76 256.73,107.53 UH4.4 ; JFAN1.5 92.24,60.72 v2(89.78,63.17) ; v2(203.99,144.93) 203.99,144.93 203.99,144.93 203.19,144.13 PR779.1 ; CT203.2 47.47,21.37 v2(48.06,21.96) ; v2(368.46,35.9) 367.95,35.39 JELC.5 ; v2(163.98,172.64) 165.38,172.64 165.7,172.32 CM19.2 ; v2(357.28,37.36) 356.89,37.75 RN6.2 ; v2(167.22,176.81) 166.93,176.81 CM16.2 CM17.2 ; v2(192.75,171.41) 192.69,171.35 CL40.2 ; PC1207.2 353.26,50.44 v2(353.62,50.09) ; v2(135.86,143.26) 135.41,143.26 PQ4.3 135.3,144.25 PR7.2 ; v2(219.48,16.46) 219.91,16.03 CS7.2 ; CT100.2 v2(36.67,52.32) ; v2(149.91,153.04) 148.91,153.04 148.55,152.68 PRS65.2 148.35,151.53 PQS17.1 ; PCS28.2 v2(131.35,144.71) ; v2(232.38,14.69) 232.51,14.55 PC2505.2 PC2506.2 ; JTOBII.8 291.61,46.3 v2(290.67,47.23) ; CU2.2 25.3,19.25 v2(25.24,19.19) ; v2(85.56,60.48) 84.65,59.56 JFAN1.7 ; JRTC.4 v2(350.75,8.54) ; PRI202.2 PRI207.2 v2(81.42,26.71) ; YL1.2 v2(183.75,157.99) ; RH635.1 v2(256.51,102.32) ; CM23.2 v2(166.73,194.54) ; v2(73.52,32.61) 73.49,32.61 73.49,32.61 PCZ21.2 ; YL1.4 v2(185.98,159.69) ; CH181.2 CH189.2 282.28,45.9 v2(283.07,46.69) ; PRA22.2 v2(125.91,110.72) ; PCI135.2 v2(121.76,66.83) ; PQ12.3 v2(146.65,171.16) ; PCI29.2 109.63,20.55 109.8,20.72 v2(110.59,20.72) ; v2(52.92,44) 52.37,44.55 CT157.2 ; v2(345.6,30.97) 345.12,30.48 344.34,30.48 343.08,31.75 JWLAN.76 ; PR1205.2 v2(352.6,51.79) ; CL26.2 CL27.2 173.07,172.88 172.56,173.39 v2(172.56,173.95) ; DK1.1 231.3,14.25 v2(231.74,14.69) ; PQ10.1 146.9,167.42 146.45,167.87 PR41.2 v2(146.45,169.18) ; PRA08.1 v2(126.93,119.87) ; JTRON.14 v2(241.8,108.67) ; JPK.22 v3(243.61,5.8) v2(244.06,6.25) ; JTP.17 98.36,11.47 v2(98.6,11.23) ; CF4.2 v2(92.95,51.14) ; CC38.2 CC30.2 149.43,106 v2(149.82,106.39) ; v2(40.16,36.88) 39.7,37.34 39.6,37.34 v3(38.71,38.22) CH242.2 ; JDIMM2.262 216.5,22.4 217,21.89 v2(217,21.38) ; CT114.2 86.71,22.18 v2(86.71,22.61) ; PR2502.2 243.77,17.23 PC2501.2 245.77,17.23 247.01,16 247.01,15.97 ; v2(239.02,13.79) 239.3,13.51 PC2507.2 ; JFC.10 v2(119.7,125.05) ; v2(290.92,36.28) 291.17,36.28 291.68,35.77 291.68,35.2 PC1804.2 ; v2(81.23,34.06) 81.23,34.69 81.23,34.69 PRI226.2 ; v2(218.08,103.72) 218.38,104.01 R185.1 ; v2(291.55,96.8) 290.68,95.92 C1.2 ; PCA09.2 v2(131.55,111.12) ; v2(375.59,19.45) 374.34,19.45 373.66,18.77 C641.2 ; v2(34.37,46.1) 35.61,46.1 36.35,45.36 CT98.2 ; RM29.2 158.6,179.91 v2(158.33,179.91) ; v2(221.02,4.74) 222.08,5.8 JPK.21 ; v2(247.58,14.6) 247.58,15.4 247.01,15.97 ; PC17.2 59.77,20.21 PR34.2 v2(60.72,20.23) ; CLRP1.2 282,81.15 CH53.2 ; PQS13.4 112.14,165.72 111.78,166.08 111.34,166.08 110.84,166.58 PQS13.1 v2(109.47,167.19) ; v2(20.35,20.42) CU242.2 CU243.2 ; JFAN2.7 v2(374.14,55.4) ; YH2.2 297.51,49.99 v2(297.46,49.93) 296.79,49.93 CH48.2 ; v2(294.39,69.61) 293.31,68.52 CH182.2 ; PCZ01.2 56.41,33.1 56.29,32.98 v2(56.27,32.98) ; v2(151.41,158.14) 151.69,158.42 PR21.2 151.69,159.62 PQ6.1 ; PC1201.2 v2(367.82,46.94) ; CE81.2 302.15,46.35 CE79.2 301.96,47.14 301.45,47.65 v2(301.45,47.79) ; YT1.4 26.22,25.98 v2(26.65,25.55) ; v2(360.12,48.23) 359.99,48.11 PC1203.1 ; CT95.1 9.55,48.49 v2(9.19,48.13) 8.84,48.49 CT94.1 ; CM32.2 v2(170.61,186.81) ; v2(111.48,174.88) 111.97,174.39 PC23.2 ; v2(370.04,35.96) 370.49,35.52 JELC.9 ; CL50.2 188.43,162.65 188.31,162.77 v2(188.31,162.84) ; CT201.2 46.77,25.23 v2(46.53,25.47) 46.13,25.88 CT206.2 ; JDIMM3.262 245.68,97.9 v2(245.77,97.81) ; v2(112.24,67.84) 112.05,67.65 PCI46.2 ; PRI228.2 81.3,35.72 PCI211.2 81.3,36.95 v2(81.58,37.23) ; JFC.9 v2(118.7,125.05) ; YE1.2 358.4,43.53 v2(357.89,43.53) ; RM6.1 v2(167.37,195.88) ; v2(213.96,167.28) CL108.2 CL31.2 ; 247.01,15.97 PC2502.2 244.84,15.95 PC2503.2 ; PC11.2 PC12.2 v2(65.17,14.81) ; CM9.2 179.48,180.45 v2(179.67,180.26) ; JFC.11 v2(109.4,122.74) ; v2(197.82,165.9) 197.82,165.46 197.84,165.44 197.84,165.37 198.15,165.06 CL110.2 ; CL47.2 v2(186.84,178.27) ; JFC.12 v2(121,122.7) ; JHDD.24 253.4,10.86 v2(253.87,11.33) ; v2(100.3,23.54) 101.04,23.54 101.26,23.33 PCI19.1 ; PCI206.2 81.44,29.25 81.45,29.26 v2(81.45,29.85) ; JHDD.22 249.49,6.94 v2(249.01,6.94) ; v2(110.28,157.92) PCS2508.2 PCS2509.2 ; JELC.3 366.68,33.36 v2(366.17,32.85) ; v2(195.93,165.19) 196.32,165.19 CL22.2 ; PRA16.2 133.25,119.3 v2(133.52,119.03) ; RL53.1 184.94,178.4 v2(184.62,178.71) ; CV1109.2 v2(119.6,126.2) ; v2(148.45,163.71) 148.2,163.96 PQ10.4 ; v2(115.6,122.77) 115.1,122.77 114.7,123.17 JFC.5 ; PHZ04.1 v2(72.99,28.48) ; PRG10.1 v2(143.14,20.04) ; RL25.2 173.96,167.3 v2(174.6,166.65) ; JTRON.12 v2(242.8,108.67) ; v2(130.59,152.68) 130.59,152.67 PD2.1 ; CF6.2 87.71,50.39 v2(87.78,50.31) ; v2(39.11,41.41) 39.13,41.38 CT99.2 ; C2.2 102.46,18.95 103.28,19.77 103.28,21.02 v2(103.74,21.48) ; PCZ27.1 v2(70.98,28.11) ; JSSD1.76 v2(365.56,6.3) ; RM21.1 166.67,169.46 166.15,168.93 v2(165.51,168.93) ; RM25.1 162.72,178.44 162.34,178.83 v2(162.34,179.22) ; PCS2510.2 133.02,128.17 v2(133.58,127.61) 134.14,128.17 PCS2511.2 ; v2(40.94,35.02) 40.06,35.91 UT2.4 ; CL116.2 199.93,165.16 199.3,165.79 v2(199.3,166) ; v2(379.86,22.12) 379.6,22.38 DU11.1 ; YH2.4 300.51,47.79 v2(301.45,48.73) ; CV1071.2 v2(299.36,44.14) 299.95,44.14 300.02,44.07 UE12.2 301.36,44.07 301.97,43.45 301.97,41.95 CE80.2 ; C2498.2 222.94,109.29 222.43,108.79 v2(222.43,107.76) ; JFAN2.6 v2(381.36,55.4) ; v2(53.56,19.16) 53.37,19.35 PC16.2 ; PCI09.2 v2(114.86,93.47) ; CF7.2 v2(371.68,46.35) ; v2(42.49,21.86) 42.49,21.96 44.49,23.96 CT200.2 CT204.2 ; CT97.2 v2(11.33,44.19) ; CL109.2 212.42,165.87 v2(212.94,166.39) ; CE5.2 358.36,42.89 358.16,42.7 ; v2(46.8,11.35) 46.32,11.84 JAUDIO.33 ; JHDD.21 v2(264.45,5.17) ; v2(109.69,168.23) PRS62.2 ; CH47.2 296.52,47.43 296.33,47.25 295.43,47.25 294.92,47.75 v2(294.92,48.09) ; CL113.2 v2(202.07,166.18) ; CL9.2 201.14,165.38 201.32,165.56 v2(201.32,165.93) ; v2(344.98,8.7) 344.4,8.11 JRTC.3 ; PRI214.2 82.08,40.34 v2(81.52,39.79) ; PCA13.2 v2(124.24,117.49) ; v2(380.87,37.92) 380.39,37.92 379.17,39.14 DU10.1 ; PC1806.2 298.13,36.7 298.05,36.62 v2(297.26,36.62) 297.23,36.6 PC1807.2 ; v2(355.03,41.69) RN8.2 ; PCG20.2 v2(160.49,17.39) ; CH49.2 v2(263.21,101.5) ; PRI216.2 81.39,42.01 PCI204.2 v2(81.39,43.55) ; PQ6.4 150.14,161.12 v2(150.08,161.06) ; JTRON.26 234.14,104.1 v2(233.9,103.87) 232.64,105.13 CE87.2 CE176.2 ; v2(300.74,30.83) 300.91,30.83 301.42,31.34 PR1805.2 301.23,31.53 PU1801.8 ; v2(170.46,174.71) 170.32,174.57 CM35.2 ; JAUDIO.32 27.16,14.16 v2(27.55,13.76) ; PCI10.2 v2(115.76,93.41) ; PRA15.1 v2(124.27,118.62) ; PCG02.2 v2(132.69,16.94) ; JHDD.23 262.15,9.55 v2(262.91,10.31) ; v2(138.82,155.03) PRS68.2 ; v2(192.41,167.28) 192.18,167.28 192.05,167.16 CL41.2 ; PCA08.2 v2(129.77,111.02) ; PR1204.2 v2(354.2,51.66) ; JWLAN.77 v2(343.99,52.45) ; v2(110.03,5.48) 110.58,5.48 112.1,7.01 C2531.2 ; CU3.2 v2(23.81,19.33) ; PBATT1.13 v2(84.6,16.85) ; PCI137.2 v2(119.16,47.46) ; PCG11.2 v2(139.98,14.63) ; PCI136.2 v2(119.19,31.58) ; JRTC.2 v2(346.95,10.69)
  vias: v2(0.43,39.34) v2(0.43,37.05) v2(0.43,8.58) v2(0.43,6.29) v2(0.47,48.47) v2(0.47,45.93) v2(0.47,43.39) v2(0.47,38.31) v2(0.54,34.77) v2(0.77,4.03) v2(1.8,52.6) v2(1.93,6.44) v2(2.39,36.1) v2(2.98,3.43) v2(3.2,11.14) v2(3.2,5.23) v2(3.45,37.93) v2(3.45,34.27) v2(3.52,8.98) v2(3.89,55.1) v2(3.9,15.01) v2(4.45,29.98) v2(4.79,12.98) v2(4.95,56.93) v2(4.95,53.27) v2(5.55,37.93) v2(5.55,34.27) v2(6.09,6.5) v2(6.24,58.57) v2(6.38,11.77) v2(6.61,36.1) v2(7.05,56.93) v2(7.05,53.27) v2(7.15,8.33) v2(7.15,4.67) v2(7.55,3.43) v2(8.11,55.1) v2(9.29,58.57) v2(9.25,8.33) v2(9.25,4.67) v2(9.36,41.43) v2(9.87,29.98) v2(10.32,14.95) v2(10.31,6.5) v2(11.2,48.33) v2(11.27,55.82) v2(11.31,29.98) v2(11.4,55.14) v2(11.48,49.71) v2(11.61,53.39) v2(12.12,3.43) v2(12.34,58.57) v2(12.67,5.74) v2(13.3,8.09) v2(14.23,4.32) v2(15.02,41.68) v2(15.01,40.28) v2(15.38,58.57) v2(15.4,14.56) v2(15.78,11.45) v2(15.9,6.69) v2(15.98,13.28) v2(16.46,38.66) v2(16.53,37.46) v2(16.51,4.33) v2(16.86,8.09) v2(17.24,56.72) v2(17.21,53.26) v2(17.29,53.82) v2(17.42,55.06) v2(17.75,53.44) v2(18.43,58.57) v2(18.42,5.6) v2(18.59,44.25) v2(18.82,44.82) v2(20.08,7.17) v2(20.64,30.25) v2(20.63,29.47) v2(20.59,28.71) v2(20.59,27.51) v2(20.65,30.96) v2(20.97,41.27) v2(21.48,58.57) v2(21.61,43.87) v2(21.68,33.81) v2(22.36,7.33) v2(23.27,32.66) v2(23.52,33.55) v2(24.13,32.67) v2(24.53,58.57) v2(24.64,7.33) v2(25.25,33.52) v2(25.53,39.31) v2(25.79,32.17) v2(26.93,7.33) v2(27.58,58.57) v2(29.06,25.19) v2(29.06,24.08) v2(29.06,22.96) v2(29.22,7.33) v2(30.17,25.19) v2(30.17,24.08) v2(30.17,22.96) v2(30.62,58.57) v2(31.29,25.19) v2(31.29,24.08) v2(31.29,22.96) v2(31.5,7.33) v2(33.67,58.57) v2(33.79,7.33) v2(34,21.61) v2(34,21.03) v2(34.19,20.5) v2(34.75,47.93) v2(35.58,23.87) v2(36.07,7.33) v2(36.27,23.89) v2(36.72,58.57) v2(37.74,26.39) v2(38.36,7.33) v2(38.87,22.43) v2(39.2,27.4) v2(39.59,57.55) v2(40.02,21.55) v2(40.65,7.33) v2(41.94,26.06) v2(42.26,48.57) v2(42.29,27.23) v2(42.43,56.43) v2(42.86,48.56) v2(42.93,7.33) v2(43.45,48.54) v2(44.3,38.25) v2(44.88,38.25) v2(45.01,21.96) v2(45.06,45.69) v2(45.22,7.33) v2(45.33,55.51) v2(45.33,47.34) v2(45.32,46.22) v2(47.5,7.33) v2(48.29,54.78) v2(49.79,7.33) v2(51.29,54.24) v2(52.08,7.33) v2(52.67,25.87) v2(52.94,29.49) v2(52.9,17.36) v2(52.92,16.71) v2(53.11,27.01) v2(53.23,28.47) v2(53.31,24.8) v2(54.32,53.9) v2(54.36,7.33) v2(56.65,7.33) v2(57.37,53.77) v2(58.81,6.58) v2(60.25,14.83) v2(60.41,53.83) v2(60.42,4.96) v2(62.62,4.33) v2(62.99,33.59) v2(62.99,31.62) v2(62.99,29.65) v2(63.42,17.32) v2(63.45,54.1) v2(64.91,4.33) v2(64.96,33.59) v2(64.96,31.62) v2(64.96,29.65) v2(66.46,54.57) v2(66.93,33.59) v2(66.93,31.62) v2(66.93,29.65) v2(67.19,4.33) v2(69.48,4.33) v2(69.97,55.23) v2(71.55,53.57) v2(71.76,4.33) v2(73.43,7.82) v2(73.83,53.57) v2(73.94,8.41) v2(74.01,7.82) v2(74.05,4.33) v2(74.52,8.41) v2(74.6,7.82) v2(75.04,53.57) v2(75.11,8.41) v2(75.18,7.82) v2(75.69,8.41) v2(75.77,7.82) v2(76.12,53.57) v2(76.27,8.41) v2(76.34,4.33) v2(76.35,7.82) v2(76.74,17.1) v2(76.86,8.41) v2(77.32,17.1) v2(77.91,17.1) v2(78.4,53.57) v2(78.49,17.1) v2(78.62,4.33) v2(79.07,17.1) v2(79.15,9.04) v2(79.15,8.46) v2(79.15,7.87) v2(79.66,17.1) v2(80.66,53.94) v2(80.91,4.33) v2(81.01,54.43) v2(81.13,58.46) v2(81.13,57.47) v2(81.13,56.17) v2(82.06,60.55) v2(83.19,4.33) v2(83.96,61.81) v2(84.43,62.14) v2(85.08,37.34) v2(85.2,40.89) v2(85.17,24) v2(85.17,23.42) v2(85.33,29.53) v2(85.48,4.33) v2(85.66,37.34) v2(85.82,63.15) v2(85.79,40.89) v2(85.83,24) v2(85.83,23.42) v2(85.91,29.53) v2(86.87,63.97) v2(87.61,64.57) v2(87.77,4.33) v2(89.32,66.08) v2(89.59,12) v2(90.05,4.33) v2(90.65,10.17) v2(90.73,41.21) v2(90.73,38.8) v2(90.73,34.1) v2(90.73,31.68) v2(90.96,67.68) v2(91.24,26.92) v2(91.31,41.21) v2(91.31,38.8) v2(91.31,34.1) v2(91.31,31.68) v2(91.3,24.57) v2(91.35,68.09) v2(91.82,26.92) v2(91.85,20.98) v2(91.9,41.21) v2(91.9,38.8) v2(91.9,34.1) v2(91.9,31.68) v2(91.88,24.57) v2(92.34,4.33) v2(92.4,26.92) v2(92.48,41.21) v2(92.48,38.8) v2(92.48,34.1) v2(92.48,31.68) v2(92.47,24.57) v2(92.99,26.92) v2(93.05,24.57) v2(93.38,70.36) v2(93.81,12) v2(93.99,71.1) v2(94.09,69.5) v2(94.62,4.33) v2(95.15,71.33) v2(95.15,67.67) v2(96.67,74.81) v2(96.77,5.13) v2(96.97,75.28) v2(97.25,71.33) v2(97.25,67.67) v2(97.67,7.23) v2(97.86,76.75) v2(98.31,69.5) v2(98.52,77.91) v2(98.96,78.76) v2(99.67,46.57) v2(99.67,45.98) v2(99.72,28.53) v2(99.72,27.95) v2(99.78,26.76) v2(99.96,80.81) v2(99.95,7.33) v2(100.25,46.57) v2(100.25,45.98) v2(100.37,26.76) v2(100.8,36.82) v2(100.8,36.23) v2(100.86,82.91) v2(101.07,83.45) v2(101.65,85.06) v2(101.8,54.35) v2(101.8,53.77) v2(102.07,86.33) v2(102.24,7.33) v2(102.34,87.24) v2(102.91,89.45) v2(103.15,60.03) v2(103.38,91.69) v2(103.48,92.25) v2(103.59,60.41) v2(103.74,93.95) v2(103.89,95.27) v2(103.98,96.22) v2(104.13,151.08) v2(104.13,150.13) v2(104.13,148.8) v2(104.13,147.08) v2(104.13,146.51) v2(104.13,144.22) v2(104.13,141.94) v2(104.13,140.98) v2(104.13,134.89) v2(104.13,132.79) v2(104.13,131.84) v2(104.13,130.51) v2(104.13,128.79) v2(104.13,128.22) v2(104.13,125.94) v2(104.13,123.65) v2(104.13,122.7) v2(104.13,121.36) v2(104.13,119.65) v2(104.13,119.08) v2(104.13,116.79) v2(104.13,114.51) v2(104.13,113.55) v2(104.13,112.22) v2(104.13,110.5) v2(104.13,109.93) v2(104.13,107.65) v2(104.13,105.36) v2(104.13,104.41) v2(104.13,103.08) v2(104.13,101.36) v2(104.13,100.79) v2(104.11,98.5) v2(104.22,39.23) v2(104.22,38.64) v2(104.23,38.06) v2(104.5,153.34) v2(104.53,7.33) v2(104.55,29.8) v2(104.8,39.23) v2(104.8,38.64) v2(104.93,47.65) v2(104.93,47.06) v2(104.98,155.57) v2(105.15,16.75) v2(105.18,29.93) v2(105.18,29.35) v2(105.18,28.76) v2(105.38,39.23) v2(105.38,38.64) v2(105.73,159.12) v2(105.82,46.63) v2(105.77,29.93) v2(105.77,29.35) v2(105.77,28.76) v2(105.77,28.18) v2(105.93,160.05) v2(105.88,143.15) v2(105.9,37.17) v2(105.97,39.24) v2(105.97,38.2) v2(106.09,137.5) v2(106.22,37.68) v2(106.32,142.71) v2(106.32,47.52) v2(106.32,46.94) v2(106.32,46.35) v2(106.29,38.72) v2(106.33,35.73) v2(106.33,34.43) v2(106.33,33.13) v2(106.35,29.93) v2(106.35,29.35) v2(106.35,28.76) v2(106.35,28.18) v2(106.41,162.28) v2(106.36,44.96) v2(106.36,43.66) v2(106.36,42.37) v2(106.49,37.17) v2(106.54,26.76) v2(106.54,25.46) v2(106.54,24.17) v2(106.55,39.24) v2(106.55,38.2) v2(106.81,37.68) v2(106.81,7.33) v2(106.88,164.52) v2(106.91,47.52) v2(106.91,46.94) v2(106.91,46.35) v2(106.87,38.72) v2(106.93,29.93) v2(106.93,29.35) v2(106.93,28.76) v2(106.93,28.18) v2(107,165.08) v2(107.15,139.33) v2(107.15,135.67) v2(107.14,44.96) v2(107.14,39.24) v2(107.14,38.2) v2(107.07,37.17) v2(107.11,35.73) v2(107.32,26.76) v2(107.36,166.75) v2(107.39,37.68) v2(107.49,47.52) v2(107.49,46.94) v2(107.49,46.35) v2(107.45,38.72) v2(107.55,32.28) v2(107.52,29.93) v2(107.52,29.35) v2(107.52,28.76) v2(107.52,28.18) v2(107.63,168.07) v2(107.58,41.52) v2(107.72,39.24) v2(107.72,38.2) v2(107.66,37.17) v2(107.83,168.99) v2(107.85,152.4) v2(107.85,151.81) v2(107.82,149.58) v2(107.82,148.99) v2(107.84,56.47) v2(107.84,55.89) v2(107.84,55.31) v2(107.84,54.72) v2(107.81,53.33) v2(107.81,52.03) v2(107.81,50.74) v2(107.75,23.32) v2(107.85,127.68) v2(107.92,44.96) v2(107.92,43.66) v2(107.92,42.37) v2(107.9,35.73) v2(107.9,34.43) v2(107.9,33.13) v2(108.02,116.65) v2(108.04,38.72) v2(107.97,37.68) v2(108.08,47.52) v2(108.08,46.94) v2(108.08,46.35) v2(108.1,29.93) v2(108.1,29.35) v2(108.1,28.76) v2(108.1,28.18) v2(108.1,26.76) v2(108.1,25.46) v2(108.1,24.17) v2(108.24,37.17) v2(108.31,171.23) v2(108.31,39.24) v2(108.31,38.2) v2(108.44,127.68) v2(108.42,56.47) v2(108.42,55.89) v2(108.42,55.31) v2(108.42,54.72) v2(108.48,75.3) v2(108.48,74.71) v2(108.48,74.13) v2(108.6,116.65) v2(108.59,53.33) v2(108.62,38.72) v2(108.56,37.68) v2(108.63,5.95) v2(108.66,47.52) v2(108.66,46.94) v2(108.66,46.35) v2(108.66,45.77) v2(108.69,29.93) v2(108.69,29.35) v2(108.69,28.76) v2(108.69,28.18) v2(108.78,173.46) v2(108.83,37.17) v2(108.9,174.03) v2(108.89,39.24) v2(108.89,38.2) v2(109.02,127.68) v2(109,56.47) v2(109,55.89) v2(109,55.31) v2(109,54.72) v2(109.02,49.89) v2(109.14,37.68) v2(109.24,47.52) v2(109.24,46.94) v2(109.24,46.35) v2(109.24,45.77) v2(109.21,38.72) v2(109.25,139.33) v2(109.25,135.67) v2(109.27,29.93) v2(109.27,29.35) v2(109.27,28.76) v2(109.27,28.18) v2(109.37,53.33) v2(109.37,52.03) v2(109.37,50.74) v2(109.52,175.63) v2(109.59,56.47) v2(109.59,55.89) v2(109.59,55.31) v2(109.59,54.72) v2(109.81,62.22) v2(109.81,60.92) v2(109.81,59.63) v2(109.83,47.52) v2(109.83,46.94) v2(109.83,46.35) v2(109.83,45.77) v2(109.85,29.93) v2(109.85,29.35) v2(109.85,28.76) v2(109.85,28.18) v2(109.96,67.14) v2(109.96,66.56) v2(109.96,65.97) v2(109.96,65.39) v2(109.96,64.81) v2(109.96,64.22) v2(109.96,63.64) v2(110.21,116.63) v2(110.17,56.47) v2(110.17,55.89) v2(110.17,55.31) v2(110.17,54.72) v2(110.25,4.33) v2(110.31,137.5) v2(110.39,54.15) v2(110.41,47.52) v2(110.41,46.94) v2(110.41,46.35) v2(110.44,29.93) v2(110.44,29.35) v2(110.44,28.76) v2(110.44,28.18) v2(110.54,66.56) v2(110.54,65.97) v2(110.54,65.39) v2(110.54,64.81) v2(110.54,64.22) v2(110.54,63.64) v2(110.59,62.22) v2(110.76,56.47) v2(110.76,55.89) v2(110.76,55.31) v2(110.76,54.72) v2(110.93,132.32) v2(111.03,58.78) v2(110.97,54.15) v2(111,47.52) v2(111,46.94) v2(111.12,66.56) v2(111.12,65.97) v2(111.12,65.39) v2(111.12,64.81) v2(111.12,64.22) v2(111.12,63.64) v2(111.17,176.07) v2(111.34,56.47) v2(111.34,55.89) v2(111.34,55.31) v2(111.38,62.22) v2(111.38,60.92) v2(111.38,59.63) v2(111.65,131.68) v2(111.65,130.92) v2(111.65,130.16) v2(111.7,133.08) v2(111.7,132.32) v2(111.71,66.56) v2(111.71,65.97) v2(111.71,65.39) v2(111.71,64.81) v2(111.71,64.22) v2(111.71,63.64) v2(111.69,18.4) v2(111.76,176.07) v2(111.95,73.45) v2(111.95,72.15) v2(111.95,70.85) v2(111.92,56.47) v2(111.92,55.89) v2(111.92,55.31) v2(112.29,66.56) v2(112.29,65.97) v2(112.29,65.39) v2(112.29,64.81) v2(112.29,64.22) v2(112.29,63.64) v2(112.41,131.68) v2(112.41,130.92) v2(112.41,130.16) v2(112.46,133.84) v2(112.46,133.08) v2(112.46,132.32) v2(112.51,56.47) v2(112.53,4.33) v2(112.61,76.92) v2(112.61,76.34) v2(112.61,75.75) v2(112.61,75.17) v2(112.73,73.45) v2(112.88,67.14) v2(112.88,66.56) v2(112.88,65.97) v2(112.88,65.39) v2(112.88,64.81) v2(112.88,64.22) v2(112.88,63.64) v2(112.94,20.58) v2(112.94,16.22) v2(113.09,133.92) v2(113.09,133.16) v2(113.09,132.4) v2(113.09,56.47) v2(113.17,131.68) v2(113.17,130.92) v2(113.17,130.16) v2(113.25,76.92) v2(113.25,76.34) v2(113.25,75.75) v2(113.25,75.17) v2(113.16,70) v2(113.41,67.38) v2(113.41,66.8) v2(113.41,66.22) v2(113.41,65.63) v2(113.41,65.05) v2(113.41,64.46) v2(113.51,73.45) v2(113.51,72.15) v2(113.51,70.85) v2(113.63,170.48) v2(113.85,133.92) v2(113.85,133.16) v2(113.85,132.4) v2(113.93,131.68) v2(113.93,130.92) v2(113.93,130.16) v2(113.88,76.92) v2(113.88,76.34) v2(113.88,75.75) v2(113.88,75.17) v2(114.04,176.07) v2(113.99,67.38) v2(113.99,66.8) v2(113.99,66.22) v2(113.99,65.63) v2(113.99,65.05) v2(113.99,64.46) v2(114.22,170.48) v2(114.2,74.66) v2(114.52,76.92) v2(114.52,76.34) v2(114.52,75.75) v2(114.52,75.17) v2(114.52,74.15) v2(114.64,133.94) v2(114.64,133.18) v2(114.64,132.42) v2(114.64,131.68) v2(114.64,130.92) v2(114.64,130.16) v2(114.58,67.38) v2(114.58,66.8) v2(114.58,66.22) v2(114.58,64.46) v2(114.83,74.66) v2(114.82,4.33) v2(115.15,76.92) v2(115.15,76.34) v2(115.15,75.75) v2(115.15,75.17) v2(115.15,74.15) v2(115.16,67.38) v2(115.16,66.8) v2(115.16,66.22) v2(115.16,64.46) v2(115.4,133.94) v2(115.4,133.18) v2(115.4,132.42) v2(115.4,131.68) v2(115.4,130.92) v2(115.47,74.66) v2(115.46,20.58) v2(115.46,16.22) v2(115.75,67.38) v2(115.75,66.8) v2(115.75,66.22) v2(115.79,76.92) v2(115.79,76.34) v2(115.79,75.75) v2(115.79,75.17) v2(115.79,74.15) v2(116.1,74.66) v2(116.17,133.94) v2(116.17,133.18) v2(116.17,132.42) v2(116.17,131.68) v2(116.33,176.07) v2(116.42,76.92) v2(116.42,76.34) v2(116.42,75.75) v2(116.42,75.17) v2(116.42,74.15) v2(116.74,85.62) v2(116.69,74.66) v2(116.71,18.4) v2(116.93,133.94) v2(116.93,133.18) v2(116.93,132.42) v2(117,76.92) v2(117,76.34) v2(117,75.75) v2(117,75.17) v2(117.11,4.33) v2(117.26,176.07) v2(117.34,103) v2(118.62,176) v2(118.59,105.18) v2(118.59,100.82) v2(118.63,2.63) v2(119.26,0.43) v2(119.74,174.01) v2(119.74,171.72) v2(119.74,169.44) v2(119.81,168.19) v2(120.62,167.33) v2(120.57,14.73) v2(120.57,14.15) v2(120.74,55.78) v2(120.8,72.35) v2(120.93,98.51) v2(120.93,97.31) v2(120.87,96.23) v2(120.99,95.02) v2(121.11,105.18) v2(121.11,100.82) v2(121.06,93.81) v2(121.16,14.73) v2(121.16,14.15) v2(121.44,72.35) v2(121.37,55.78) v2(121.54,0.43) v2(121.72,148.18) v2(121.72,147.52) v2(121.94,138.76) v2(121.94,138.17) v2(122.01,55.78) v2(122.07,72.35) v2(122.14,16.03) v2(122.14,14.31) v2(122.24,151.04) v2(122.36,103) v2(122.53,138.76) v2(122.53,138.17) v2(122.64,55.78) v2(122.71,72.35) v2(122.71,16.03) v2(122.71,14.31) v2(122.85,150.49) v2(122.85,149.86) v2(122.9,167.22) v2(122.88,151.05) v2(122.92,19.44) v2(122.92,18.86) v2(122.92,18.27) v2(122.92,17.69) v2(123.11,138.76) v2(123.11,138.17) v2(123.47,105.56) v2(123.51,19.44) v2(123.51,18.86) v2(123.51,18.27) v2(123.51,17.69) v2(123.67,138.76) v2(123.67,138.17) v2(123.83,0.43) v2(124.09,19.44) v2(124.09,18.86) v2(124.09,18.27) v2(124.09,17.69) v2(124.29,104.67) v2(124.29,78.32) v2(124.43,78.86) v2(124.51,151.03) v2(124.51,150.39) v2(124.49,136.55) v2(124.68,19.44) v2(124.68,18.86) v2(124.68,18.27) v2(124.68,17.69) v2(124.93,106.7) v2(124.86,78.41) v2(125.04,137.1) v2(125.1,146.38) v2(125.1,144.19) v2(125.06,136.48) v2(125.19,167.22) v2(125.73,138.58) v2(125.73,138) v2(125.73,137.36) v2(125.73,136.8) v2(125.75,167.22) v2(126.09,18.3) v2(126.09,17.51) v2(126.09,16.73) v2(126.12,0.43) v2(127.28,144.19) v2(127.39,18.3) v2(127.39,16.73) v2(127.47,167.22) v2(127.52,2.24) v2(127.84,163.79) v2(127.84,114.55) v2(127.84,113.94) v2(128.02,155.7) v2(128.02,155.12) v2(128.23,105.62) v2(128.24,37.9) v2(128.29,154.56) v2(128.42,163.79) v2(128.6,155.7) v2(128.6,155.12) v2(128.68,117.42) v2(128.7,115.52) v2(128.69,18.3) v2(128.69,16.73) v2(128.8,167.22) v2(128.79,24.57) v2(129.06,15.59) v2(129.19,163.85) v2(129.18,155.7) v2(129.18,155.12) v2(129.17,116.46) v2(129.31,106.13) v2(129.43,24.57) v2(129.49,40.08) v2(129.49,35.72) v2(129.54,17.95) v2(129.57,163.45) v2(129.62,140.8) v2(129.62,140.22) v2(129.62,139.63) v2(129.67,117.42) v2(129.67,115.54) v2(129.76,167.22) v2(129.77,155.7) v2(129.77,155.12) v2(129.77,154.53) v2(129.8,2.43) v2(130,163.85) v2(130.06,24.57) v2(130.19,133.64) v2(130.38,163.45) v2(130.35,155.12) v2(130.35,154.53) v2(130.46,133.09) v2(130.81,163.85) v2(130.77,133.64) v2(130.9,154.84) v2(130.91,147.69) v2(130.97,154.26) v2(131.07,133.13) v2(131.37,163.85) v2(131.36,133.64) v2(131.47,147.78) v2(131.79,163.48) v2(131.91,105.62) v2(132.04,167.22) v2(132.01,40.08) v2(132.01,35.72) v2(131.97,31.21) v2(131.97,30.63) v2(132.09,2.43) v2(132.2,163.85) v2(132.47,155.66) v2(132.55,31.21) v2(132.55,30.63) v2(132.76,163.85) v2(132.78,155.15) v2(133.06,155.66) v2(133.26,37.9) v2(133.36,155.15) v2(133.51,163.36) v2(133.64,155.66) v2(133.81,163.85) v2(133.76,105.62) v2(133.95,155.15) v2(134.23,155.66) v2(134.33,167.22) v2(134.37,163.85) v2(134.37,2.43) v2(134.53,155.15) v2(134.81,155.66) v2(134.89,167.22) v2(134.93,163.85) v2(134.95,163.23) v2(135.11,155.15) v2(135.35,102.51) v2(135.35,101.93) v2(135.35,101.34) v2(135.35,100.76) v2(135.39,155.66) v2(135.49,163.85) v2(135.7,155.15) v2(135.79,121.82) v2(136.05,163.85) v2(135.98,155.66) v2(135.98,106.2) v2(136.28,155.15) v2(136.35,163.38) v2(136.62,167.22) v2(136.61,121.82) v2(136.67,163.85) v2(136.68,155.59) v2(136.66,2.43) v2(136.91,116.86) v2(137.1,163.49) v2(137.27,155.59) v2(137.38,121.82) v2(137.44,105.62) v2(137.49,116.86) v2(137.57,163.85) v2(137.77,128.98) v2(137.77,128.22) v2(137.94,167.22) v2(137.85,155.59) v2(138.04,163.49) v2(138.14,155.12) v2(138.43,155.59) v2(138.54,163.85) v2(138.9,167.22) v2(138.94,2.43) v2(139.01,163.49) v2(139.02,155.59) v2(139.15,106) v2(139.5,163.85) v2(139.97,163.49) v2(140.26,129.13) v2(140.26,128.37) v2(140.26,127.61) v2(140.47,163.85) v2(140.72,14.59) v2(140.87,53.74) v2(141.02,129.13) v2(141.02,128.37) v2(141.02,127.61) v2(141.19,167.22) v2(141.23,2.43) v2(141.45,53.74) v2(142.04,53.74) v2(142.27,148.93) v2(142.62,53.74) v2(142.67,64.16) v2(142.71,19.14) v2(142.71,18.5) v2(142.71,17.87) v2(142.71,17.23) v2(142.9,74.19) v2(142.9,73.62) v2(142.96,65.43) v2(143.09,70.57) v2(143.1,12.47) v2(143.25,64.16) v2(143.34,19.14) v2(143.34,18.5) v2(143.34,17.87) v2(143.34,17.23) v2(143.43,1.81) v2(143.47,167.22) v2(143.55,65.43) v2(143.47,59.4) v2(143.7,19.72) v2(143.74,12.47) v2(143.92,71.65) v2(144.03,167.38) v2(143.98,68.67) v2(143.98,19.14) v2(143.98,18.5) v2(143.98,17.87) v2(143.98,17.23) v2(144.06,59.4) v2(144.11,22.46) v2(144.11,21.83) v2(144.2,29.82) v2(144.2,29.18) v2(144.2,28.55) v2(144.2,27.91) v2(144.33,19.72) v2(144.38,148.49) v2(144.42,12.47) v2(144.49,71.65) v2(144.49,2.56) v2(144.49,1.93) v2(144.56,68.67) v2(144.68,65.43) v2(144.8,171.37) v2(144.8,170.33) v2(144.8,169.08) v2(144.77,22.49) v2(144.77,21.85) v2(144.93,59.4) v2(145,148.49) v2(144.96,120.17) v2(144.96,119.58) v2(144.96,119) v2(144.96,118.41) v2(144.97,19.72) v2(145.06,12.47) v2(145.12,2.56) v2(145.12,1.93) v2(145.26,65.43) v2(145.25,0.43) v2(145.44,54.7) v2(145.44,54.11) v2(145.44,53.49) v2(145.44,52.86) v2(145.44,52.27) v2(145.44,50.7) v2(145.54,120.17) v2(145.54,119.58) v2(145.54,119) v2(145.54,118.41) v2(145.52,59.4) v2(145.55,18.59) v2(145.55,17.81) v2(145.55,17.03) v2(145.77,173.44) v2(145.76,2.56) v2(145.76,1.93) v2(146.13,120.17) v2(146.13,119.58) v2(146.13,119) v2(146.13,118.41) v2(146.24,98.96) v2(146.39,65.43) v2(146.39,2.56) v2(146.39,1.93) v2(146.58,59.4) v2(146.71,120.17) v2(146.71,119.58) v2(146.71,119) v2(146.71,118.41) v2(146.65,117.75) v2(146.84,56.6) v2(146.85,18.59) v2(146.85,17.03) v2(146.9,71.27) v2(146.98,70.33) v2(146.98,65.43) v2(147.17,59.4) v2(147.39,175.05) v2(147.42,56.6) v2(147.48,143.86) v2(147.48,141.68) v2(147.49,101.14) v2(147.49,96.78) v2(147.5,87.25) v2(147.48,71.27) v2(147.54,0.49) v2(147.6,70.32) v2(147.75,59.4) v2(148.04,71.29) v2(148.11,65.43) v2(148.14,18.59) v2(148.14,17.03) v2(148.23,56.6) v2(148.23,54.63) v2(148.23,54.05) v2(148.17,52.86) v2(148.17,52.27) v2(148.3,50.76) v2(148.36,68.54) v2(148.36,59.4) v2(148.51,15.88) v2(148.57,142.77) v2(148.73,176.9) v2(148.67,71.29) v2(148.69,65.43) v2(148.83,181.47) v2(148.8,179.19) v2(148.8,178.29) v2(148.77,118.95) v2(148.77,118.36) v2(148.77,117.78) v2(148.82,56.6) v2(148.85,2.36) v2(148.92,86) v2(148.95,68.54) v2(148.95,59.4) v2(148.97,84.22) v2(148.99,18.24) v2(149.19,74) v2(149.19,73.43) v2(149.28,71.35) v2(149.53,59.4) v2(149.5,56.6) v2(149.66,143.86) v2(149.66,141.68) v2(149.82,65.43) v2(149.86,71.35) v2(150.01,101.14) v2(150.01,96.78) v2(150.14,59.4) v2(150.09,56.6) v2(150.25,183.27) v2(150.39,135.56) v2(150.39,134.39) v2(150.39,133.22) v2(150.39,131.47) v2(150.39,130.88) v2(150.39,130.3) v2(150.45,71.35) v2(150.41,65.43) v2(150.71,183.72) v2(150.72,59.4) v2(150.65,56.6) v2(150.98,135.56) v2(150.98,134.97) v2(150.98,134.39) v2(150.98,133.81) v2(150.98,133.22) v2(150.98,132.64) v2(150.98,132.05) v2(150.98,131.47) v2(150.98,130.88) v2(150.98,130.3) v2(151.03,71.35) v2(151.13,2.43) v2(151.15,54.51) v2(151.15,53.92) v2(151.15,52.92) v2(151.15,52.33) v2(151.26,98.96) v2(151.41,65.43) v2(151.56,136.14) v2(151.56,135.56) v2(151.56,134.97) v2(151.56,134.39) v2(151.56,133.81) v2(151.56,133.22) v2(151.56,132.64) v2(151.56,132.05) v2(151.56,131.47) v2(151.56,130.88) v2(151.56,130.3) v2(151.56,129.72) v2(151.6,59.4) v2(151.81,184.94) v2(151.99,65.43) v2(152.13,196.35) v2(152.13,195.56) v2(152.13,194.06) v2(152.13,192.51) v2(152.13,191.77) v2(152.13,189.49) v2(152.13,187.2) v2(152.13,186.42) v2(152.15,136.14) v2(152.15,135.56) v2(152.15,134.97) v2(152.15,134.39) v2(152.15,133.81) v2(152.15,133.22) v2(152.15,132.64) v2(152.15,132.05) v2(152.15,131.47) v2(152.15,130.88) v2(152.15,130.3) v2(152.15,129.72) v2(152.23,198.63) v2(152.18,59.4) v2(152.36,75.14) v2(152.36,74.57) v2(152.36,74) v2(152.75,71.4) v2(152.74,54.96) v2(152.74,54.38) v2(152.74,53.8) v2(152.74,53.11) v2(152.74,52.53) v2(152.75,42.53) v2(152.75,41.16) v2(152.77,39.84) v2(152.93,87.48) v2(153.04,86.28) v2(153.07,84.78) v2(153.19,65.43) v2(153.25,170.01) v2(153.42,2.43) v2(153.7,157.57) v2(153.7,56.6) v2(153.77,65.43) v2(153.76,42.58) v2(153.9,178.76) v2(153.9,175.77) v2(153.95,64.89) v2(153.95,64.31) v2(153.95,63.72) v2(153.95,63.14) v2(154.08,69.65) v2(154.08,69.07) v2(154.08,68.48) v2(154.08,67.9) v2(154.33,58.57) v2(154.4,56.92) v2(155.03,58.57) v2(154.99,29.69) v2(154.99,29.06) v2(154.99,28.42) v2(154.99,27.79) v2(155.1,56.92) v2(155.19,114.78) v2(155.17,43.12) v2(155.22,42) v2(155.19,40.88) v2(155.4,177.26) v2(155.43,112.48) v2(155.73,58.57) v2(155.7,2.43) v2(155.79,56.92) v2(156.05,72.92) v2(156.05,72.34) v2(156.11,117.04) v2(156.19,86.72) v2(156.23,85.57) v2(156.55,199.67) v2(156.67,41.5) v2(156.9,178.76) v2(157.5,88.04) v2(157.72,43.02) v2(158.03,87.08) v2(157.99,2.43) v2(158.12,199.67) v2(158.33,41.39) v2(158.31,39.64) v2(158.55,198.57) v2(158.73,103.31) v2(158.88,87.88) v2(159.05,108.91) v2(159.11,42.31) v2(159.16,188.05) v2(159.2,103.61) v2(159.42,184.62) v2(159.51,115.97) v2(159.46,41.25) v2(159.64,108.91) v2(159.98,184.62) v2(160.28,2.43) v2(160.42,86.14) v2(160.4,41.43) v2(160.55,184.62) v2(160.84,198.57) v2(161,187.48) v2(161.14,42.07) v2(161.61,42.69) v2(161.79,87.51) v2(162.31,85.55) v2(162.52,42.03) v2(162.56,2.43) v2(162.78,163.09) v2(162.96,88.83) v2(163.13,198.57) v2(163.66,89.82) v2(164.02,198.57) v2(164.24,37.9) v2(164.36,42.86) v2(164.53,89.48) v2(164.77,1.83) v2(165.15,84.63) v2(165.41,198.57) v2(165.49,40.08) v2(165.49,35.72) v2(165.73,30.6) v2(166.01,103.59) v2(166.04,85.62) v2(166.03,83.09) v2(166.34,100.69) v2(166.37,30.6) v2(166.52,103.91) v2(166.58,0.43) v2(166.95,86.51) v2(167,30.6) v2(167.06,198.57) v2(167.3,182.32) v2(167.3,179.27) v2(167.43,84.49) v2(167.43,81.77) v2(167.64,30.6) v2(167.7,198.57) v2(168.04,73.39) v2(168.01,40.08) v2(168.01,35.72) v2(168.09,77.07) v2(168.27,82.7) v2(168.56,46.68) v2(168.9,76.69) v2(168.86,55.31) v2(168.86,0.43) v2(169.23,69.94) v2(169.29,83.67) v2(169.33,73.39) v2(169.26,37.9) v2(169.45,167.58) v2(169.56,78.47) v2(169.74,66.89) v2(169.82,77.58) v2(169.91,47.72) v2(169.88,46.68) v2(169.98,198.57) v2(170.04,52.08) v2(170.1,80.99) v2(170.12,71.03) v2(170.11,54.75) v2(170.27,190.21) v2(170.32,68.97) v2(170.5,60.43) v2(170.48,49.78) v2(170.56,73.4) v2(170.63,64.37) v2(170.59,62.39) v2(170.81,180.8) v2(170.88,78.5) v2(170.96,68.97) v2(171.09,189.89) v2(171.06,81.93) v2(171.15,0.43) v2(171.16,56.17) v2(171.21,52.08) v2(171.19,46.71) v2(171.31,58.38) v2(171.35,54.76) v2(171.39,71.03) v2(171.62,69) v2(171.57,53.66) v2(171.75,60.45) v2(171.78,47.72) v2(171.92,64.35) v2(171.95,62.47) v2(172,82.87) v2(172.05,133.98) v2(172.24,189.63) v2(172.18,164.55) v2(172.27,198.57) v2(172.38,52.08) v2(172.5,56.09) v2(172.61,58.35) v2(172.92,68.97) v2(172.92,53.63) v2(173.02,60.43) v2(173.16,198.57) v2(173.2,64.34) v2(173.19,62.46) v2(173.35,190.4) v2(173.43,0.43) v2(174.08,160.81) v2(174.33,182.32) v2(174.33,179.27) v2(174.42,156.77) v2(174.46,163.79) v2(174.56,198.57) v2(174.59,160.36) v2(175.1,167.85) v2(175.1,160.04) v2(175.16,153.57) v2(175.31,190.02) v2(175.28,163.22) v2(175.34,103) v2(175.73,190.46) v2(175.72,0.43) v2(176.21,198.57) v2(176.59,105.18) v2(176.59,100.82) v2(176.84,198.57) v2(176.94,190.46) v2(176.94,186.9) v2(176.94,185.06) v2(177.06,153.5) v2(178.01,0.43) v2(178.21,190.46) v2(178.91,144.1) v2(179.13,198.57) v2(179.11,105.18) v2(179.11,100.82) v2(179.48,190.59) v2(180.12,172.83) v2(180.12,170.49) v2(180.12,168.14) v2(180.12,165.8) v2(180.29,0.43) v2(180.36,103) v2(180.55,18.4) v2(181.41,198.57) v2(181.8,20.58) v2(181.8,16.22) v2(182.3,198.57) v2(182.29,133.5) v2(182.57,172.83) v2(182.57,170.49) v2(182.57,168.14) v2(182.57,165.8) v2(182.58,0.43) v2(183.7,198.57) v2(184.32,20.58) v2(184.32,16.22) v2(184.86,0.43) v2(185.02,172.83) v2(185.02,170.49) v2(185.02,168.14) v2(185.02,165.8) v2(185.57,18.4) v2(187.15,0.43) v2(187.46,172.83) v2(187.46,170.49) v2(187.46,168.14) v2(187.46,165.8) v2(187.99,199.67) v2(189.44,0.43) v2(190.09,6.5) v2(190.34,179.98) v2(190.92,179.98) v2(191.15,4.67) v2(191.15,198.67) v2(191.72,0.43) v2(192.33,198.67) v2(193.12,132.67) v2(193.12,131.91) v2(193.12,130.9) v2(193.12,130.24) v2(193.12,129.65) v2(193.25,4.67) v2(194.01,0.43) v2(194.34,168.36) v2(194.31,6.5) v2(194.43,154.18) v2(194.43,153.52) v2(194.68,154.81) v2(195.01,154.18) v2(195.01,153.52) v2(195.29,156.61) v2(195.29,156.03) v2(195.29,155.45) v2(195.27,154.81) v2(195.6,154.18) v2(195.6,153.52) v2(195.88,156.61) v2(195.88,156.03) v2(195.88,155.45) v2(195.85,154.81) v2(196.18,154.18) v2(196.18,153.52) v2(196.29,0.52) v2(196.43,154.81) v2(196.46,156.61) v2(196.46,156.03) v2(196.46,155.45) v2(196.67,193.08) v2(196.67,190.79) v2(196.67,188.51) v2(196.77,154.18) v2(196.77,153.52) v2(197.13,156.09) v2(197.13,155.51) v2(197.11,154.82) v2(197.61,2.38) v2(197.72,156.09) v2(197.72,155.51) v2(197.69,154.82) v2(198.3,156.09) v2(198.3,155.51) v2(199.58,136.19) v2(199.6,135.62) v2(199.6,135.06) v2(199.6,134.44) v2(199.59,133.86) v2(199.59,133.27) v2(199.9,2.43) v2(199.97,132.05) v2(199.97,131.47) v2(199.97,130.88) v2(200.14,133.49) v2(200.14,132.9) v2(200.25,134.08) v2(200.48,132.33) v2(200.48,131.75) v2(200.48,131.16) v2(200.7,133.47) v2(200.7,132.89) v2(200.9,134.66) v2(200.89,134.06) v2(201.28,133.47) v2(201.28,132.89) v2(201.47,134.06) v2(201.87,133.47) v2(201.87,132.89) v2(202.19,2.43) v2(202.45,133.47) v2(202.45,132.89) v2(204.47,2.43) v2(205.94,141.07) v2(205.94,138.89) v2(205.96,139.98) v2(206.44,39.02) v2(206.59,44.23) v2(206.65,80.95) v2(206.7,68.46) v2(206.82,166.09) v2(206.78,25.55) v2(206.76,2.43) v2(206.88,32.29) v2(207.03,141.06) v2(207.03,139.98) v2(207.03,138.9) v2(207.03,65.22) v2(207.14,89.49) v2(207.16,46.76) v2(207.47,74.31) v2(207.5,41.78) v2(207.45,36.4) v2(207.62,50.05) v2(207.69,54.27) v2(207.82,80.95) v2(207.86,52.37) v2(207.92,34.31) v2(207.98,93.32) v2(207.99,60.85) v2(208.02,29.4) v2(208.13,141.07) v2(208.11,139.98) v2(208.13,138.89) v2(208.09,68.46) v2(208.12,67.02) v2(208.15,87.65) v2(208.16,32.3) v2(208.31,89.49) v2(208.3,65.22) v2(208.43,46.76) v2(208.43,39.02) v2(208.46,91.53) v2(208.64,74.31) v2(208.55,72.83) v2(208.56,27.51) v2(208.68,166.11) v2(208.72,36.4) v2(208.77,41.78) v2(208.96,54.27) v2(209.04,2.43) v2(209.09,153) v2(209.1,86.15) v2(209.13,52.37) v2(209.16,60.85) v2(209.19,34.31) v2(209.29,29.4) v2(209.43,32.3) v2(209.55,78.56) v2(209.46,58.57) v2(209.52,50.05) v2(209.59,44.23) v2(209.7,68.46) v2(209.7,67.02) v2(209.7,46.76) v2(209.7,39.02) v2(209.82,93.32) v2(209.81,74.31) v2(209.76,72.83) v2(210.02,82.75) v2(210.04,41.78) v2(210,36.4) v2(210.15,154.83) v2(210.15,151.17) v2(210.33,165.76) v2(210.33,91.53) v2(210.36,83.92) v2(210.56,29.4) v2(210.7,32.3) v2(210.77,131.42) v2(210.77,129.13) v2(210.82,52.37) v2(210.79,50.05) v2(210.87,126.85) v2(210.86,44.23) v2(210.97,39.02) v2(211.03,24.11) v2(211.34,167.1) v2(211.27,133.65) v2(211.33,2.43) v2(211.38,78.55) v2(211.92,124.82) v2(212.25,154.83) v2(212.25,151.17) v2(212.81,135.33) v2(213.07,96.7) v2(213.31,153) v2(213.62,2.43) v2(213.65,96.7) v2(213.84,123.58) v2(214,186.71) v2(214.29,96.7) v2(214.53,194.24) v2(214.53,193.5) v2(214.53,191.96) v2(214.53,191.22) v2(214.53,189.67) v2(214.53,188.93) v2(214.53,187.38) v2(214.86,136.35) v2(214.87,96.7) v2(215.1,120.22) v2(215.06,119.66) v2(215.27,179.75) v2(215.27,177.46) v2(215.27,175.18) v2(215.27,172.89) v2(215.27,170.61) v2(215.27,168.32) v2(215.27,166.03) v2(215.27,163.75) v2(215.27,161.46) v2(215.27,159.18) v2(215.27,156.89) v2(215.27,150.03) v2(215.27,147.75) v2(215.27,145.46) v2(215.27,143.17) v2(215.27,140.89) v2(215.27,138.6) v2(215.46,182.03) v2(215.57,198.57) v2(215.73,120.22) v2(215.75,119.66) v2(215.9,2.43) v2(216.06,192.56) v2(216.06,190.33) v2(216.12,187.54) v2(216.12,123.37) v2(217.55,182.96) v2(217.67,189.81) v2(217.67,187.53) v2(217.67,185.24) v2(217.79,116.88) v2(217.9,192.09) v2(218.16,2.07) v2(218.4,123.37) v2(218.42,117.5) v2(218.42,116.25) v2(219.04,116.88) v2(219.76,0.43) v2(220.09,192.74) v2(220.06,107.76) v2(220.43,25.88) v2(220.53,77.57) v2(220.65,107.76) v2(220.59,84.11) v2(220.57,61.41) v2(220.62,52.37) v2(220.69,123.37) v2(220.68,80.24) v2(220.66,44.23) v2(220.67,37.88) v2(220.78,30.15) v2(220.92,87.16) v2(220.92,40.49) v2(220.88,35.74) v2(221.03,91.44) v2(221.01,27.63) v2(221.23,107.76) v2(221.21,70.08) v2(221.25,59.88) v2(221.26,41.92) v2(221.39,50.05) v2(221.74,61.41) v2(221.82,107.76) v2(221.83,89.55) v2(221.9,80.24) v2(221.9,37.89) v2(221.88,11.8) v2(222.02,52.37) v2(222,32.54) v2(222.04,0.43) v2(222.15,68.46) v2(222.39,91.43) v2(222.42,59.88) v2(222.43,29.6) v2(222.45,84.1) v2(222.59,46.76) v2(222.84,49.1) v2(222.83,40.49) v2(222.81,35.76) v2(222.92,27.63) v2(222.98,123.37) v2(223.05,107.76) v2(223.07,80.24) v2(223.19,78.77) v2(223.16,37.87) v2(223.26,87.16) v2(223.32,68.46) v2(223.29,52.37) v2(223.27,32.54) v2(223.49,82.15) v2(223.54,70.08) v2(223.49,61.41) v2(223.55,2.15) v2(223.59,59.88) v2(223.65,91.44) v2(223.72,84.12) v2(223.8,89.55) v2(223.8,85.49) v2(224.08,65.22) v2(224.11,49.1) v2(224.15,44.25) v2(224.23,80.24) v2(224.43,87.16) v2(224.44,37.89) v2(224.49,68.46) v2(224.68,122.02) v2(224.66,82.15) v2(224.66,61.41) v2(224.89,84.12) v2(224.87,76.6) v2(224.9,41.91) v2(225.04,78.77) v2(225.01,35.71) v2(225.09,85.49) v2(225.25,61.41) v2(225.26,123.37) v2(225.4,80.24) v2(225.82,2.43) v2(227.55,123.37) v2(228.1,2.43) v2(229.64,10.44) v2(229.83,123.37) v2(229.82,85.7) v2(230.2,10.44) v2(230.39,2.43) v2(231.62,25.9) v2(231.7,122.07) v2(231.72,10.37) v2(232.12,123.37) v2(232.29,122.07) v2(232.3,19.86) v2(232.28,10.41) v2(232.6,20.39) v2(232.68,2.43) v2(232.79,25.9) v2(232.87,122.07) v2(232.89,41.48) v2(232.88,19.86) v2(233.1,65.09) v2(233.13,50.07) v2(233.19,20.39) v2(233.34,67.42) v2(233.33,28.05) v2(233.46,122.07) v2(233.5,57.08) v2(233.47,19.86) v2(233.6,52) v2(233.71,50.06) v2(233.77,20.39) v2(234.04,122.07) v2(233.96,69.26) v2(234.13,75.26) v2(234.06,41.48) v2(234.19,30.71) v2(234.29,91.68) v2(234.26,65.09) v2(234.28,47.81) v2(234.41,123.37) v2(234.41,34.76) v2(234.47,77.15) v2(234.52,44.28) v2(234.62,122.07) v2(234.65,67.43) v2(234.63,32.12) v2(234.63,20.13) v2(234.79,79.34) v2(234.81,38) v2(234.98,50.06) v2(234.96,2.43) v2(235.1,82.26) v2(235.13,69.26) v2(235.13,52) v2(235.1,28.12) v2(235.21,122.07) v2(235.15,90.32) v2(235.45,86.75) v2(235.37,33.57) v2(235.38,30.63) v2(235.64,77.15) v2(235.56,73.15) v2(235.65,55.01) v2(235.79,122.07) v2(235.82,67.43) v2(235.79,44.29) v2(235.88,75.26) v2(235.92,39.48) v2(235.88,13.87) v2(235.96,79.34) v2(235.98,37.99) v2(236.1,46.22) v2(236.24,43.24) v2(236.27,82.26) v2(236.3,69.26) v2(236.38,122.07) v2(236.45,85.03) v2(236.51,47.81) v2(236.6,65.09) v2(236.58,34.75) v2(236.6,30.58) v2(236.69,123.37) v2(236.77,89.24) v2(236.8,77.15) v2(236.81,55.01) v2(236.89,41.43) v2(236.96,122.07) v2(236.99,67.43) v2(237.13,79.34) v2(237.13,33.55) v2(237.2,26.09) v2(237.25,2.43) v2(237.27,28.55) v2(237.32,20.47) v2(237.41,43.24) v2(237.54,122.07) v2(237.72,79.34) v2(237.67,47.81) v2(237.67,39.48) v2(238.13,122.07) v2(238.12,88.09) v2(238.05,41.43) v2(238.15,67.43) v2(238.28,46.22) v2(238.42,26.09) v2(238.58,43.24) v2(238.71,122.07) v2(238.91,97.7) v2(238.98,123.37) v2(239.3,122.07) v2(239.34,1.51) v2(239.5,97.7) v2(239.48,21.85) v2(241.19,79.06) v2(241.26,123.37) v2(241.36,0.43) v2(242.14,43.64) v2(242.16,90.57) v2(242.51,87.88) v2(242.51,86.45) v2(243.37,68.4) v2(243.53,79.06) v2(243.55,123.37) v2(243.64,0.43) v2(244.98,10.36) v2(244.98,8.38) v2(245.84,123.37) v2(245.93,0.43) v2(245.97,9.37) v2(246.96,10.36) v2(246.96,8.38) v2(247.43,77.05) v2(247.42,44.35) v2(247.55,67.25) v2(247.48,60.04) v2(247.56,93.28) v2(247.69,37.16) v2(247.72,32.35) v2(247.8,74.87) v2(247.8,53.39) v2(247.86,70.78) v2(248.12,123.37) v2(248.11,79.93) v2(248.11,73.33) v2(248.09,69.32) v2(248.24,41.61) v2(248.21,30.18) v2(248.21,0.43) v2(248.51,41.02) v2(248.6,77.05) v2(248.64,44.35) v2(248.72,93.28) v2(248.71,64.8) v2(248.69,61.56) v2(248.82,67.25) v2(248.95,37.13) v2(248.93,32.36) v2(248.92,27.96) v2(248.97,74.87) v2(249.13,53.39) v2(249.28,79.93) v2(249.26,69.32) v2(249.38,92.47) v2(249.53,45.57) v2(249.77,77.05) v2(249.76,62) v2(249.94,78.38) v2(249.88,30.57) v2(250.14,74.87) v2(250.09,67.25) v2(250.28,35.14) v2(250.41,123.37) v2(250.4,73.35) v2(250.43,69.32) v2(250.48,86.51) v2(250.5,0.43) v2(250.58,42.06) v2(250.72,72.22) v2(250.72,66.19) v2(250.72,44.09) v2(250.7,32.89) v2(250.77,90.2) v2(250.84,38.12) v2(250.84,36.98) v2(250.86,40.92) v2(251.12,30.5) v2(251.19,68.66) v2(251.18,56.76) v2(251.25,87.44) v2(251.28,83.56) v2(251.31,74.87) v2(251.31,45.62) v2(251.39,58.36) v2(251.51,62) v2(251.62,108.67) v2(251.64,81.99) v2(251.58,27.55) v2(251.79,59.54) v2(251.94,90.2) v2(251.9,85.39) v2(251.89,80.43) v2(251.87,78.42) v2(251.92,55.05) v2(251.88,44.09) v2(251.91,42.06) v2(251.94,32.89) v2(251.97,53.33) v2(252.02,38.12) v2(252.01,36.98) v2(252.03,35.08) v2(252.2,108.67) v2(252.69,123.37) v2(252.79,0.43) v2(254.37,122.26) v2(254.98,123.37) v2(254.96,122.26) v2(255.07,0.43) v2(255.54,122.26) v2(255.7,7.44) v2(256.12,122.26) v2(257.27,123.37) v2(257.36,0.43) v2(259.13,122.26) v2(259.55,123.37) v2(259.64,0.43) v2(259.72,122.26) v2(260.3,122.26) v2(260.89,122.26) v2(261.84,123.37) v2(261.93,0.43) v2(262.91,8.37) v2(263.5,9.34) v2(264.12,123.37) v2(264.1,10.31) v2(264.22,0.43) v2(264.44,72.02) v2(264.44,71.46) v2(266.41,123.37) v2(266.5,0.43) v2(267.24,113.75) v2(267.45,26.55) v2(267.87,113.75) v2(268.08,26.55) v2(268.51,113.75) v2(268.49,22.73) v2(268.7,123.37) v2(268.72,26.55) v2(268.79,0.43) v2(268.88,40.41) v2(269.14,113.75) v2(269.13,22.73) v2(269.35,26.55) v2(269.52,122.07) v2(269.76,22.73) v2(269.9,40.41) v2(270.16,122.07) v2(270.4,22.73) v2(270.69,6.5) v2(270.79,122.07) v2(270.98,123.37) v2(271.07,0.43) v2(271.43,122.07) v2(271.75,8.33) v2(271.75,4.67) v2(272.45,16.84) v2(272.45,16.2) v2(272.45,15.57) v2(272.45,14.98) v2(273.01,16.84) v2(273.01,16.2) v2(273.01,15.57) v2(273.01,14.98) v2(273.27,123.37) v2(273.36,0.43) v2(273.62,16.84) v2(273.62,16.2) v2(273.62,15.57) v2(273.62,14.98) v2(273.85,8.33) v2(273.85,4.67) v2(274.14,17.22) v2(274.14,16.58) v2(274.14,15.95) v2(274.91,6.5) v2(275.55,123.37) v2(275.65,0.43) v2(276.33,111.2) v2(276.33,110.61) v2(276.33,110.03) v2(276.33,109.45) v2(276.91,111.2) v2(276.91,110.61) v2(276.91,110.03) v2(276.91,109.45) v2(276.95,35.14) v2(277.52,101.05) v2(277.84,123.37) v2(277.93,0.43) v2(278.1,101.12) v2(278.1,100.53) v2(278.69,101.12) v2(278.69,100.53) v2(278.69,99.95) v2(278.94,48.93) v2(279.27,101.12) v2(279.27,100.53) v2(279.27,99.95) v2(279.27,99.36) v2(279.43,53.93) v2(279.43,50.83) v2(279.43,49.25) v2(279.86,100.53) v2(279.86,99.95) v2(279.86,99.36) v2(280.13,123.37) v2(280.22,0.43) v2(280.92,9.68) v2(280.92,7.69) v2(281.58,80.27) v2(281.61,79.13) v2(281.69,34.06) v2(281.91,8.68) v2(282.41,123.37) v2(282.5,0.43) v2(282.9,9.68) v2(282.9,7.69) v2(284.7,123.37) v2(284.82,38.8) v2(284.79,0.43) v2(286.11,112.6) v2(286.11,112.01) v2(286.11,111.43) v2(286.28,110.75) v2(286.41,113.12) v2(286.69,112.6) v2(286.69,112.01) v2(286.69,111.43) v2(286.92,110.83) v2(286.98,123.37) v2(287.08,0.43) v2(288.09,106.7) v2(289.15,108.53) v2(289.15,104.87) v2(289.27,123.37) v2(289.36,0.43) v2(291.25,108.53) v2(291.25,104.87) v2(291.27,99.77) v2(291.27,99.18) v2(291.27,98.6) v2(291.56,123.37) v2(291.65,0.43) v2(291.86,99.77) v2(291.86,99.18) v2(291.86,98.6) v2(292.31,106.7) v2(293.71,91.21) v2(293.73,38.66) v2(293.8,122.92) v2(293.93,0.43) v2(293.97,90.57) v2(294.22,89.94) v2(294.27,120.68) v2(294.27,111.54) v2(294.27,109.25) v2(294.27,102.39) v2(294.27,100.11) v2(294.32,97.82) v2(294.39,38.66) v2(294.48,95.54) v2(294.54,89.24) v2(294.76,93.27) v2(295.15,91.02) v2(295.65,88.79) v2(296.22,0.43) v2(296.26,86.58) v2(296.97,84.41) v2(297.32,33.44) v2(297.8,82.28) v2(298.51,0.43) v2(298.72,80.19) v2(299.75,78.15) v2(300.79,0.43) v2(300.88,76.16) v2(302.11,74.23) v2(303.08,0.43) v2(303.43,72.37) v2(304.84,70.57) v2(305.36,0.43) v2(306.15,65.33) v2(306.34,68.84) v2(307.65,0.43) v2(308.25,65.33) v2(309.31,63.5) v2(309.58,65.62) v2(309.94,0.43) v2(311.32,64.14) v2(312.22,0.43) v2(312.34,39.19) v2(313.13,62.74) v2(313.97,34.59) v2(314.51,0.43) v2(315,61.43) v2(316.79,0.43) v2(316.94,60.22) v2(317.08,23.43) v2(317.72,23.43) v2(318.35,23.43) v2(318.94,59.1) v2(318.99,23.43) v2(319.08,0.43) v2(320.62,41.83) v2(320.62,41.07) v2(320.62,40.31) v2(320.62,39.67) v2(320.62,39.04) v2(320.99,58.09) v2(321.39,41.83) v2(321.39,41.07) v2(321.39,40.31) v2(321.39,39.67) v2(321.39,39.04) v2(321.37,0.43) v2(322.15,41.83) v2(322.15,41.07) v2(322.15,40.31) v2(322.15,39.67) v2(322.15,39.04) v2(322.38,35.89) v2(322.91,41.83) v2(322.91,41.07) v2(322.91,40.31) v2(322.91,39.67) v2(322.91,39.04) v2(323.01,35.89) v2(323.08,57.17) v2(323.65,35.89) v2(323.67,41.07) v2(323.67,40.31) v2(323.67,39.67) v2(323.67,39.04) v2(323.65,0.43) v2(325.22,56.36) v2(325.94,0.43) v2(327.18,50.16) v2(327.39,55.66) v2(327.76,50.16) v2(328.22,0.43) v2(328.35,50.16) v2(328.41,38.33) v2(329.03,38.95) v2(329.03,38.33) v2(329.03,37.7) v2(329.6,55.07) v2(329.65,38.33) v2(330.51,0.43) v2(330.96,50.18) v2(331.14,31.13) v2(331.14,30.49) v2(331.19,31.76) v2(331.19,29.86) v2(331.55,50.18) v2(332.13,50.18) v2(332.71,50.18) v2(332.8,0.43) v2(333.5,35.43) v2(333.5,34.85) v2(335.08,0.43) v2(336.36,53.95) v2(337.37,0.43) v2(338.64,53.8) v2(339.65,0.43) v2(340.51,14.73) v2(340.93,53.77) v2(341.79,1.1) v2(343.21,53.85) v2(343.25,2.56) v2(344.77,3.43) v2(345.49,54.04) v2(345.5,32.73) v2(345.66,22.25) v2(346.36,34.42) v2(347.06,3.43) v2(347.76,54.34) v2(347.85,38.02) v2(347.94,46.25) v2(347.88,33.71) v2(347.98,22.83) v2(348,21.69) v2(348.51,48.99) v2(348.47,47.65) v2(348.64,49.56) v2(348.64,22.86) v2(348.71,21.68) v2(349.34,3.43) v2(350.01,54.75) v2(350.75,13.94) v2(351.25,3.15) v2(351.33,13.94) v2(351.92,13.94) v2(352.23,55.28) v2(352.5,13.94) v2(352.71,1.71) v2(352.98,25.19) v2(353.01,24.61) v2(354.34,0.43) v2(354.43,55.91) v2(354.84,9.68) v2(355.45,9.7) v2(355.73,0.43) v2(356.59,56.66) v2(358.02,0.43) v2(358.71,57.5) v2(359.64,7.8) v2(359.82,53.24) v2(359.82,52.65) v2(359.89,52.04) v2(359.89,51.46) v2(360.32,39.96) v2(360.31,0.43) v2(360.88,58.23) v2(360.96,13.74) v2(361.21,4.83) v2(361.96,56.21) v2(362.59,0.43) v2(364.25,56.07) v2(364.74,7.62) v2(364.88,0.43) v2(365.22,25.87) v2(365.22,25.23) v2(365.38,7.62) v2(365.75,2.55) v2(366.53,56.07) v2(367.18,15.87) v2(367.67,3.79) v2(367.86,15.07) v2(367.91,13.09) v2(368.49,13.08) v2(368.6,54.07) v2(368.82,56.07) v2(369.24,54.07) v2(369.34,21.99) v2(369.4,38.31) v2(369.66,23.33) v2(370.93,56.95) v2(371.37,43.33) v2(371.75,24.66) v2(372.54,58.57) v2(374.42,44.47) v2(374.61,43.2) v2(374.83,58.57) v2(376.65,16.02) v2(377.12,58.57) v2(378.97,16.03) v2(379.4,58.57) v2(379.5,17.8) v2(380.99,17.39) v2(381.41,31.77) v2(381.69,58.57) v2(381.79,34.19) v2(383.97,58.57) v2(384.01,36.15) v2(384.01,16.66) v2(384.65,32.73) v2(384.97,52.47) v2(385.47,56.6) v2(386.24,34.88) v2(386.26,58.57) v2(386.3,50.12) v2(386.3,14.95) v2(386.55,54.82) v2(386.55,30) v2(387.06,51.59) v2(387.82,31.9) v2(387.89,33.23) v2(388.1,34.97) v2(388.55,58.57) v2(388.52,50.03) v2(388.52,30.03) v2(388.46,14.95) v2(389.09,55.1) v2(389.37,9) v2(390.15,56.93) v2(390.15,53.27) v2(390.24,12.79) v2(391.25,9.1) v2(391.61,3.15) v2(391.76,33.17) v2(392.01,11.26) v2(392.25,56.93) v2(392.25,53.27) v2(393.03,31.71) v2(393.12,58.51) v2(393.09,6.5) v2(393.22,15.27) v2(393.31,55.1) v2(393.54,12.79) v2(393.72,29.73) v2(393.75,49.73) v2(393.86,0.43) v2(394.05,1.8) v2(394.15,8.33) v2(394.15,4.67) v2(394.27,54.25) v2(394.27,51.96) v2(394.27,34.24) v2(394.27,31.95) v2(395.27,11.95) v2(396.02,1.86) v2(396.14,0.43) v2(396.25,8.33) v2(396.25,4.67) v2(397.31,6.5) v2(397.96,1.82) v3(14.89,12.28) v3(16.35,10.25) v3(65.75,33.61) v3(79.28,16.15) v3(81.12,19.64) v3(99.79,45.36) v3(106.26,36.54) v3(106.52,152.3) v3(107.66,27.26) v3(110.9,131.02) v3(111.6,52.41) v3(114.46,78.19) v3(115.03,78.26) v3(119.92,78.26) v3(125.06,80.48) v3(137.38,127.09) v3(140.68,164.55) v3(145.95,117.82) v3(170.91,127.59) v3(181.13,173.44) v3(194.24,157.17) v3(199.55,132.48) v3(212.06,120.93) v3(224.95,109.05) v3(250.68,109.93) v3(276,15.2) v3(282.1,99.65) v3(288.45,86.51) v3(292.13,86.76) v3(340.03,15.33) v3(347.25,20.09) v3(370.11,15.58)

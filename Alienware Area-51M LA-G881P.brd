# Allegro board Alienware Area-51M LA-G881P.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
INTRUDER#: length 12.4
  TOP w0.089: v2(261.37,61.98) 261.16,62.19 260.69,62.19 260.2,62.68 ; v2(270.7,61.4) 270.76,61.46 UH1.BB44
  TOP w0.127: RH531.1 259.99,62.89 260.2,62.68
  IN3 w0.127: v2(261.37,61.98) 262.08,61.28 266.44,61.28 266.48,61.24 270.53,61.24 v2(270.7,61.4)
ISEN1_GT: length 102.6
  TOP w0.203: PUZ01.9 65.96,27.89 65.9,27.82 v2(65.9,27.79)
  TOP w0.254: PCZ20.2 66.51,23.2 v1(65.94,22.63) v2(65.37,22.63)
  IN1 w0.254: v2(65.37,22.63) 65.49,22.5 67.59,22.5 68.36,21.73 72.89,21.73 73.74,22.58 76.7,22.58 81.86,17.43 87.49,17.43 87.92,17.01 92.06,17.01 93.05,18 107.19,18 109.23,15.96 110.64,15.96 112.89,13.71 118.03,13.71 v2(121.04,16.72)
  IN3 w0.254: v2(65.9,27.79) 65.86,27.75 65.86,22.88 65.61,22.63 v2(65.37,22.63)
  IN4 w0.254: v2(141.17,17.66) 141.17,18.96 140.43,19.71 139.06,19.71 136.21,22.57 127.25,22.57 125.92,23.9 122.2,23.9 121.12,22.82 121.12,22.12 120.04,21.04 120.04,17.72 v2(121.04,16.72)
  BOTTOM w0.254: PRG12.2 PRG09.2 v2(141.17,17.66)
ISEN1_VCORE: length 67.1
  TOP w0.112: v2(111.77,25.08) v1(110.54,25.08)
  TOP w0.203: PCZ19.1 69.85,33.6 69.24,32.99 v2(69.23,32.99) 69.08,32.84 68.81,32.84 68.58,32.62 PUZ01.21
  TOP w0.254: v2(110.62,33.14) 111.07,32.69 PRI19.2 112.33,33.43 PRI22.2 111.84,34.04 PRI23.2 ; PRI38.2 111.67,28.45 PRI34.2 ; PRI38.2 PRI37.2 ; PRI38.2 v2(111.06,29.16)
  IN3 w0.254: v2(111.06,29.16) 111.77,28.46 v2(111.77,25.08)
  IN4 w0.203: v2(111.77,25.08) 111.7,25.08 111.62,25.01 107.43,25.01 106.99,24.57 106.99,23.82 106.34,23.16 103.94,23.16 102.11,24.99 95.63,24.99 94.42,23.79 89.27,23.79 86.8,26.25 82.81,26.25 81.58,27.48 80.73,27.48 77.28,30.94 73.01,30.94 72.63,31.32 71.35,31.32 69.67,32.99 v2(69.23,32.99)
  IN4 w0.254: v2(111.06,29.16) 111.51,29.61 111.51,32.26 v2(110.62,33.14)
ISEN1N_CHG: length 18.1
  TOP w0.254: v2(205.64,146.58) 205.64,146.49 205.75,146.38 PR776.2 ; v2(204.04,145.57) 203.94,145.67 203.76,145.67 203.48,145.39 203.48,144.38 203.06,143.96 200.14,143.96 199.41,143.23 199.41,141.88 v1(198.97,141.44) 198.53,140.99 198.53,139.29 197.81,138.57 196.4,138.57 196.01,138.19 PR765.3
  IN4 w0.254: v2(204.04,145.57) 204.14,145.67 204.96,145.67 205.54,146.25 205.54,146.48 v2(205.64,146.58)
ISEN1P_CHG: length 17.4
  TOP w0.254: PR765.2 196.01,139.2 196.27,138.95 197.65,138.95 198.14,139.44 198.14,141.19 199.03,142.08 v1(199.03,143.39) 199.98,144.34 202.9,144.34 203.1,144.54 203.1,145.55 203.6,146.05 203.94,146.05 v2(204.04,146.15) ; PR742.2 204.93,146.38 205.05,146.51 v2(205.05,146.58)
  IN4 w0.254: v2(205.05,146.58) 205.05,146.3 204.8,146.05 204.14,146.05 v2(204.04,146.15)
ISEN2_GT: length 118.4
  TOP w0.112: PCZ17.2 v1(67.42,22.46)
  TOP w0.203: v2(66.48,27.79) 66.48,27.8 66.36,27.92 PUZ01.10
  TOP w0.254: v2(68.1,23.73) 67.98,23.73 67.82,23.57 PCZ17.2
  IN3 w0.254: v2(68.1,23.73) 68.1,23.9 66.45,25.55 66.45,27.75 v2(66.48,27.79)
  IN4 w0.254: v2(68.1,23.73) 68.1,22.02 68.45,21.66 71.8,21.66 71.93,21.79 81.03,21.79 81.65,21.17 84.75,21.17 84.75,21.17 90.98,21.17 91.65,20.5 99.2,20.5 100.93,18.77 108.01,18.77 109.08,19.85 109.08,20.86 109.81,21.59 111.3,21.59 113.99,24.28 126.08,24.28 127.41,22.95 136.36,22.95 139.22,20.09 141.29,20.09 142.64,21.44 142.64,24.4 143.41,25.17 157.89,25.17 158.46,24.6 158.46,20.66 159.42,19.7 v2(161.38,19.7)
  BOTTOM w0.254: v2(161.38,19.7) 160.97,19.29 PRG23.2 PRG21.2
ISEN2_VCORE: length 78.6
  TOP w0.203: v2(69.17,33.58) 69.07,33.58 68.51,33.02 PUZ01.22
  TOP w0.254: v2(116.58,61.73) 116.75,61.55 117.45,61.55 PRI60.2 117.65,61.79 118.2,62.33 118.2,63.04 118.16,63.08 118.16,63.12 117.64,63.64 PRI62.2 118.16,64.18 118.16,65.95 117.65,66.46 PRI63.2 117.5,66.58 v1(117.5,67.46) 117.5,70.58 117.72,70.8 PRI75.2 PRI77.2 PRI78.2
  IN1 w0.254: v2(116.58,61.73) 112.69,57.84 106.01,57.84 104.93,56.77 103.38,56.77 93.24,46.63 93.24,41.27 92.32,40.35 90.74,40.35 89.4,39.01 82.83,39.01 82.51,39.01 81.6,38.1 81.22,38.1 80.22,37.1 75.46,37.1 75.45,37.09 71.25,37.09 v2(69.87,35.71)
  BOTTOM w0.254: v2(69.17,33.58) PCZ18.1 70.12,35.47 v2(69.87,35.71)
ISEN3_VCORE: length 82.6
  TOP w0.112: v2(110.58,38.31) v1(110.58,37.75)
  TOP w0.203: PCZ16.1 69.66,34.03 68.98,34.03 68.68,33.74 68.68,33.68 68.42,33.42 PUZ01.23
  TOP w0.254: PRI103.2 PRI102.2 PRI100.2 110.79,38.53 v2(110.58,38.31) ; PCZ16.1 70.12,34.55 v2(70.7,35.13) ; v2(116.9,57.78) 117.59,57.78 PRI115.2 117.61,58.48 PRI117.2 PRI118.2
  IN1 w0.254: v2(116.9,57.78) 115.28,56.16 114.97,56.16 114.58,56.16 113.25,54.82 113.25,47.01 111.09,44.85 111.09,41.09 110.9,40.9 110.9,38.63 v2(110.58,38.31) 110.58,35.71 111.72,34.57 111.72,33.42 109.82,31.52 100.23,31.52 99.02,32.73 94.62,32.73 93.02,31.12 81.64,31.12 76.48,36.28 71.85,36.28 v2(70.7,35.13)
ISH_GP1: length 68
  TOP w0.089: v2(275.92,61.88) 276.06,62.02 UH1.BD34
  TOP w0.112: v2(292.83,23.65) 292.6,23.88 UE5.1
  BOTTOM w0.112: v1(301.88,22.19) 299.76,22.19 298.39,23.55 298.39,24.24 297.85,24.79 295.03,24.79 294.53,24.29 294.53,24.07 294.07,23.61 293.73,23.61 293.7,23.65 v2(292.83,23.65) 291.92,23.65 288.98,26.59 288.39,26.59 283.19,31.79 281.5,31.79 279.36,33.93 279.36,35.59 278.86,36.09 275.48,36.09 269.82,41.75 269.82,43.89 269.92,43.99 269.92,46.89 269.82,46.99 269.82,48.42 272.06,50.66 272.06,52.98 274.15,55.08 274.15,55.7 274.57,56.12 274.91,56.12 275.29,56.51 275.63,56.51 276.25,57.12 276.25,59.21 276.13,59.33 276.13,60.84 276,60.97 276,61.81 v2(275.92,61.88)
ISH_I2C0_SCL: length 285.8
  TOP w0.089: UH1.AG45 270.65,54.33 270.23,54.33 270.11,54.21 269.17,54.21 268.45,53.49 267.46,53.49 267.03,53.92 266.84,53.92 266.62,53.7 v2(266.62,53.64)
  TOP w0.112: RH617.1 v2(114.9,173.95) RS18.1
  IN1 w0.084: v2(266.62,53.64) 266.5,53.76 266.27,53.76 265.91,54.12 265.91,56.99 267.04,58.12 267.04,58.31 267.04,58.31 267.04,79.01 267.94,79.91 268.19,79.91 v2(268.38,80.1)
  IN2 w0.104: v2(114.9,173.95) 114.42,174.43 114.24,174.43 111.98,172.17 111.98,166.65 113.82,164.81 120.87,164.81 121.9,163.77 121.9,160.02 123.52,158.41 150.44,158.41 152.45,156.4 153.13,156.4 153.49,156.76 153.49,157 v2(153.46,157.03)
  IN3 w0.104: v2(268.38,80.1) 268.38,80.03 268.49,79.92 268.98,79.92 269.28,80.22 269.28,80.6 269.18,80.7 268.93,80.7 268.82,80.81 268.82,81.02 268.93,81.12 269.18,81.12 269.28,81.22 269.28,85.35 274.13,90.2 274.13,96.23 273.5,96.86 273.5,101.72 269.01,106.21 262.5,106.21 259.07,109.64 238.67,109.64 237.32,108.29 220.02,108.29 219.58,107.85 217.33,107.85 216.88,108.29 214.15,108.29 213.49,107.63 205.29,107.63 202.62,110.3 202.62,115.45 203.35,116.18 203.35,126.28 206.51,129.44 206.51,132.89 207.35,133.73 207.35,135.34 204.75,137.94 204.75,140.49 204,141.24 200.74,141.24 199.98,142.01 197.87,142.01 192.82,147.06 184.67,147.06 184.21,147.52 181.85,147.52 179.19,150.19 165.21,150.19 161.32,154.08 157.34,154.08 155.57,155.85 154.02,155.85 153.51,156.36 153.51,156.98 v2(153.46,157.03)
ISH_I2C0_SDA: length 286
  TOP w0.089: v2(266.62,54.23) 266.75,54.1 267.1,54.1 267.54,53.67 268.38,53.67 269.1,54.39 270.04,54.39 UH1.AH46
  TOP w0.112: RH618.1 114.43,174.91 v2(114.91,174.91) 115.38,174.91 RS19.1
  IN1 w0.084: v2(268.38,79.44) 268.12,79.44 267.5,78.81 267.5,58.5 267.5,57.92 266.38,56.8 266.38,54.31 266.46,54.23 v2(266.62,54.23)
  IN2 w0.104: v2(154.04,157.03) 153.99,156.98 153.99,156.58 153.33,155.92 152.25,155.92 150.24,157.92 123.32,157.92 121.42,159.82 121.42,163.57 120.67,164.32 113.62,164.32 111.49,166.45 111.49,172.37 114.04,174.91 v2(114.91,174.91)
  IN3 w0.104: v2(268.38,79.44) 269.18,79.44 269.77,80.02 269.77,85.15 274.62,90 274.62,96.43 273.99,97.06 273.99,101.92 269.21,106.7 262.7,106.7 259.27,110.13 238.47,110.13 237.12,108.78 219.82,108.78 219.38,108.33 217.53,108.33 217.08,108.78 213.95,108.78 213.29,108.12 205.49,108.12 203.1,110.5 203.1,115.25 203.83,115.98 203.83,126.08 206.99,129.24 206.99,132.69 207.83,133.53 207.83,135.54 205.24,138.14 205.24,140.69 204.2,141.73 200.94,141.73 200.18,142.49 198.07,142.49 193.02,147.55 184.88,147.55 184.41,148.01 182.05,148.01 179.39,150.68 165.41,150.68 161.52,154.56 157.54,154.56 155.77,156.33 154.22,156.33 153.99,156.56 153.99,156.98 v2(154.04,157.03)
ISH_I2C1_SCL: length 38.7
  TOP w0.089: v2(267.04,55.22) 267.21,55.05 267.91,55.05 267.93,55.08 269.27,55.08 269.46,54.88 269.46,54.8 269.61,54.65 UH1.AH47
  TOP w0.112: v2(276.07,81.87) 276.07,82.17 276.2,82.29 RH620.1
  IN1 w0.084: v2(267.04,55.22) 267.12,55.14 268.1,55.14 268.56,55.6 268.56,59.33 268.85,59.63 268.85,62.73 269.09,62.96 269.09,67.89 269.12,67.92 269.12,68.56 269.75,69.2 269.75,72.92 268.1,74.57 268.1,75.87 272.09,79.86 275.89,79.86 276.07,80.04 v2(276.07,81.87)
ISH_I2C1_SCL_R: length 3.8
  TOP w0.112: v1(274.35,81.3) 274.53,81.48 RH31.2 275.54,81.38 RH620.2 276.73,80.2 US3.1
ISH_I2C1_SDA: length 38.6
  TOP w0.089: v2(267.04,54.63) 267.28,54.87 267.98,54.87 268.01,54.9 269.19,54.9 269.28,54.81 269.28,54.69 UH1.AH48
  TOP w0.112: RH621.1 276.57,76.71 276.45,76.82 v2(276.16,77.11)
  IN1 w0.084: v2(276.16,77.11) 276.44,77.4 276.44,78.95 276,79.4 272.29,79.4 268.57,75.68 268.57,74.76 270.22,73.11 270.22,69 269.58,68.37 269.58,67.73 269.55,67.7 269.55,62.77 269.32,62.54 269.32,59.43 269.02,59.14 269.02,55.41 268.29,54.68 267.09,54.68 v2(267.04,54.63)
ISH_I2C1_SDA_R: length 3.3
  TOP w0.112: US3.4 276.73,78.6 RH621.2 275.56,77.62 RH32.2 v1(274.53,77.63)
ISL95338_N001:
  vias: v1(122.84,151.92)
ISL95338_N003:
  vias: v1(131.35,147.03)
ISL95338_N004:
  vias: v1(139.86,146.84)
ISL95338_N006:
  vias: v1(154.02,144.04)
ISOLATE#: length 4.1
  TOP w0.112: UL1.49 177.39,171.91 v2(176.88,172.43)
  BOTTOM w0.112: RL10.2 RL9.2 177.19,172.74 v2(176.88,172.43)
IST_TRIG: length 1.6
  TOP w0.102: v2(140.18,76.69) 140.18,77.24 TC13.1
  BOTTOM w0.102: UC1.L8 139.72,76.23 v2(140.18,76.69)
ISUMN_GT: length 118.6
  TOP w0.254: PCZ20.1 66.51,25.28 PRZ32.1 66.51,25.28 PRZ31.1 67.42,24.49 PCZ17.1 67.46,24.52 PRZ30.2 68.43,24.52 PCZ15.1 69.27,25.42 PCZ12.2 69.27,26.7 69.24,26.73 v2(69.24,26.92)
  IN4 w0.254: v2(69.24,26.92) 69.18,26.87 69.18,25.81 71.6,23.39 79.81,23.39 80.57,24.15 83.8,24.15 84.59,23.36 84.59,23.31 85.97,21.93 98.91,21.93 101.3,19.54 107.69,19.54 108.32,20.17 108.32,21.17 109.5,22.35 110.99,22.35 113.68,25.04 126.39,25.04 127.73,23.71 136.87,23.71 139.7,20.88 140.26,20.88 v2(140.68,21.3) 140.78,21.19 141.32,21.19 141.88,21.75 141.88,24.71 143.09,25.93 158.21,25.93 159.22,24.92 159.22,21.3 159.73,20.79 160.04,20.79 v2(160.17,20.91)
  BOTTOM w0.254: v2(69.24,26.92) 69.21,26.95 PCZ13.2 ; v2(160.17,20.91) 160.02,20.76 PRG22.1 ; PHZ02.2 139.96,19.64 PRG11.1 140.68,21.07 v2(140.68,21.3)
ISUMN_VCORE: length 136.8
  TOP w0.254: v2(116.42,30.88) 116.42,29.39 117.35,28.47 117.35,27.1 118.77,25.68 123.59,25.68 124.04,26.13 PRI36.1 ; PRI20.1 122.19,51.9 PRI101.1 122.06,51.78 v1(120.81,51.78) 120.29,51.78 118.86,53.21 PRI116.1 118.86,54.61 119.11,54.87 119.15,54.87 ; 119.15,54.87 v2(119.15,54.87) ; 119.15,54.87 119.15,54.89 119.26,54.89 119.78,55.4 119.78,58.07 120.16,58.45 120.16,61.11 120.16,61.11 120.16,63.79 119.43,64.51 PRI61.1 119.07,66.76 PRI76.1 ; PCZ16.2 PCZ19.2 71.11,33.52 PRZ35.2 72.01,34.48 PCZ22.1 72,34.51 PRZ34.1 72.56,35.9 73.37,35.9 74.07,35.2 v2(74.07,35.08)
  IN1 w0.254: v2(74.07,35.08) 73.24,35.08 72.62,34.45 72.62,33.78 73.31,33.09 76.21,33.09 83.04,26.26 87.87,26.26 88.31,26.69 90.23,26.69 93.15,29.61 102.39,29.61 104.76,27.24 113.42,27.24 116.17,30 116.17,30.63 v2(116.42,30.88) 116.17,31.14 116.17,32.78 115.09,33.87 115.09,34.63 113.44,36.28 113.44,37.23 115.38,39.18 115.38,41.02 113.44,42.97 113.44,43.97 115.53,46.06 115.53,53.24 116.1,53.81 117.82,53.81 118.88,54.87 v2(119.15,54.87)
  BOTTOM w0.254: PRZ33.2 71.03,32.74 PCZ18.2 71.97,33.58 PCZ21.1 72.02,34.48 PCZ23.1 72.02,34.93 72.99,35.9 73.56,35.9 74.07,35.39 v2(74.07,35.08) ; PHZ03.1 115.73,24.09 115.73,28.76 116.17,29.2 116.17,30.63 v2(116.42,30.88)
ISUMP_GT: length 123.3
  TOP w0.203: PUZ01.7 65.16,28.19 65.07,28.1 65.07,27.21 v2(65.06,27.19)
  TOP w0.254: PRZ30.1 68.29,26.17 PCZ12.1 68.36,26.65 v2(68.63,26.92)
  IN4 w0.254: v2(68.63,26.92) 68.76,26.8 68.76,26.72 68.8,26.68 68.8,25.65 71.44,23.01 79.96,23.01 80.73,23.77 83.64,23.77 84.21,23.2 84.21,23.15 85.81,21.55 98.75,21.55 101.15,19.15 107.85,19.15 108.7,20.01 108.7,21.01 109.66,21.97 111.14,21.97 113.84,24.66 126.24,24.66 127.57,23.33 136.71,23.33 139.55,20.5 140.79,20.5 v2(140.97,20.68) 141.35,20.68 142.26,21.59 142.26,24.55 143.25,25.55 158.05,25.55 158.84,24.76 158.84,21.14 159.57,20.41 160.04,20.41 v2(160.17,20.28)
  BOTTOM w0.254: v2(140.97,20.68) 140.77,20.48 PRZ29.1 141.03,19.94 141.13,20.04 PRG10.2 142.16,19.4 142.16,18.53 141.78,18.15 140.97,18.15 140.63,17.8 PRG08.1 ; v2(65.06,27.19) 65.11,27.25 67.84,27.25 PCZ13.1 68.36,27.65 68.36,27.2 v2(68.63,26.92) ; PRG20.1 159.52,20.38 160.07,20.38 v2(160.17,20.28)
ISUMP_VCORE: length 135.2
  TOP w0.203: v2(69.43,31.85) 69.42,31.86 69.33,31.86 69.27,31.92 68.82,31.92 68.71,31.82 PUZ01.19
  TOP w0.254: v2(73.62,34.57) 73.56,34.63 73.56,35.13 73.34,35.34 PRZ34.2 72.92,34.51 PCZ22.2 72.93,33.55 PRZ45.2 ; PRI33.1 114.85,26.19 115.88,27.22 115.88,30.48 v2(115.47,30.88) 111.91,30.88 111.11,31.69 PRI18.1 ; PRI74.1 118.41,66.48 118.67,66.23 v1(118.67,65.62) 118.54,65.49 118.54,63.24 118.69,63.09 118.69,62.04 PRI59.1 119.63,61.1 119.63,58.46 119.4,58.22 119.4,55.7 v2(119.14,55.45) 119.14,55.44 PRI114.1 ; PRI99.1 114.58,39.4 v2(114.87,39.7)
  IN1 w0.254: v2(119.14,55.45) 118.92,55.45 117.66,54.19 115.94,54.19 115.15,53.39 115.15,46.22 112.99,44.06 112.99,42.87 114.87,40.99 v2(114.87,39.7) 114.87,39.26 113.05,37.45 113.05,36.12 114.71,34.47 114.71,33.71 115.79,32.63 115.79,31.2 v2(115.47,30.88) 115.79,30.57 115.79,30.15 113.26,27.62 104.92,27.62 102.55,30 92.99,30 90.07,27.07 88.15,27.07 87.71,26.64 83.2,26.64 76.37,33.47 73.47,33.47 73,33.94 73,34.29 73.27,34.57 v2(73.62,34.57)
  BOTTOM w0.254: v2(115.47,30.88) 115.79,30.57 115.79,29.36 115.35,28.92 115.35,23.97 PRZ36.2 ; v2(73.62,34.57) 73.54,34.48 PCZ23.2 74.04,33.38 74.04,32.19 73.72,31.87 73.42,31.87 73.39,31.85 69.43,31.85 v2(69.43,31.85)
JRTC1: length 2.8
  TOP w0.112: PR18.2 352.73,12.19 v1(353.28,11.64)
  TOP w0.254: PD5.2 350.9,12.19 PR18.2
LAN_ACTIVITY#: length 26.1
  TOP w0.112: v2(184.06,179.09) 183.99,179.03 T364.1 184.45,177.43 184.45,176.3 184.79,175.97 184.79,175.03 184.79,175.02 UL1.31
  BOTTOM w0.112: JLAN.10 193.65,184.94 CL107.1 191.8,184.45 189.7,184.45 189.42,184.17 189.42,180.72 188.56,179.86 184.44,179.86 184.06,179.47 v2(184.06,179.09)
LAN_GPI: length 3.2
  TOP w0.112: UL1.48 178.2,172.31 178.02,172.49 178.02,172.8 177.32,173.51 RL5.2 177.27,172.67 T361.1
LAN_GPIO0: length 3.3
  TOP w0.112: UL1.29 185.59,174.75 185.38,174.97 185.38,175.41 T368.1 185.7,176.04 185.76,176.1 RL52.2 RL51.2
LAN_GPIO1: length 4.3
  TOP w0.112: UL1.30 185.19,174.71 185.13,174.78 185.13,175.76 v2(185.2,175.83)
  BOTTOM w0.112: v2(185.2,175.83) 185.2,175.45 T369.1 185.41,175.32 185.76,175.67 RL54.2 RL53.2
LAN_GPIO4: length 31.7
  TOP w0.112: v2(182.91,177.57) 182.59,177.24 182.59,176.11 T362.1 182.31,175.83 182.31,175.26 182.79,174.78 UL1.36 ; v2(159.6,173.95) 159.83,174.18 160.51,174.18 160.98,174.65 UL4.1
  IN3 w0.104: v2(159.6,173.95) 159.6,173.82 160.11,173.31 160.44,173.31 161.69,174.56 168.58,174.56 170.71,176.69 175.29,176.69 176.08,177.49 179.2,177.49 179.44,177.74 182.74,177.74 v2(182.91,177.57)
LAN_GPIO8: length 1.2
  TOP w0.112: T371.1 181.19,175.54 UL1.40
LAN_MDIN0: length 18.6
  TOP w0.089: v2(200.01,166.1) 200.34,165.77 200.34,165.62 200.25,165.53 199.66,165.53 199.48,165.35 UL2.2 ; UL1.88 187.99,163.79 187.92,163.72 187.92,163.62 188.01,163.53 188.2,163.53 188.4,163.73 189,163.73 189.24,163.49 189.24,163.41 189.55,163.09 v2(189.57,163.09)
  IN4 w0.084: v2(200.01,166.1) 200.26,165.85 200.26,165.33 199.05,164.11 196.89,164.11 196.1,163.33 190.77,163.33 190.09,162.65 189.52,162.65 189.38,162.79 189.38,162.9 v2(189.57,163.09)
LAN_MDIN1: length 19.8
  TOP w0.089: v2(192.8,168.4) 192.62,168.22 189.52,168.22 189.42,168.31 UL1.9 ; UL2.5 203.29,164.95 203.8,165.45 203.8,166.14 204.02,166.36 v2(204.02,166.63)
  IN1 w0.084: v2(204.02,166.63) 204.02,166.46 202.89,165.33 197.24,165.33 196.6,165.97 195.65,165.97 193.34,168.28 192.91,168.28 v2(192.8,168.4)
LAN_MDIN2: length 24.8
  TOP w0.089: v2(193.15,170.92) 193.15,170.86 192.64,170.35 192.49,170.35 191.8,171.04 189.5,171.04 189.42,171.11 UL1.16 ; UL2.8 207.1,165.17 207.61,165.68 207.61,165.99 v2(207.46,166.14)
  IN1 w0.084: v2(207.46,166.14) 207.59,166.27 207.59,166.67 206.7,167.56 195.84,167.56 193.91,169.49 193.34,169.49 192.81,170.02 192.81,170.58 193.14,170.92 v2(193.15,170.92)
LAN_MDIN3: length 40.7
  TOP w0.089: v2(187.83,175.43) 187.82,175.43 187.82,175.41 187.76,175.35 187.67,175.35 187.19,174.87 UL1.25 ; v2(210.94,166.06) 211.11,166.23 211.33,166.23 211.42,166.14 211.42,165.78 210.91,165.28 210.91,164.34
  IN2 w0.089: v2(193.42,168.84) 193.55,168.7 193.55,167.9 194.97,166.48 194.97,163.28 196.43,161.82 207.67,161.82 209.64,163.79 209.64,165.76 210.08,166.19 210.81,166.19 v2(210.94,166.06)
  IN4 w0.084: v2(187.83,175.43) 187.82,175.43 187.82,175.42 187.54,175.14 187.54,174.33 187.93,173.94 190.11,173.94 190.66,173.39 190.66,171.43 192.71,169.38 193.37,169.38 193.55,169.19 193.55,168.97 v2(193.42,168.84)
LAN_MDIP0: length 18.7
  TOP w0.089: v2(200.65,166.02) 200.59,165.96 200.59,165.33 200.75,165.16 200.75,164.34 ; UL1.87 187.59,163.69 187.67,163.61 187.67,163.52 187.9,163.28 188.31,163.28 188.5,163.47 188.9,163.47 188.99,163.39 v2(188.99,163.09)
  IN4 w0.084: v2(200.65,166.02) 200.65,165.17 199.21,163.73 197.05,163.73 196.26,162.94 190.93,162.94 190.25,162.27 189.35,162.27 189,162.63 189,163.08 v2(188.99,163.09)
LAN_MDIP1: length 19.8
  TOP w0.089: UL1.8 189.42,167.91 189.48,167.97 v4(190.08,167.97) 192.64,167.97 v2(192.8,167.81) ; UL2.6 204.56,164.97 204.05,165.48 204.05,166.04 204.23,166.22 v2(204.44,166.22)
  IN1 w0.084: v2(204.44,166.22) 204.33,166.22 203.06,164.95 197.08,164.95 196.44,165.58 195.49,165.58 193.18,167.89 192.88,167.89 v2(192.8,167.81)
LAN_MDIP2: length 24.8
  TOP w0.089: v2(208.04,166.14) 207.86,165.96 207.86,165.63 208.37,165.12 UL2.9 ; v2(193.56,170.51) 193.16,170.51 192.75,170.1 192.39,170.1 191.7,170.79 v4(190.02,170.79) 189.5,170.79 189.42,170.71 UL1.15
  IN1 w0.084: v2(208.04,166.14) 207.97,166.21 207.97,166.83 206.86,167.95 196,167.95 194.07,169.88 193.5,169.88 193.2,170.18 193.2,170.42 193.28,170.51 v2(193.56,170.51)
LAN_MDIP3: length 40.7
  TOP w0.089: v2(188.43,175.03) 188.3,175.16 188.12,175.16 187.99,175.03 187.79,175.03 187.59,174.83 UL1.24 ; v2(210.94,166.64) 211.11,166.48 211.44,166.48 211.67,166.24 211.67,165.76 212.18,165.25 UL2.12
  IN2 w0.089: v2(210.94,166.64) 210.81,166.51 209.95,166.51 209.33,165.89 209.33,163.92 207.54,162.14 196.57,162.14 195.29,163.41 195.29,166.61 193.87,168.03 193.87,168.7 v2(194,168.84)
  IN4 w0.084: v2(194,168.84) 193.94,168.9 193.94,169.35 193.53,169.77 192.87,169.77 191.05,171.59 191.05,173.55 190.27,174.33 188.09,174.33 187.93,174.49 187.93,174.97 188.11,175.15 188.3,175.15 v2(188.43,175.03)
LAN_SPICS#: length 3.9
  TOP w0.112: UL1.37 182.39,174.84 182.07,175.16 182.07,176.67 182.35,176.95 182.35,177.77 T370.1
LAN_SPISCK: length 75.2
  TOP w0.112: v2(160.31,173.76) 160.56,173.76 160.8,174 UL4.2 ; UL1.32 184.39,174.86 184.55,175.02 184.55,175.87 T365.1 183.8,177.32 183.42,177.7 v2(183.42,178.01)
  IN3 w0.104: v2(160.31,173.76) 161.34,174.79 168.49,174.79 170.62,176.92 175.19,176.92 176.16,177.89 176.83,177.89 178.12,179.18 180.7,179.18 181.87,178.01 v2(183.42,178.01) 183.61,178.2 184.7,178.2 186.03,179.54 190.09,179.54 192.21,177.42 192.21,171.2 193.72,169.7 194.41,169.7 196.43,167.67 196.43,165.58 197.8,164.22 206.61,164.22 208.98,161.85 212.06,161.85 212.24,162.03 v2(212.24,162.35)
  BOTTOM w0.112: v2(212.24,162.35) 212.24,163.9 RL68.2
LAN_SPISI: length 54.2
  TOP w0.112: v2(183.35,179.09) 183.35,178.7 183.05,178.39 181.55,178.39 T367.1 180.88,177.72 180.88,176.74 181.59,176.03 UL1.39 ; RL60.2 170.91,170.85 v2(170.91,171.01) ; v2(159.27,173.47) 159.39,173.35 UL4.3
  IN3 w0.104: v2(170.91,171.01) 170.91,170.72 169.53,169.34 160.84,169.34 158.97,171.22 158.97,173.16 v2(159.27,173.47) 159.03,173.71 159.03,174.84 159.21,175.02 168.39,175.02 170.52,177.15 175.09,177.15 176.07,178.13 176.74,178.13 178.02,179.41 183.04,179.41 v2(183.35,179.09)
LAN_SPISO: length 76.7
  TOP w0.112: UL1.38 181.99,174.87 181.83,175.03 181.83,176.4 T366.1 181.79,177.12 v2(181.94,177.12) ; v2(159.46,172.91) 159.67,172.7 UL4.4
  IN3 w0.104: v2(212.83,162.29) 212.16,161.62 208.88,161.62 206.51,163.98 197.71,163.98 196.2,165.49 196.2,167.58 194.32,169.46 193.62,169.46 191.98,171.11 191.98,177.33 190,179.31 186.13,179.31 183.97,177.15 181.97,177.15 v2(181.94,177.12) 181.56,177.51 179.54,177.51 179.29,177.26 176.18,177.26 175.38,176.46 170.81,176.46 168.68,174.33 161.78,174.33 160.36,172.91 v2(159.46,172.91)
  BOTTOM w0.112: v2(212.83,162.29) 213.96,163.42 RL67.2
LCD_TEST: length 197.5
  TOP w0.112: UE10.9 246.22,12.23 v2(246.31,12.32)
  IN2 w0.104: v2(196.73,101.66) 196.73,101.7 196.46,101.96 192.04,101.96 186.98,107.02 186.98,110.47 170.57,126.88 170.57,131.48 171.36,132.27 172.21,132.27 173.89,133.94 v2(173.89,134.2)
  BOTTOM w0.112: JDGFF1.F7 174.27,133.82 v2(173.89,134.2) ; v2(196.73,101.66) 195.94,100.88 v1(195.42,100.88) 192.38,100.88 191.29,99.79 191.29,99.08 192.01,98.36 192.01,25.8 194.86,22.95 211.38,22.95 213.16,24.73 217.18,24.73 218.6,23.31 242.17,23.31 248.33,17.15 248.33,14.33 v2(246.31,12.32)
LDO_EN: length 28.5
  TOP w0.112: UE10.15 237.21,9.62 236.85,9.26 v3(232.82,9.26) 229.99,9.26 229.13,10.12 229.13,13.71 v2(228.08,14.76)
  BOTTOM w0.112: JPK.18 227.45,11.69 227.13,12.01 226.64,12.01 225.93,12.72 225.93,13.56 226.19,13.82 228.14,13.82 DK3.3 228.73,14.1 v2(228.08,14.76)
LG1_ISL95338_1: length 8.9
  TOP w0.112: v2(123.21,143.03) 123.21,143.02 v1(122.84,142.64)
  IN4 w1.016: 122.64,142.45 121.75,142.45 119.21,139.91 119.21,136.04
  vias: v2(119.6,135.21) v2(119.6,134.58) v2(123.6,143.47)
LG1_ISL95338_2: length 6.8
  TOP w0.112: v2(146.23,140.89) 146.23,140.89 v1(146.71,141.37)
  IN1 w1.016: 145.63,139.34 145.63,137.95 147.09,136.48 149.69,136.48
  vias: v2(145.85,140.46) v2(150.67,136.88) v2(150.7,136.29)
LG2_ISL95338_1: length 5.4
  IN4 w1.016: 120.74,137.75 120.74,139.28 122.23,140.77 122.74,140.77 123.66,141.69
  vias: v2(120.67,136.82) v2(120.67,136.23) v2(124.15,142.36) v2(124.71,142.44) v3(121.06,138.26)
LG2_ISL95338_2: length 15.6
  TOP w0.112: v2(146.96,139.53) 146.96,139.54 v1(146.59,139.91)
  IN4 w1.016: 146.46,138.76 145.95,138.25 145.95,137.36 144.91,136.32 144.91,135.32 143.63,134.04 143.63,131.87 142.54,130.79 142.54,129.69 141.91,129.06 141.91,125.63
  vias: v2(141.57,124.78) v2(142.13,124.78) v2(147.41,139.91)
LG_3V: length 5.5
  IN1 w1.016: 325.09,40.94 321.23,44.8 321.16,44.8
  vias: v1(326.04,40.73) v2(320.75,45.67) v2(321.33,45.67) v2(326.49,39.93) v2(326.92,39.52)
LG_5V: length 4.4
  TOP w0.112: v2(326.49,37.03) v1(325.73,37.03)
  IN1 w1.016: 325.48,36.88 321.82,36.88
  vias: v2(320.95,37.64) v2(321.59,37.64) v2(327.1,37.06)
LG_+1VALWP: length 12.6
  TOP w0.112: v1(265.21,6.44) 265.93,7.16 v2(265.94,7.16)
  IN1 w1.016: 266.85,7.39 268.83,9.37 268.83,12.98 268.87,13.01 269.3,14.05 269.66,14.59 270.12,15.05 270.39,15.23 271.53,16.36 271.53,17.17
  vias: v2(265.56,7.62) v2(271.25,18.08) v2(271.88,18.08)
LG_CHG: length 16
  IN1 w0.889: 202.69,140.57 202.69,154.04 202.06,154.67 200.4,154.67
  vias: v2(198.81,154.57) v2(199.38,154.57) v2(203.25,139.37) v2(203.68,139.75) v3(198.1,154.06)
LG_VCCSA: length 16.9
  TOP w0.112: v2(128.93,112.98) v1(129.51,112.98)
  IN4 w1.016: 129.84,113.15 130.55,112.45 141.54,112.45 144.6,115.52
  vias: v2(128.93,113.56) v2(145.08,117.02) v2(145.08,116.43)
LID_SW#: length 365.6
  TOP w0.112: v2(353.77,23.99) 353.25,23.99 v3(352.9,23.65) ; v2(294.94,24.12) 294.94,22.58 296.21,21.31 296.49,21.31 298.47,23.29 298.47,24.28 298.34,24.42 UE5.115 298.34,27.11 RE70.2 298.4,28.1 298.4,29.17 298.53,29.3 298.53,30.24 CE43.1
  TOP w0.127: DE1.1 v2(353.77,23.99)
  IN3 w0.104: v2(37.98,17.42) 38.65,17.42 39.27,18.03 41.4,18.03 41.63,18.26 47.45,18.26 48.21,17.5 48.21,14.84 48.86,14.19 50.58,14.19 51.39,15 55.36,15 55.72,15.36 65.2,15.36 67.89,12.67 81.36,12.67 83.87,15.19 88.16,15.19 89.33,16.36 93.51,16.36 95.45,14.41 105.8,14.41 106.59,13.62 109.52,13.62 110.09,13.62 112.54,11.17 114.65,11.17 115.42,11.94 118.37,11.94 118.98,11.33 123.24,11.33 123.51,11.06 125.76,11.06 126.43,10.39 132.71,10.39 133.14,10.83 141.44,10.83 141.89,10.37 155.3,10.37 158.69,13.76 179.85,13.76 180.75,12.86 186.85,12.86 188.72,14.74 226.26,14.74 227.45,15.93 231.1,15.93 231.75,16.59 236.34,16.59 238.38,18.62 258.29,18.62 267.26,27.59 285.01,27.59 285.49,27.1 286.95,27.1 287.7,26.35 289.93,26.35 291.18,25.09 293.97,25.09 v2(294.94,24.12) 295.85,25.02 301.89,25.02 302.49,25.63 304.45,25.63 306.58,23.49 308.63,23.49 308.86,23.26 308.86,22.72 309.7,21.88 310.8,21.88 315.59,17.1 326.79,17.1 329.53,19.84 331.63,19.84 334.3,22.52 336.5,22.52 336.96,22.06 336.96,20.8 338.64,19.11 348.11,19.11 350.13,21.14 350.13,21.84 352.17,23.88 353.65,23.88 v2(353.77,23.99)
  BOTTOM w0.112: v2(37.98,17.42) 38.04,17.42 38.36,17.09 38.36,16 38.06,15.69 JAUDIO.10
LX1_ISL95338_1:
  vias: v2(111.38,143.61) v2(111.37,143) v2(111.96,143.61) v2(111.96,143.03) v2(112.72,143.66) v2(112.88,141.83) v2(113.31,143.66) v2(113.46,141.83) v2(113.46,141.25) v2(114.05,141.83) v2(114.05,141.25) v2(114.33,143.23) v2(114.37,142.52) v2(114.63,141.83) v2(114.63,141.25) v2(114.98,143.22) v2(115.54,142.99) v2(115.54,142.35) v2(115.54,141.59) v2(116.19,143.01) v2(116.19,142.38) v2(116.19,141.62) v2(116.36,143.72) v2(116.8,143.22) v2(116.8,142.58) v2(116.8,141.82) v2(117.12,143.72) v2(117.56,143.22) v2(117.56,142.58) v2(117.56,141.82) v2(117.88,143.72) v2(118.33,143.22) v2(118.33,142.58) v2(118.33,141.82) v2(118.64,143.72) v2(119.09,143.22) v2(119.09,142.58) v2(119.09,141.82) v2(119.72,142.96) v2(119.72,142.2) v3(119.73,143.6)
LX1_ISL95338_2:
  vias: v2(140.68,139.34) v2(140.68,138.58) v2(140.68,137.82) v2(140.68,137.06) v2(140.68,136.29) v2(140.68,135.53) v2(140.68,134.77) v2(140.68,134.01) v2(140.68,133.25) v2(141.26,139.34) v2(141.26,138.58) v2(141.26,137.82) v2(141.26,137.06) v2(141.26,136.29) v2(141.26,135.53) v2(141.26,134.77) v2(141.26,134.01) v2(141.26,133.25) v2(141.26,132.48) v2(141.85,138.58) v2(141.85,137.82) v2(141.85,137.06) v2(141.85,136.29) v2(141.85,135.53) v2(141.85,134.77) v2(141.85,134.01) v2(141.85,133.25) v2(141.85,132.48) v2(142.43,138.58) v2(142.43,137.82) v2(142.43,137.06) v2(142.43,136.29) v2(142.43,135.53) v2(142.43,134.77) v2(142.43,134.01) v2(142.43,133.25) v2(142.43,132.48) v2(143.01,137.82) v2(143.01,137.06) v2(143.03,136.48) v3(143.22,139.72)
LX2_ISL95338_1: length 8.6
  IN4 w1.016: 122.14,133.56 123.27,134.69 123.27,136.55 124.54,137.82 124.54,138.89 125.18,139.53 125.18,140.9
  vias: v2(113.6,128.66) v2(113.6,128.08) v2(114.13,129.02) v2(114.13,128.43) v2(114.19,127.85) v2(114.72,129.02) v2(114.72,128.43) v2(114.77,127.85) v2(115.3,129.68) v2(115.3,129.09) v2(115.3,128.51) v2(115.35,127.93) v2(115.89,129.68) v2(115.89,129.09) v2(115.89,128.51) v2(115.94,127.93) v2(115.99,130.29) v2(116.47,129.68) v2(116.47,129.09) v2(116.47,128.51) v2(116.52,127.93) v2(116.57,130.87) v2(116.57,130.29) v2(117.06,129.68) v2(117.06,129.09) v2(117.06,128.51) v2(117.11,127.93) v2(117.16,131.46) v2(117.16,130.87) v2(117.16,130.29) v2(118.58,133.56) v2(118.58,132.98) v2(118.58,132.4) v2(119.16,133.56) v2(119.16,132.98) v2(119.16,132.4) v2(119.75,133.56) v2(119.75,132.98) v2(119.75,132.4) v2(120.33,133.56) v2(120.33,132.98) v2(120.33,132.4) v2(120.93,132.87) v2(121.56,132.87) v2(125.4,142.34) v2(125.37,141.78) v3(118.46,129.63)
LX2_ISL95338_2: length 6.8
  IN4 w1.016: 145,131.93 145,132.87 146.96,134.83 146.96,135.91 147.73,136.68 147.73,137.63
  vias: v2(143.09,128.42) v2(143.52,130.33) v2(143.52,129.56) v2(143.52,128.8) v2(143.52,128.04) v2(144.11,131.09) v2(144.11,130.33) v2(144.11,129.56) v2(144.11,128.8) v2(144.11,128.04) v2(144.69,131.09) v2(144.69,130.33) v2(144.69,129.56) v2(144.69,128.8) v2(144.69,128.04) v2(145.27,131.09) v2(145.27,130.33) v2(145.27,129.56) v2(145.27,128.8) v2(145.27,128.04) v2(147.37,131.29) v2(147.37,130.71) v2(147.37,130.12) v2(147.88,139.29) v2(147.9,138.71) v2(147.95,131.29) v2(147.95,130.71) v2(147.95,130.12) v2(148.54,131.29) v2(148.54,130.71) v2(148.54,130.12) v2(149.12,131.29) v2(149.12,130.71) v2(149.12,130.12) v3(143.09,130.71)
LX_3V: length 15.5
  IN1 w1.016: 329.34,42.21 329.34,44.52 323.85,50.01 318.39,50.01
  vias: v1(307.18,51.84) v2(317.55,50.29) v2(317.55,49.6) v2(329.18,40.71) v2(329.59,41.15)
LX_5V: length 9.4
  IN1 w1.016: 320.04,33.2 326.95,33.2 328.7,34.95
  vias: v2(319.15,33.6) v2(319.15,32.97) v2(329.11,35.99) v2(329.54,35.56) v3(311.69,28.09)
LX_CHG: length 11.8
  IN1 w1.016: 202.27,138.63 199.72,138.63 198.21,140.14 198.21,147.28
  vias: v2(198.53,151.6) v2(198.53,150.96) v2(198.51,150.39) v2(198.51,149.76) v2(198.58,149.04) v2(198.59,148.44) v2(199.11,151.6) v2(199.11,150.96) v2(203.1,138.76) v2(203.68,138.91) v2(204.72,151.62) v2(204.72,150.99) v2(204.72,150.35) v2(204.72,149.72) v2(205.29,151.62) v2(205.29,150.99) v2(205.29,150.35) v2(205.29,149.72) v3(205.99,149.08)
LX_VCCIO: length 4.4
  TOP w0.112: v2(154.36,114.91) 154.18,114.91 v1(153.94,115.15)
  IN1 w0.762: v2(153.31,110.7) 153.31,112.04 154.36,113.08 154.36,114.11 154.33,114.13
LX_VCCSA: length 2.9
  TOP w0.112: v2(133.17,116.3) v1(133.7,116.3)
  IN4 w1.016: 136.17,115.44 135.66,115.95 134.01,115.95
  vias: v2(133.17,115.72) v2(137.18,115.69) v2(137.18,115.11) v2(141.51,119.92) v2(141.51,118.86) v2(141.51,117.8) v2(142.24,119.92) v2(142.24,118.86) v2(142.24,117.8) v2(142.97,119.92) v2(142.97,118.86) v2(142.97,117.8)
ME_EN: length 55.7
  TOP w0.089: v2(288.59,66.8) 288.59,66.8 288.95,67.16 RH16.1
  TOP w0.112: v2(306.14,32.35) 306.14,32.29 v1(306.79,31.64) 306.96,31.47 306.96,27.89 306.43,27.35 305.15,27.35 304.74,26.94 UE5.99
  IN3 w0.104: v2(306.14,32.35) 305.98,32.19 302.89,32.19 298.56,36.52 298.56,41.09 296.11,43.54 296.11,52.24 295.46,52.89 295.46,53.9 296,54.44 296,56.33 295.81,56.52 295.81,58.85 294.19,60.46 294.19,63.6 292.65,65.14 291.67,65.14 290.01,66.8 288.59,66.8 v2(288.59,66.8)
ME_SUS_PWR_ACK: length 8.5
  TOP w0.089: RH506.1 274.48,68.99 v1(274.48,68.6) 274.22,68.34 274.22,67.18 274.66,66.74 274.66,65.88 274.98,65.56 274.98,63.9 274.73,63.64 274.73,63.59 274.71,63.58 274.71,63.3 274.73,63.29 274.73,63.09 274.7,63.07 274.7,62.81 274.73,62.79 274.73,62.7 274.64,62.62 274.64,62.21 UH1.BC37
MIC_CLK: length 262.2
  TOP w0.112: v2(124.04,95.02) v1(124.04,94.26) 124.04,92.99 121.63,90.57 v2(121.11,90.57)
  IN1 w0.084: v2(177.07,137.71) 177.56,137.22 177.56,136.32 176.69,135.45 173.85,135.45 173.48,135.07 173.48,133.54 172.07,132.13 171.3,132.13 170.73,131.56 170.73,129.39 171.37,128.75 171.37,112.48 166.95,108.06 166.95,106.04 168.33,104.66 168.33,103.87 v2(168.25,103.8) ; v2(74.58,46.89) 74.76,46.71 77.9,46.71 77.99,46.79 77.99,46.87 78.07,46.95 78.24,46.95 78.32,46.87 78.32,46.79 78.4,46.71 78.57,46.71 78.66,46.79 78.66,47.34 78.74,47.42 82.37,47.42 96.93,61.98 98.36,61.98 104.29,67.91 104.29,76.87 104.34,76.92 104.34,76.93 110.14,82.73 110.14,89.33 111.45,90.63 121.05,90.63 v2(121.11,90.57) ; v2(30.16,37.49) 30.08,37.4 30.08,35.94 29.81,35.67 29.81,31.84 31.77,29.88 31.77,21.98 30.32,20.53 30.32,17.75 28.52,15.94 28.52,13.96 v2(28.37,13.82)
  IN3 w0.104: v2(124.04,95.02) 125.03,94.03 133.83,94.03 136.68,96.89 136.68,99.23 140.73,103.28 156.71,103.28 157.54,102.45 166.9,102.45 v2(168.25,103.8)
  IN4 w0.084: v2(53.45,45.03) 53,45.49 52.93,45.49 52.93,45.5 51.06,45.5 50.7,45.14 47.73,45.14 47.48,44.89 44.82,44.89 44.44,44.51 41.62,44.51 40.99,45.14 40.73,45.14 40.72,45.13 40.39,45.13 40.38,45.14 39.29,45.14 38.63,45.79 36.3,45.79 35.19,46.9 33.75,46.9 33.54,46.7 32.57,46.7 31.73,45.85 31.73,44.82 29.46,42.56 29.46,38.19 v2(30.16,37.49)
  BOTTOM w0.112: v2(53.45,45.03) 53.45,46.72 57.56,50.82 66.07,50.82 70.83,46.06 74.39,46.06 74.58,46.25 v2(74.58,46.89) ; JAUDIO.30 28.06,14.13 v2(28.37,13.82) ; v2(177.07,137.71) 177.09,137.71 177.57,137.23 177.57,137.15 177.87,136.86 JDGFF1.H1
MIC_DATA12: length 262.2
  TOP w0.112: v2(124.8,95.02) 124.8,92.82 v1(122.79,90.81) 122.07,90.09 v2(121.58,90.09)
  IN1 w0.084: v2(177.09,137.13) 177.09,136.33 176.55,135.79 173.71,135.79 173.14,135.21 173.14,133.68 171.93,132.47 171.16,132.47 170.39,131.7 170.39,129.25 171.03,128.61 171.03,112.62 166.61,108.2 166.61,105.9 167.85,104.66 v2(167.85,104.35) ; v2(28.37,13.16) 28.37,13.21 28.85,13.69 28.85,15.8 30.66,17.61 30.66,20.39 32.11,21.84 32.11,30.02 30.15,31.98 30.15,32.95 30.23,33.03 30.74,33.03 30.83,33.12 30.83,33.29 30.74,33.37 30.23,33.37 30.15,33.45 30.15,33.62 30.23,33.7 30.74,33.7 30.83,33.79 30.83,33.96 30.74,34.04 30.23,34.04 30.15,34.12 30.15,35.53 30.45,35.83 30.45,36.63 v2(30.68,36.87) ; v2(74.13,46.51) 74.27,46.37 79.21,46.37 79.92,47.08 82.51,47.08 97.07,61.64 98.5,61.64 104.63,67.77 104.63,76.73 110.48,82.59 110.48,88.77 110.61,88.89 111.88,90.17 120.49,90.17 120.7,89.95 121.45,89.95 v2(121.58,90.09)
  IN3 w0.104: v2(167.85,104.35) 167.85,103.9 166.76,102.8 157.69,102.8 156.86,103.63 140.58,103.63 136.33,99.38 136.33,97.04 133.68,94.39 125.43,94.39 v2(124.8,95.02)
  IN4 w0.084: v2(52.87,45.04) 52.87,45.08 52.79,45.16 51.2,45.16 50.74,44.7 47.77,44.7 47.6,44.54 44.94,44.54 44.58,44.17 41.48,44.17 40.93,44.72 39.23,44.72 38.49,45.45 36.16,45.45 35.05,46.57 34.12,46.57 33.84,46.29 32.86,46.29 32.18,45.62 32.18,44.54 31.78,44.13 31.78,42.95 29.8,40.98 29.8,38.62 30.68,37.74 v2(30.68,36.87)
  BOTTOM w0.112: v2(28.37,13.16) 28.83,13.61 28.83,14.09 28.56,14.36 JAUDIO.29 ; JDGFF1.H2 177.27,136.95 v2(177.09,137.13) ; v2(74.13,46.51) 71.21,46.51 66.31,51.41 57.32,51.41 52.87,46.96 v2(52.87,45.04)
N17_ID0: length 16.3
  TOP w0.089: UH1.AR18 284.1,57.91 284.31,58.13 v2(284.31,58.25) ; v1(284.51,69.11) 284.13,69.49 RH27.1 283.54,69.47 RH28.1 282.96,69.46 v2(282.38,68.88)
  IN2 w0.104: v2(282.38,68.88) 282.38,68.88 282.38,62.38 281.65,61.65 281.65,60.69 282.18,60.16 283.25,60.16 283.81,59.6 283.81,58.38 284.05,58.14 284.2,58.14 v2(284.31,58.25)
N17_ID1: length 6.2
  TOP w0.089: UH1.BF14 286.12,63.65 286.13,63.66 286.13,65.21 286.59,65.67 286.59,67.09 v1(286.7,67.2) 286.67,67.2 286.67,67.21 286.73,67.21 286.82,67.3 286.82,68.12 RH26.1 287.25,68.55 RH25.1
NC_B4: length 5.2
  BOTTOM w0.089: UT1.B4 19.8,46.42 19.72,46.34 19.32,46.34
  BOTTOM w0.104: 17.79,46.06 18.52,46.06 18.76,46.3 19.28,46.3 19.32,46.34
  BOTTOM w0.112: RT45.1 17.47,45.38 17.47,45.42 17.36,45.53 17.32,45.53 17.26,45.58 16.02,45.58 v1(15.98,45.54)
  BOTTOM w0.127: RT45.1 17.68,45.5 17.68,45.5 RT86.2 17.79,46.06
NC_B5: length 5
  TOP w0.112: v2(18.22,43.71) v1(18.22,43.17)
  BOTTOM w0.089: UT1.B5 19.72,45.88 19.3,45.88
  BOTTOM w0.102: 19.3,45.88 19.28,45.91 18.93,45.91
  BOTTOM w0.104: RT46.1 18.22,43.64 v2(18.22,43.71) 18.22,44.63 18.45,44.86 18.45,44.97 18.6,45.13 18.6,45.58 18.93,45.91
NC_G2: length 3.9
  BOTTOM w0.089: UT1.G2 22.48,47.72 22.48,48.11 22.63,48.26 23.25,48.26 23.4,48.41
  BOTTOM w0.112: 23.4,48.41 23.51,48.52 23.51,48.55 23.98,49.02 v1(23.98,49.2) 23.83,49.35 23.6,49.35
  BOTTOM w0.127: RT47.1 23.12,49.83 23.6,49.35
NRB_BIT: length 11.5
  TOP w0.089: UH1.BE30 278.17,63.06 278.27,63.16 278.27,66.46 278.17,66.56 278.17,69.41 277.62,69.96 v1(277.62,71.44)
  TOP w0.127: v1(277.62,71.44) 277.62,73.35 RH524.2
NRST: length 40.6
  TOP w0.112: RE691.2 352.19,44.22 352.73,44.76 v2(354.26,44.76) 354.85,45.35 QE59.1 355.32,46.47 v1(356.45,46.47) 356.53,46.47 356.92,46.07 356.92,44.57 356.39,44.04 RE4.1
  TOP w0.127: UE1.7 358.32,40.41 358.14,40.59 CE8.1 358.14,42.19 RE4.1
  IN1 w0.084: v2(361.47,32.6) 361.47,33.84 355.86,39.45 355.86,43.33 354.43,44.76 v2(354.26,44.76)
  BOTTOM w0.112: v2(361.47,32.6) 361.76,32.31 366.84,32.31 367.06,32.09 370.11,32.09 370.49,31.71 JELC.10
NTC_CHG: length 3.9
  TOP w0.203: v2(205.13,142.14) 204.98,141.99 PU703.17
  BOTTOM w0.254: PR757.2 203.49,143.51 v1(204.18,143.51) 204.58,143.51 205.13,142.96 v2(205.13,142.14)
OCSET_VCCSA: length 15.9
  BOTTOM w0.254: PRA06.1 135.56,111.68 PCA11.2 PCA14.2 136.45,113.82 136.12,114.15 136.12,116.03 134.67,117.48 v1(134.67,118.26) 134.67,119.14 133.45,120.36 130.01,120.36 129.42,119.77 PUA01.9
OCSET_VCCSA_C: length 14.3
  BOTTOM w0.254: PRA13.1 PCA14.1 PCA11.1 135.53,112.53 134.92,111.92 134.92,111.25 v1(135.82,110.35) 136.3,109.88 140.21,109.88 140.87,110.53 140.87,113.03 141.06,113.22 PLA01.3
OCSET_VCCSA_R: length 8.6
  BOTTOM w0.254: PRA06.2 136.42,111.5 136.42,110.82 136.96,110.28 v1(137.32,110.28) 140.08,110.28 140.49,110.69 140.49,113.03 140.29,113.22 PLA01.2
OFF_FWEN_1: length 299.5
  TOP w0.112: v2(299.32,8.58) 299.14,8.76 UE5.48
  TOP w0.254: PQS18.2 129.4,154.14 PRS77.1 129.18,152.83 129.18,151.79 v2(129.86,151.12)
  IN2 w0.104: v2(129.86,151.12) 129.42,150.67 129.42,150.21 129.56,150.07 129.56,148.46 130.92,147.1 145.82,147.1 146.16,146.77 149.93,146.77 150.52,147.35 155.81,147.35 156.28,146.88 159.32,146.88 166.87,139.34 166.87,125.28 178.62,113.54 178.62,112.23 182.91,107.93 182.91,104 189.07,97.84 198,97.84 199.31,99.15 210.1,99.15 211.05,98.2 234.43,98.2 234.93,97.7 237.86,97.7 238.57,96.99 241.53,96.99 241.65,97.11 244.29,97.11 244.5,96.91 257.58,96.91 259.62,94.87 259.62,84.29 v2(260.89,83.02)
  BOTTOM w0.112: v2(260.89,83.02) 260.67,82.8 260.67,73.92 260.58,73.83 260.58,71.51 260.03,70.96 260.03,68.09 259.19,67.25 259.19,64.34 258.25,63.41 258.25,57.32 257.71,56.78 257.71,54.1 259.65,52.16 259.65,49.47 259.03,48.84 259.03,38.48 261.62,35.89 261.62,33.71 267.42,27.91 269.26,27.91 276.49,20.69 276.49,15.69 277.22,13.92 280.03,11.1 280.03,9.17 281.6,7.6 281.6,5.87 283.89,3.59 291.97,3.59 293.82,5.43 293.82,8.61 294.92,9.71 298.19,9.71 v1(298.51,9.39) v2(299.32,8.58)
OFF_FWEN_2: length 413.8
  TOP w0.112: v2(243.56,2.78) 242.97,3.38 241.72,3.38 239.01,6.08 239.01,7.69 v1(239.79,8.47) 240.44,9.12 UE10.16
  TOP w0.254: PQS19.2 152.61,150.68 PRS78.1 152.7,150.98 v2(153.32,151.6)
  IN1 w0.084: v2(105.79,20.8) 105.79,20.79 104.77,19.77 95.55,19.77 92.92,22.4 88.08,22.4 87.68,22 83.98,22 83.56,21.58 81.1,21.58 80.18,22.5 79.29,22.5 77.42,24.37 70.93,24.37 69.65,25.65 64.02,25.65 63.46,26.21 62.54,26.21 61.8,26.95 61.8,28.35 59.03,31.11 59.03,34.07 60.21,35.25 61.45,35.25 62.1,35.9 64.79,35.9 65.43,36.54 66.16,36.54 72.33,42.71 83.82,42.71 84.63,43.52 84.63,44.3 84.63,44.3 84.63,44.48 86.17,46.02 89.54,46.02 97.75,54.23 97.75,57.6 98.45,58.29 99.95,58.29 108.09,66.42 108.09,75.46 115.84,83.22 129.2,83.22 129.66,83.68 129.82,83.68 ; 132.58,84.99 132.61,85.02 134.47,85.02 135.92,86.47 135.92,91.19 139.79,95.06 139.79,100.31 142.66,103.18 142.66,106.6 144.6,108.55 147.84,108.55 149.38,110.09 149.38,119 151.54,121.17 154.32,121.17 160.5,127.35 160.5,133.39 162.83,135.72 162.83,142.08 159.34,145.57 157.79,145.57 153.32,150.05 v2(153.32,151.6)
  IN1 w0.102: 129.82,83.68 131.27,83.68 132.58,84.99
  IN3 w0.104: v2(125.02,4.75) 125.16,4.61 165.64,4.61 166.91,3.34 172.65,3.34 173.39,2.61 186.19,2.61 186.87,3.28 188.83,3.28 189.5,2.61 194.25,2.61 196.25,4.61 218.69,4.61 219.76,3.54 221.84,3.54 222.91,4.61 241.39,4.61 243.21,2.78 v2(243.56,2.78)
  BOTTOM w0.112: v2(125.02,4.75) 125.02,8.66 123.71,9.97 119.16,9.97 115.84,13.29 113.01,13.29 110.03,16.26 109.39,16.26 105.79,19.86 v2(105.79,20.8)
OFF_PMOS_1: length 286.7
  TOP w0.112: v2(126.67,152.68) 126.48,152.68 v1(126.23,152.93) ; UE6.2 284.65,7.93 285.03,7.55 v2(285.03,6.93)
  IN2 w0.104: v2(126.67,152.68) 127.66,151.69 127.66,149.71 130.73,146.64 145.63,146.64 145.97,146.31 150.48,146.31 150.82,145.97 159.59,145.97 166.41,139.15 166.41,125.09 175.2,116.3 175.2,113.57 182.45,106.32 182.45,102.97 189.01,96.42 197.23,96.42 199.51,98.69 209.91,98.69 210.86,97.74 234.24,97.74 234.73,97.24 237.66,97.24 238.38,96.53 241.72,96.53 241.84,96.65 244.1,96.65 244.31,96.44 257.39,96.44 258.41,95.42 258.41,93.24 259.15,92.5 259.15,76.75 261.5,74.41 262.25,74.41 v2(262.62,74.78)
  BOTTOM w0.112: v2(285.03,6.93) 285.03,6.75 284.79,6.51 284.29,6.51 284.03,6.77 284.03,7.23 284.49,7.68 284.49,9.77 286.38,11.67 286.38,13.59 287.18,14.38 287.18,16.66 287.22,16.7 287.22,19.56 286.91,19.87 286.38,19.87 283.88,22.37 276.83,22.37 269.86,29.35 268.01,29.35 263.05,34.31 263.05,36.49 260.46,39.07 260.46,48.25 261.09,48.87 261.09,52.76 260.68,53.16 260.68,54.09 261.77,55.18 261.77,60.63 263.94,62.8 263.94,67.11 262.83,68.22 262.83,74.57 v2(262.62,74.78)
  BOTTOM w0.254: PRS92.1 126.54,152.55 v2(126.67,152.68)
OFF_PMOS_2: length 247
  TOP w0.112: UE6.5 285.07,9.43 285.21,9.57 285.63,9.57 286.14,10.08 286.14,15.01 285.6,15.54 285.6,18.06 281.86,21.8 280.25,21.8 v2(278.1,23.96)
  TOP w0.254: v2(155.64,145.53) 155.64,145.96 155.3,146.3 v1(155.3,146.81) 155.3,148.18 PRS93.1
  IN2 w0.104: v2(155.64,145.53) 155.73,145.44 159.79,145.44 166.18,139.05 166.18,125 174.97,116.2 174.97,113.48 182.22,106.23 182.22,102.87 188.91,96.18 197.33,96.18 199.6,98.46 209.81,98.46 210.77,97.51 234.14,97.51 234.64,97.01 237.57,97.01 238.28,96.3 241.81,96.3 241.94,96.42 244.01,96.42 244.21,96.21 257.3,96.21 258.18,95.33 258.18,93.15 258.92,92.4 258.92,76.22 261.31,73.83 263.85,73.83 v2(264.44,73.24)
  BOTTOM w0.112: v2(278.1,23.96) 277.44,24.62 276.27,24.62 270.35,30.54 268.51,30.54 264.34,34.71 264.34,37.04 261.66,39.72 261.66,47.7 262.28,48.32 262.28,50.6 263.3,51.63 263.3,53.98 262.97,54.32 262.97,56.99 265.08,59.11 265.08,61.66 265.38,61.96 265.38,67.7 264.85,68.23 264.85,72.83 v2(264.44,73.24)
ON/OFF#: length 371.2
  TOP w0.112: UE5.114 298.74,26.43 298.58,26.59 298.58,26.93 298.84,27.2 299.22,27.2 299.33,27.3 299.33,28.11 RE63.2 300.02,28.81 300.02,30.15 300.31,30.43 300.31,30.89 299.99,31.2 v2(296.75,31.2) ; v2(268.55,92.05) 268.14,92.45 268.14,96.82 270.02,98.7 v2(280.82,98.7) 282.21,98.7 v3(284.5,96.41) SW2.1 289.86,94.41 C1.1 290.75,94.41 v2(292.25,95.91) 293.14,95.02 293.14,93.29 SW2.2 ; JPWR.9 JPWR.10 169.5,177.3 v2(169.21,177.01)
  IN2 w0.104: v2(182.69,179.89) 182.15,179.89 181.11,178.85 181.11,175.13 177.86,171.88 177.33,171.88 176.88,171.42 176.88,161.63 177.13,161.38 179.84,161.38 181.51,159.71 181.51,155.9 185.56,151.85 185.56,138.98 186.37,138.17 186.37,130.22 189.7,126.89 189.7,120.66 192.15,118.21 196.86,118.21 201.04,114.04 247.08,114.04 247.84,113.28 266.32,113.28 267.31,112.29 269.97,112.29 270.98,111.28 270.98,106.16 278.44,98.7 v2(280.82,98.7)
  IN3 w0.104: v2(296.75,31.2) 296.49,31.46 294.82,31.46 292.86,33.41 291.29,33.41 287.95,36.76 287.95,38.33 287.86,38.42 287.86,42.22 287.11,42.97 287.11,47.36 286.11,48.36 286.11,50.46 286.57,50.92 286.57,52.72 287.33,53.47 287.33,54.9 287.11,55.12 287.11,56.34 286.68,56.77 286.68,59.33 285.75,60.25 285.75,60.54 285.18,61.11 284.65,61.11 283.91,60.37 282.14,60.37 282,60.51 281.49,60.51 280.88,59.9 280.88,57.29 279.72,56.13 273.22,56.13 272.28,57.07 264.97,57.07 264.12,56.22 262.6,56.22 259.07,52.69 254.81,52.69 254.41,53.09 254.41,57.47 255.68,58.75 255.68,62.56 254.56,63.67 254.56,77.76 256.66,79.86 256.66,81.15 267.56,92.05 v2(268.55,92.05) ; v2(169.21,177.01) 169.64,177.44 174.79,177.44 178.02,180.67 181.92,180.67 v2(182.69,179.89)
  BOTTOM w0.112: SW3.1 293.14,93.3 293.14,95.02 v2(292.25,95.91) 290.75,94.41 C1.1 289.85,94.41 SW3.2
OPCN_CHG: length 3.9
  TOP w0.203: PC750.2 206.32,134.83 206.53,135.04 206.53,137.01 206.83,137.32 PU703.28
OSC24M_IN: length 3.2
  TOP w0.112: 359.32,39.6 v2(360.51,40.79)
  TOP w0.127: UE1.5 359.32,39.6
  BOTTOM w0.112: RE18.2 360.51,41.22 v2(360.51,40.79)
OSC24M_IN_R: length 5.1
  BOTTOM w0.112: RE18.1 361.19,41.45 360.67,41.97 RE3.1 CE2.1 360.26,43.29 360.26,44.71 360.38,44.82 360.63,44.82 YE1.1
OSC24M_OUT: length 3.2
  TOP w0.127: UE1.6 358.82,39.48 359.28,39.94 359.28,40.27 v1(359.3,40.29) 359.8,40.8 v2(359.93,40.8)
  BOTTOM w0.112: v2(359.93,40.8) 359.94,40.8 359.94,40.79 359.99,40.84 RE19.2
OSC24M_OUT_R: length 5.2
  BOTTOM w0.112: YE1.3 359.95,45.01 359.95,43.27 359.83,43.15 CE5.1 359.83,42.12 RE3.2 359.75,41.81 359.41,41.46 RE19.1
P1: length 136.1
  TOP w0.254: v2(122.2,149.25) 122.21,149.24 123.23,149.24 123.5,149.5 123.5,151.39 124.05,151.94 PRS75.1
  TOP w0.381: v2(204.24,131.85) 204.31,131.92 205.89,131.92 206.34,131.47 206.34,130.33 206.95,129.72 206.95,129.18 PD706.2 206.77,128.99 PD704.3
  IN2 w0.508: v2(109.05,165.63) 109.05,164.74 110.2,163.6 118.08,163.6 118.96,162.71 118.96,150.26 119.98,149.25 v2(122.2,149.25)
  IN3 w0.381: v2(204.24,131.85) 204.49,132.1 204.49,133.68 202.85,135.33 202.36,135.33 201.74,135.95 201.74,136.82 199.62,138.94 196.28,138.94 190.17,145.05 184.99,145.05 183.7,143.76 182.72,143.76 180.59,145.89 179.52,145.89 179.07,145.44 177.51,145.44 176.08,144.01 173.3,144.01 173.12,144.18 171.29,144.18 170.83,144.64 170.83,145.3 169.39,146.74 160.97,146.74 158.45,149.26 151.08,149.26 150.97,149.15 143.82,149.15 143.02,148.35 142.08,148.35 141.11,149.31 136.17,149.31 135.73,149.76 129.32,149.76 128.81,149.25 v2(122.2,149.25)
  vias: v1(108.87,164.23)
P2: length 1.5
  TOP w0.112: 118.24,154.63 119.37,154.63 v1(119.6,154.86)
P3: length 97.7
  TOP w0.381: PRS80.1 153.94,149.07 154.66,148.35 154.66,145.92 v2(155.06,145.53) ; v2(203.56,133.22) 204.23,132.55 205.98,132.55 206.81,131.72 206.81,131.7 206.84,131.66 206.84,130.58 208.07,129.36 208.07,129.25 PD706.3 208.07,128.99 PD704.2
  IN2 w0.508: v2(144.4,146.07) 135.84,146.07 v2(134.1,144.33)
  IN3 w0.381: v2(144.4,146.07) 145.42,145.06 149.86,145.06 150.84,144.08 154.37,144.08 154.97,144.68 154.97,145.44 v2(155.06,145.53) 155.06,145.76 155.44,146.14 158.51,146.14 159.24,145.41 168.26,145.41 170.39,143.28 170.39,142.69 172.27,140.8 180.17,140.8 180.88,141.51 180.88,142.49 181.26,142.87 184.07,142.87 185.36,144.16 189.63,144.16 195.91,137.88 198.9,137.88 200.78,136 200.78,135.61 202.03,134.36 202.42,134.36 v2(203.56,133.22)
  BOTTOM w0.508: PDS02.2 PRS26.2 143.26,144.93 v2(144.4,146.07)
  vias: v3(130.84,150.77)
P4:
  vias: v1(141.32,142.9)
P_SYS: length 240.7
  TOP w0.112: v2(64.29,38.43) v1(66.07,38.43)
  TOP w0.254: PRZ26.1 58.6,26.73 58.51,26.82 v2(58.51,26.82)
  TOP w0.508: PR792.1 v2(212.5,144.8)
  IN1 w0.254: v2(137.82,97.62) 137.82,97.62 137.82,97.56 134.45,94.19 134.45,88.52 131.62,85.69 129.44,85.69 127.84,84.08 120.43,84.08 119.6,84.92 119.6,86.62 119.02,87.19 119.02,87.98 118.52,88.48 116.33,88.48 115.79,87.94 115.79,86.63 105.62,76.46 105.62,67.42 98.92,60.72 97.52,60.72 95.24,58.44 95.24,56.49 87.35,48.61 85.43,48.61 82.99,46.17 80.29,46.17 79.53,45.41 71.66,45.41 65.25,39 64.86,39 v2(64.29,38.43)
  IN2 w0.254: v2(212.5,144.8) 212.5,142.83 210.4,140.74 210.4,135.02 202.03,126.64 v2(199.9,126.64) ; v2(58.51,26.82) 58.51,26.82 58.78,26.82 60.49,28.52 60.49,30.38 64.29,34.18 v2(64.29,38.43)
  IN3 w0.254: v2(137.82,97.62) 137.82,97.62 138.14,97.94 138.14,99.79 140.01,101.66 140.01,101.9 140.82,102.72 141.95,102.72 142.54,102.12 145.82,102.12 146.41,102.72 156.15,102.72 156.89,101.98 172.45,101.98 175.42,99.02 180.34,99.02 187.71,106.39 189.83,106.39 192.76,109.31 192.76,110.88 196.67,114.79 196.67,115.6 199.03,117.97 199.03,123.76 199.67,124.39 199.67,125.97 199.9,126.2 v2(199.9,126.64)
PA_USB2_RBIAS: length 2.3
  TOP w0.112: v1(23.84,38.19) 23.62,38.41 RT43.1 22.97,39.27 v2(22.92,39.32)
  BOTTOM w0.102: UT1.H19 v2(22.92,39.32)
PB_USB2_RBIAS: length 2.4
  TOP w0.112: v2(22.25,39.31) 21.77,38.83 RT44.1 v1(20.89,38.41)
  BOTTOM w0.076: UT1.F19 21.95,39.62 v2(22.25,39.31)
PBTN_OUT#: length 77.8
  TOP w0.089: v2(270.53,63.53) 270.16,63.3 UH1.BE46
  TOP w0.112: UE5.106 301.94,26.75 v2(301.88,26.8)
  TOP w0.127: CH174.1 272.14,74.47 RH2.2 271.27,74.12 271.5,73.89 271.5,73.89 v2(271.6,73.78)
  IN1 w0.084: v2(270.53,63.53) 270.72,63.53 271.98,62.27 271.98,61.72 271.77,61.5 271.77,61.02 269.49,58.74 269.49,54.2 270.32,53.36 271.53,53.36 271.84,53.06 271.84,52 272.17,51.67 272.17,49.66 272.57,49.26 275.93,49.26 276.76,48.43 277.93,48.43 278.5,47.86 278.5,47.4 279.08,46.83 279.84,46.83 281.73,44.93 281.73,43.72 282.31,43.15 282.31,39.13 283.06,38.37 283.06,36.08 284.96,34.17 284.96,33.39 v2(284.94,33.36)
  IN2 w0.104: v2(270.53,63.53) 270.53,65.58 271.45,66.5 271.45,69.19 271.19,69.44 271.19,71.8 271.6,72.21 v2(271.6,73.78)
  IN3 w0.104: v2(284.94,33.36) 285.59,34.02 287.79,34.02 291.09,30.72 291.09,30.09 292.03,29.16 294.05,29.16 295.49,27.71 296.76,27.71 298.39,26.07 301.24,26.07 301.88,26.72 v2(301.88,26.8)
PCH_ACC1_INT1: length 277.8
  TOP w0.089: UH1.AV34 276.34,59.01 v2(276.73,59.01)
  TOP w0.112: v2(277.76,82.9) 277.57,82.71 RH622.2 ; v2(109.22,169.58) 109.22,169.8 109.49,170.07 RH619.2 109.49,170.86 RS11.1 v1(109.72,172.02)
  IN1 w0.084: v2(276.73,59.01) 276.82,59.01 278.03,60.22 278.03,61.24 278.41,61.62 278.41,67.55 276.3,69.67 276.3,72.98 277.61,74.29 277.61,75.75 278.43,76.58 278.43,78.66 277.76,79.33 v2(277.76,82.9)
  IN2 w0.104: v2(109.22,169.58) 109.08,169.45 109.08,169.3 109.7,168.68 109.95,168.68 111.26,167.36 111.26,166.35 113.52,164.09 120.57,164.09 121.19,163.47 121.19,159.73 123.22,157.69 148.98,157.69 151.71,154.96 157,154.96 v2(157.89,155.85)
  IN3 w0.104: v2(157.89,155.85) 161.43,155.85 165.76,151.52 179.74,151.52 182.4,148.85 184.76,148.85 185.23,148.39 193.37,148.39 197.9,143.85 207.29,143.85 209.44,141.71 209.44,136.59 208.68,135.83 208.68,133 208,132.32 208,129.06 204.69,125.74 204.69,115.62 203.96,114.89 203.96,111.04 205.38,109.62 207.92,109.62 209.82,111.52 214.69,111.52 215.67,110.54 219.45,110.54 219.91,110.08 232.81,110.08 233.61,110.88 236.89,110.88 237.44,111.43 259.82,111.43 263.25,108 269.75,108 275.29,102.46 275.29,97.6 275.92,96.97 275.92,87.42 277.76,85.58 v2(277.76,82.9)
PCH_BATLOW#: length 341.3
  TOP w0.076: RT14.2 22.76,50.44
  TOP w0.089: UH1.BF44 271.14,63.67 270.86,63.94 270.86,64.53 270,65.39 270,66.5
  TOP w0.112: 22.76,50.44 v2(22.76,50.98)
  TOP w0.127: RH515.1 269.47,69.7 v1(269.08,69.3) 269.08,69.14 269.48,68.74 269.64,68.74 270,68.38 v2(270,68.1) 270,66.5
  IN1 w0.084: v2(48.8,48.51) 48.79,48.51 48.56,48.28 46.89,48.28 45.62,49.55 42.87,49.55 40.89,51.53 39.89,51.53 38.69,52.74 27.54,52.74 25.26,50.47 23.27,50.47 v2(22.76,50.98)
  IN3 w0.104: v2(48.8,48.51) 50.41,48.51 50.8,48.12 50.8,35.64 54.55,31.9 54.55,28.51 v2(54.13,28.09)
  IN4 w0.084: v2(54.13,28.09) 54.84,28.09 56.05,26.88 56.05,24.64 58.53,22.16 58.53,18.71 58.62,18.62 82.47,18.62 83.24,17.84 86.79,17.84 88.01,19.06 90.93,19.06 91.24,18.76 96.99,18.76 99.24,16.51 102.49,16.51 103.2,17.22 107.81,17.22 108.82,16.21 110.26,16.21 112.7,13.76 117.42,13.76 118.28,12.91 122.76,12.91 124.79,10.88 132.26,10.88 132.52,11.14 140.54,11.14 141.14,10.54 142.85,10.54 143.39,10 168.86,10 169.19,9.68 181.79,9.68 188.24,16.13 200.81,16.13 200.92,16.02 239.88,16.02 245.42,21.56 250.42,21.56 253.32,24.47 256.24,24.47 256.32,24.55 256.32,26.43 256.44,26.55 256.44,33.68 255.86,34.25 255.86,35.3 255.65,35.5 255.65,35.9 255.86,36.11 255.86,47 256.76,47.9 256.76,56.2 256.84,56.28 259.81,56.28 261.79,58.26 261.79,62.78 261.87,62.87 262.42,62.87 262.99,62.3 265.63,62.3 267.17,63.84 270.22,63.84 271.81,65.43 271.81,67.59 271.33,68.06 270.03,68.06 v2(270,68.1)

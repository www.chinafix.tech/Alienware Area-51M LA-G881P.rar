# Allegro board Alienware Area-51M LA-G881P.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_D12: length 114.1
  IN1 w0.122: v2(156.75,40.92) 157.38,40.29 157.38,39.64 158.27,38.75 158.27,38.43 164.25,32.45 165.66,31.72 203.98,31.72 205.74,31.02 211.22,31.02 211.7,31.51 212.26,31.51 212.63,31.87 218.29,31.87 218.89,31.27 225.69,31.27 226.53,30.43 230.71,30.43 231.19,30.91 232.94,30.91 233.25,31.22 236.92,31.22 237.23,30.91 v2(237.23,30.58)
  IN3 w0.15: v2(252.55,32.89) 250.8,31.14 248.54,31.14 248.03,30.63 245.86,30.63 244.86,29.63 238.93,29.63 238.6,29.3 237.09,29.3 236.94,29.45 236.94,30.29 v2(237.23,30.58)
  BOTTOM w0.102: v2(156.75,40.92) 157.07,41.23 157.07,44.77 UC1.AJ40
  BOTTOM w0.157: v2(252.55,32.89) 252.92,32.53 JDIMM1.24 ; JDIMM3.24 238.77,32.53 237.23,30.98 v2(237.23,30.58)
DDR_A_D13: length 116.3
  IN1 w0.102: v2(157.77,39.8) 157.76,39.79 157.76,39.64 158.8,38.61 158.8,38.5
  IN1 w0.122: 158.8,38.5 164.5,32.8 165.76,32.15 175.39,32.15 175.51,32.27 175.51,32.58 175.63,32.7 175.88,32.7 176,32.58 176,32.27 176.12,32.15 176.37,32.15 176.49,32.27 176.49,32.58 176.61,32.7 176.85,32.7 176.98,32.58 176.98,32.27 177.1,32.15 204.06,32.15 205.82,31.45 211.04,31.45 211.53,31.94 212.08,31.94 212.45,32.3 218.47,32.3 219.07,31.7 225.87,31.7 226.71,30.86 230.53,30.86 231.01,31.34 232.76,31.34 233.07,31.65 234.83,31.65 v2(235.28,32.1)
  IN3 w0.15: v2(235.28,32.1) 235.28,32.11 234.55,32.84 234.54,32.84 233.7,33.68 233.7,33.95 233.89,34.14 234.16,34.14 236.2,32.1 237.81,32.1 238.71,31.2 240.03,31.2 240.37,31.54 244.65,31.54 245.29,32.18 246.95,32.18 v2(247.13,32.36)
  BOTTOM w0.102: v2(157.77,39.8) 157.05,39.8 156.01,40.84 156.01,42.23 156.48,43.38 156.48,44.29 156.41,44.35 156.41,45.28 156.82,45.68 UC1.AJ39
  BOTTOM w0.157: JDIMM1.25 246.34,32.78 246.79,33.22 247.1,33.22 247.35,32.97 247.35,32.58 v2(247.13,32.36) ; JDIMM3.25 232.63,32.78 233.73,31.67 234.85,31.67 v2(235.28,32.1)
DDR_A_D14: length 113.7
  IN1 w0.102: 174.27,40.22 172.68,40.22 172.25,40.65 169.24,40.65 168.25,41.63 163.26,41.63 162.82,41.2 161.43,41.2 159.76,42.87 v2(159.13,42.87)
  IN1 w0.122: 174.27,40.22 175.75,40.22 179.27,36.7 205.93,36.7 206.84,35.79 211.18,35.79 212.03,36.65 217.49,36.65 218.6,35.54 219.81,35.54 220.07,35.28 231.1,35.28 232.25,36.44 238.27,36.44 238.91,35.8 238.91,35.35 238.3,34.74 v2(237.18,34.74)
  IN3 w0.15: v2(237.18,34.74) 237.25,34.67 237.35,34.67 237.74,34.29 240.27,34.29 240.68,33.88 242.02,33.88 242.55,34.4 248.89,34.4 249.34,34.85 249.34,35.74 249.92,36.32 251.48,36.32 251.63,36.47 251.63,36.77 v2(251.43,36.98)
  BOTTOM w0.102: UC1.AL39 158.81,45.3 158.47,44.96 158.47,44.49 158.6,44.36 158.6,43.71 159.13,43.18 v2(159.13,42.87)
  BOTTOM w0.157: v2(251.43,36.98) 251.43,36.84 252.24,36.03 JDIMM1.38 ; v2(237.18,34.74) 237.18,35.25 237.96,36.03 JDIMM3.38
DDR_A_D15: length 111.9
  IN1 w0.102: v2(159.33,41.79) 159.08,41.54 159.08,40.99 159.18,40.89
  IN1 w0.122: v2(233.82,34.76) 233.82,35.08 233.75,35.16 232.78,35.16 232.22,34.6 232.22,34.43 232.65,34 232.65,33.83 232.48,33.65 232.31,33.65 231.88,34.08 231.71,34.08 230.93,33.3 227.57,33.3 226.88,34 219.54,34 219.28,34.26 211.64,34.26 211.27,33.9 205.85,33.9 204.33,35.42 201.81,35.42 201.69,35.29 201.69,34.85 201.57,34.73 201.32,34.73 201.2,34.85 201.2,35.29 201.08,35.42 200.84,35.42 200.71,35.29 200.71,34.85 200.59,34.73 200.35,34.73 200.23,34.85 200.23,35.29 200.1,35.42 199.64,35.42 198.89,34.66 198.49,34.66 198.37,34.79 198.37,35.29 198.25,35.42 198,35.42 197.88,35.29 197.88,34.79 197.76,34.66 197.51,34.66 197.39,34.79 197.39,35.29 197.27,35.42 197.03,35.42 196.9,35.29 196.9,34.79 196.78,34.66 165.96,34.66 164.92,35.2 164.82,35.25 159.18,40.89
  IN3 w0.15: v2(233.82,34.76) 232.8,34.76 232.61,34.95 232.61,35.53 232.79,35.71 241.11,35.71 241.42,35.39 244.54,35.39 245.61,36.47 246.78,36.47 246.95,36.29 246.95,35.75 v2(246.79,35.58)
  BOTTOM w0.102: UC1.AL40 158.81,43.79 159.51,43.09 159.51,41.89 159.41,41.79 v2(159.33,41.79)
  BOTTOM w0.157: v2(246.79,35.58) 246.59,35.78 JDIMM1.37 ; JDIMM3.37 232.81,35.78 v2(233.82,34.76)
DDR_A_D16: length 109.1
  IN1 w0.102: v2(160.86,42.58) 161.17,42.58 162.11,41.65 162.7,41.65 163.09,42.04 168.42,42.04 169.18,41.28 174.27,41.28
  IN1 w0.122: 174.27,41.28 182.92,41.28 186.44,37.75 194.32,37.75 194.44,37.87 194.44,38.7 194.56,38.82 194.81,38.82 194.93,38.7 194.93,37.94 195.11,37.75 217.88,37.75 219.04,36.6 227.48,36.6 227.74,36.34 230.66,36.34 231.82,37.5 236.43,37.5 236.56,37.63 v2(236.56,37.99)
  IN3 w0.15: v2(251.42,38.12) 251.42,38.41 251.19,38.64 250.17,38.64 249.7,38.18 244.9,38.18 243.8,37.08 242.12,37.08 241.81,37.4 236.79,37.4 236.56,37.63 v2(236.56,37.99)
  BOTTOM w0.102: UC1.AN38 160.64,46.21 160.97,45.87 160.97,45.49 160.66,45.18 160.52,45.18 160.3,44.96 160.3,44.54 160.4,44.45 160.4,43.79 160.68,43.51 160.68,42.68 160.78,42.58 v2(160.86,42.58)
  BOTTOM w0.157: v2(236.56,37.99) 237.23,38.66 238.61,38.66 238.98,39.03 JDIMM3.50 ; JDIMM1.50 252.08,39.03 251.42,38.37 v2(251.42,38.12)
DDR_A_D17: length 107.4
  IN1 w0.122: v2(161.21,43.08) 163.6,43.08 164.22,42.45 168.59,42.45 168.92,42.13 195.72,42.13 196.99,40.85 196.99,38.94 197.12,38.82 197.36,38.82 197.48,38.94 197.48,39.63 197.6,39.75 197.85,39.75 197.97,39.63 197.97,38.73 198.09,38.61 218.76,38.61 219.91,37.45 225.51,37.45 225.64,37.57 225.64,37.75 225.76,37.87 226,37.87 226.12,37.75 226.12,37.57 226.24,37.45 226.49,37.45 226.61,37.57 226.61,37.83 226.73,37.95 226.98,37.95 227.1,37.83 227.1,37.57 227.22,37.45 227.44,37.45 227.94,37.95 231.06,37.95 231.62,38.5 235.31,38.5 235.4,38.41 v2(235.4,38.02)
  IN3 w0.15: v2(235.4,38.02) 235.4,37.74 235.22,37.56 234.75,37.56 234.5,37.32 234.5,37.03 234.63,36.9 241.6,36.9 241.92,36.59 244.02,36.59 245.11,37.67 247.82,37.67 v2(248.36,37.13)
  BOTTOM w0.102: UC1.AN40 160.64,43.88 161.08,43.44 161.08,43.21 v2(161.21,43.08)
  BOTTOM w0.157: JDIMM3.49 234.75,38.78 235.4,38.14 v2(235.4,38.02) ; v2(248.36,37.13) 246.72,38.78 JDIMM1.49
DDR_A_D18: length 106.5
  IN1 w0.122: v2(237.47,41.43) 237.47,41.85 237.33,41.98 235.48,41.98 235.22,41.72 235.22,41.3 234.52,40.6 230.63,40.6 230.34,40.31 230.01,40.31 229.81,40.51 229.27,40.51 229.15,40.39 229.15,40.09 229.03,39.97 228.78,39.97 228.66,40.09 228.66,40.39 228.54,40.51 228.3,40.51 228.18,40.39 228.18,40.09 228.05,39.97 227.81,39.97 227.69,40.09 227.69,40.39 227.57,40.51 227.32,40.51 227.2,40.39 227.2,40.09 227.08,39.97 226.83,39.97 226.71,40.09 226.71,40.39 226.59,40.51 226.35,40.51 226.22,40.39 226.22,40.09 226.1,39.97 225.86,39.97 225.74,40.09 225.74,40.39 225.61,40.51 223.87,40.51 223.75,40.39 223.75,40.09 223.63,39.97 220.52,39.97 219.57,40.92 202.53,40.92 202.41,41.04 202.41,41.78 202.29,41.91 202.04,41.91 201.92,41.78 201.92,41.74 201.8,41.62 201.56,41.62 201.43,41.74 201.43,41.78 201.31,41.91 199.51,41.91 197.32,44.09 166.27,44.09 v2(165.61,44.75)
  IN3 w0.15: v2(237.47,41.43) 237.47,41.63 237.71,41.88 238.36,41.88 238.77,41.46 240.41,41.46 240.91,41.97 242.84,41.97 243.44,42.57 244.19,42.57 244.83,41.93 246.39,41.93 247.03,42.57 252.32,42.57 252.51,42.38 v2(252.51,42.03)
  BOTTOM w0.102: v2(165.61,44.75) 165.35,44.49 164.59,44.49 164.46,44.36 164.1,44.36 163.54,43.8 163.11,43.8 162.8,44.11 162.8,46.26 UC1.AR38
  BOTTOM w0.157: v2(252.51,42.03) 252.59,42.03 252.59,42.03 JDIMM1.62 ; v2(237.47,41.43) 237.47,41.63 237.86,42.03 JDIMM3.62
DDR_A_D19: length 108.6
  IN1 w0.122: v2(166.91,44.74) 167.14,44.52 197.5,44.52 199.68,42.33 202.85,42.33 202.97,42.21 202.97,41.47 203.1,41.35 203.34,41.35 203.46,41.47 203.46,42.21 203.58,42.33 203.89,42.33 204.01,42.21 204.01,41.47 204.13,41.35 204.38,41.35 204.5,41.47 204.5,42.21 204.62,42.33 204.86,42.33 204.99,42.21 204.99,41.47 205.11,41.35 205.35,41.35 205.47,41.47 205.47,42.21 205.59,42.33 205.84,42.33 205.96,42.21 205.96,41.47 206.08,41.35 206.33,41.35 206.45,41.47 206.45,42.21 206.57,42.33 210.96,42.33 211.94,41.35 220.05,41.35 220.46,40.94 226.83,40.94 226.95,41.06 226.95,41.27 227.08,41.39 227.32,41.39 227.44,41.27 227.44,41.06 227.56,40.94 227.81,40.94 227.93,41.06 227.93,41.27 228.05,41.39 228.3,41.39 228.42,41.27 228.42,41.06 228.54,40.94 228.78,40.94 228.91,41.06 228.91,41.27 229.03,41.39 229.27,41.39 229.39,41.27 229.39,41.06 229.51,40.94 229.74,40.94 230.09,41.29 231.49,41.29 231.61,41.41 231.61,41.64 231.74,41.76 231.98,41.76 232.1,41.64 232.1,41.41 232.22,41.29 232.45,41.29 232.7,41.03 234.2,41.03 234.64,41.47 v2(234.64,41.48)
  IN3 w0.15: v2(234.64,41.48) 234.48,41.64 234.48,42.17 234.67,42.37 235.62,42.37 235.81,42.17 235.81,41.83 235.04,41.05 235.04,40.67 235.23,40.47 241.41,40.47 241.87,40.94 247.06,40.94 247.41,41.29 v2(247.41,41.6)
  BOTTOM w0.102: v2(166.91,44.74) 166.98,44.81 166.98,44.96 166.81,45.13 165.42,45.13 165.29,45.26 163.28,45.26 163.04,45.49 163.04,46.34 162.88,46.5 162.88,47.1 UC1.AR37
  BOTTOM w0.157: JDIMM1.63 246.74,42.28 v2(247.41,41.6) ; v2(234.64,41.48) 234.64,41.83 234.2,42.28 JDIMM3.63
DDR_A_D20: length 106.1
  IN1 w0.102: v2(161.53,41.64) 161.74,41.43 162.76,41.43 163.17,41.83 168.34,41.83 169.32,40.85 174.27,40.85
  IN1 w0.122: 174.27,40.85 182.74,40.85 186.26,37.33 206.72,37.33 206.84,37.2 206.84,37.04 206.96,36.92 207.21,36.92 207.33,37.04 207.33,37.2 207.45,37.33 217.71,37.33 218.86,36.17 227.31,36.17 227.57,35.91 230.83,35.91 231.99,37.07 237.86,37.07 238.02,37.23 238.02,37.77 237.9,37.89 v2(237.77,37.89)
  IN3 w0.15: v2(237.77,37.89) 242.03,37.89 242.41,38.28 244.27,38.28 244.69,38.69 249.51,38.69 250.15,39.33 252.31,39.33 252.63,39.01 252.63,38.25 v2(252.6,38.22)
  BOTTOM w0.102: UC1.AN39 160.48,45.68 160.07,45.28 160.07,44.35 160.16,44.26 160.16,43.67 160.48,43.36 160.48,42.2 161.01,41.67 161.49,41.67 v2(161.53,41.64)
  BOTTOM w0.157: JDIMM1.46 252.76,38.03 252.6,38.18 v2(252.6,38.22) ; v2(237.77,37.89) 237.9,38.03 JDIMM3.46
DDR_A_D21: length 108.5
  IN1 w0.102: v2(162.1,42.41) 163.96,42.41 164.13,42.24 168.5,42.24 169.04,41.7 174.27,41.7
  IN1 w0.122: v2(234.13,38) 234.05,38.08 233.58,38.08 233.43,37.92 232.56,37.92 232.41,38.08 231.79,38.08 231.24,37.52 228.12,37.52 227.62,37.03 219.21,37.03 218.06,38.18 196.69,38.18 196.57,38.3 196.57,40.68 196.44,40.8 196.2,40.8 196.08,40.68 196.08,38.3 195.96,38.18 195.66,38.18 195.54,38.3 195.54,41.58 195.42,41.7 174.27,41.7
  IN3 w0.15: v2(247.11,37.16) 245.32,37.16 244.25,36.09 241.71,36.09 241.4,36.41 233.95,36.41 233.2,37.16 233.2,37.72 233.48,38 v2(234.13,38)
  BOTTOM w0.102: v2(162.1,42.41) 162.1,42.73 160.88,43.96 160.88,44.46 160.97,44.55 160.97,45.2 161.2,45.42 161.2,46.24 161.07,46.37 161.07,47.08 UC1.AN37
  BOTTOM w0.157: JDIMM1.45 246.5,37.78 v2(247.11,37.16) ; v2(234.13,38) 233.91,37.78 JDIMM3.45
DDR_A_D22: length 106.7
  IN1 w0.122: v2(165.77,43.77) 165.88,43.66 196.35,43.66 196.76,43.26 196.93,43.26 197.16,43.48 197.33,43.48 197.5,43.31 197.5,43.13 197.28,42.91 197.28,42.74 197.45,42.57 197.62,42.57 197.85,42.79 198.02,42.79 198.19,42.62 198.19,42.44 197.97,42.22 197.97,42.05 199.52,40.49 200.4,40.49 200.52,40.62 200.52,41.36 200.64,41.48 200.89,41.48 201.01,41.36 201.01,40.62 201.13,40.49 201.37,40.49 201.5,40.62 201.5,41.07 201.62,41.19 201.86,41.19 201.98,41.07 201.98,40.62 202.11,40.49 219.39,40.49 220.35,39.54 229.45,39.54 229.72,39.81 230.54,39.81 230.77,40.04 234.56,40.04 235.95,41.43 v2(236.3,41.43)
  IN3 w0.15: v2(236.3,41.43) 236.3,41.4 236.73,40.97 240.62,40.97 241.11,41.46 243.05,41.46 243.6,42 244.05,42 244.62,41.43 246.6,41.43 247.23,42.06 249.98,42.06 250.43,41.61 250.77,41.61 251.22,42.06 v2(251.23,42.06)
  BOTTOM w0.102: UC1.AR39 162.47,45.3 162.13,44.96 162.13,44.49 162.22,44.4 162.22,44.11 162.94,43.4 163.71,43.4 164.27,43.96 164.63,43.96 164.76,44.08 165.46,44.08 v2(165.77,43.77)
  BOTTOM w0.157: v2(251.23,42.06) 252.27,41.03 JDIMM1.58 ; JDIMM3.58 238.64,41.03 238.58,40.97 236.68,40.97 236.3,41.34 v2(236.3,41.43)
DDR_A_D23: length 104.1
  IN1 w0.122: v2(233.48,41.48) 233.73,41.73 233.73,42.04 233.58,42.19 230.62,42.19 230.24,41.82 228.93,41.82 228.81,41.94 228.81,42.07 228.69,42.19 228.44,42.19 228.32,42.07 228.32,41.94 228.2,41.82 227.95,41.82 227.83,41.94 227.83,42.07 227.71,42.19 227.47,42.19 227.34,42.07 227.34,41.94 227.22,41.82 226.98,41.82 226.86,41.94 226.86,42.07 226.74,42.19 226.49,42.19 226.37,42.07 226.37,41.49 226.25,41.36 222.95,41.36 222.82,41.49 222.82,41.94 222.7,42.06 222.46,42.06 222.34,41.94 222.34,41.49 222.21,41.36 220.64,41.36 219.67,42.33 219.28,42.33 219.16,42.21 219.16,41.9 219.04,41.77 218.79,41.77 218.67,41.9 218.67,42.21 218.55,42.33 218.3,42.33 218.18,42.21 218.18,41.9 218.06,41.77 217.82,41.77 217.69,41.9 217.69,42.21 217.57,42.33 217.33,42.33 217.21,42.21 217.21,41.9 217.08,41.77 216.84,41.77 216.72,41.9 216.72,42.21 216.6,42.33 216.35,42.33 216.23,42.21 216.23,41.9 216.11,41.77 215.87,41.77 215.74,41.9 215.74,42.21 215.62,42.33 215.38,42.33 215.26,42.21 215.26,41.9 215.13,41.77 214.89,41.77 214.77,41.9 214.77,42.21 214.65,42.33 213.83,42.33 213.71,42.21 213.71,41.9 213.59,41.77 213.35,41.77 213.22,41.9 213.22,42.21 213.1,42.33 212.86,42.33 212.74,42.21 212.74,41.9 212.61,41.77 212.37,41.77 212.25,41.9 212.25,42.21 212.13,42.33 211.56,42.33 211.13,42.76 199.86,42.76 197.68,44.94 167.92,44.94 167.73,45.13 166.67,45.13 v2(166.29,44.75)
  IN3 w0.15: v2(247.93,41.11) 247.26,40.44 242.09,40.44 241.63,39.98 234.95,39.98 233.58,41.35 233.58,41.37 v2(233.48,41.48)
  BOTTOM w0.102: UC1.AR40 162.47,44.16 163.02,43.6 163.62,43.6 164.18,44.16 164.55,44.16 164.67,44.29 165.82,44.29 v2(166.29,44.75)
  BOTTOM w0.157: JDIMM3.59 232.38,41.28 232.61,41.04 233.12,41.04 233.48,41.4 v2(233.48,41.48) ; JDIMM1.59 246.5,41.28 246.65,41.13 247.91,41.13 v2(247.93,41.11)
DDR_A_D24: length 96
  IN1 w0.122: v2(167.99,46.68) 167.99,45.92 168.11,45.8 187.23,45.8 187.46,45.57 197.94,45.57 200.12,43.39 212.05,43.39 212.47,42.96 227.25,42.96 227.4,42.82 237.39,42.82 237.9,42.31 238.23,42.31 238.4,42.49 238.4,42.82 237.99,43.23 v2(237.99,43.24)
  IN3 w0.15: v2(252.55,44.07) 252.55,44.32 252.07,44.8 250.55,44.8 249.53,43.79 242.94,43.79 242.33,43.18 239.31,43.18 238.79,43.71 238.18,43.71 237.99,43.52 v2(237.99,43.24)
  BOTTOM w0.102: v2(167.99,46.68) 167.99,47.4 167.88,47.51 UC1.AW37
  BOTTOM w0.157: JDIMM1.70 252.59,44.03 v2(252.55,44.07) ; v2(237.99,43.24) 237.99,43.45 238.57,44.03 JDIMM3.70
DDR_A_D25: length 99.7
  IN1 w0.102: 174.27,46.9 171.92,46.9 171.75,46.73 v2(171.75,46.7)
  IN1 w0.122: 174.27,46.9 184.09,46.9 184.32,47.14 187.09,47.14 187.81,46.43 198.29,46.43 199.7,45.01 212.88,45.01 214.08,43.82 217.85,43.82 217.98,43.94 217.98,44.26 218.1,44.38 218.34,44.38 218.46,44.26 218.46,43.94 218.59,43.82 218.83,43.82 218.95,43.94 218.95,43.97 219.07,44.09 219.32,44.09 219.44,43.97 219.44,43.94 219.56,43.82 225.99,43.82 226.09,43.92 226.09,44.25 226.21,44.38 226.46,44.38 226.58,44.25 226.58,43.99 226.7,43.86 226.95,43.86 227.07,43.99 227.07,44.25 227.19,44.38 227.43,44.38 227.56,44.25 227.56,43.85 227.63,43.78 234.89,43.78 235.16,44.05 v2(235.16,44.28)
  IN3 w0.15: v2(235.16,44.28) 235.16,44.01 234.97,43.83 234.18,43.83 233.71,43.36 233.29,43.36 233.06,43.12 233.06,42.81 233.25,42.62 233.94,42.62 234.38,43.06 235.43,43.06 236.11,43.74 237.13,43.74 237.64,44.24 239.9,44.24 240.51,44.85 244.68,44.85 244.96,44.58 246.5,44.58 v2(246.81,44.28)
  BOTTOM w0.102: v2(171.75,46.7) 171.75,46.7 170.71,45.67 166.19,45.67 165.73,46.13 164.75,46.13 164.29,46.59 UC1.AU38
  BOTTOM w0.157: JDIMM3.71 233.07,44.28 233.6,44.8 234.63,44.8 v2(235.16,44.28) ; JDIMM1.71 v2(246.81,44.28)
DDR_A_D26: length 98.3
  IN1 w0.102: v2(172.33,49.79) 172.62,50.08 174.27,50.08
  IN1 w0.122: 174.27,50.08 190.8,50.08 190.92,49.95 190.92,49.36 191.04,49.24 191.28,49.24 191.41,49.36 191.41,49.95 191.53,50.08 191.77,50.08 191.89,49.95 191.89,49.36 192.02,49.24 192.26,49.24 192.38,49.36 192.38,49.95 192.5,50.08 192.75,50.08 192.87,49.95 192.87,49.36 192.99,49.24 193.24,49.24 193.36,49.36 193.36,49.95 193.48,50.08 193.72,50.08 193.84,49.95 193.84,49.36 193.97,49.24 194.21,49.24 194.33,49.36 194.33,49.95 194.45,50.08 194.7,50.08 194.82,49.95 194.82,49.36 194.94,49.24 195.19,49.24 195.31,49.36 195.31,49.95 195.43,50.08 195.67,50.08 195.8,49.95 195.8,49.36 195.92,49.24 199.46,49.24 200.26,48.43 212.19,48.43 212.53,48.09 232.34,48.09 232.46,47.97 232.46,47.8 232.58,47.67 232.82,47.67 232.95,47.8 232.95,47.97 233.07,48.09 233.37,48.09 v2(233.69,47.77)
  IN3 w0.15: v2(233.69,47.77) 233.4,47.48 233.4,46.04 233.65,45.79 235.03,45.79 236,46.76 239.14,46.76 239.78,47.4 246.8,47.4 v2(246.91,47.52)
  BOTTOM w0.102: UC1.AV35 165.21,49.5 165.62,49.91 166.42,49.91 166.45,49.88 166.95,49.88 167.65,50.57 171.55,50.57 v2(172.33,49.79)
  BOTTOM w0.157: JDIMM1.83 246.67,47.28 v2(246.91,47.52) ; v2(233.69,47.77) 233.11,47.77 232.62,47.28 JDIMM3.83
DDR_A_D27: length 95.9
  IN1 w0.122: v2(169.82,49.78) 170.5,49.1 187.91,49.1 188.62,48.39 199.1,48.39 199.91,47.58 211.84,47.58 212.18,47.24 214.22,47.24 215.12,46.34 225.22,46.34 225.63,46.76 230.16,46.76 230.2,46.72 236.71,46.72 236.83,46.84 239.36,46.84 239.48,46.97 239.48,47.61 239.36,47.73 v2(238.38,47.73)
  IN3 w0.15: v2(238.38,47.73) 239.13,48.48 244.61,48.48 244.91,48.78 249.23,48.78 249.63,48.38 249.63,48.11 250.67,47.07 251.59,47.07 251.99,47.48 v2(251.99,47.53)
  BOTTOM w0.102: v2(169.82,49.78) 169.82,50.06 169.71,50.16 168.13,50.16 167.31,49.34 UC1.AW35
  BOTTOM w0.157: v2(238.38,47.73) 238.59,47.53 JDIMM3.84 ; v2(251.99,47.53) 251.99,47.53 JDIMM1.84
DDR_A_D28: length 99.8
  IN1 w0.122: v2(236.83,43.24) 236.83,43.35 237.49,44.02 237.49,44.37 237.26,44.6 236.8,44.6 235.56,43.35 227.49,43.35 227.46,43.39 212.65,43.39 212.22,43.82 200.3,43.82 198.11,46 187.63,46 187.4,46.23 170.98,46.23 v2(170.53,46.68)
  IN3 w0.15: v2(251.3,44.09) 251.3,43.67 250.91,43.28 243.15,43.28 242.54,42.68 237.32,42.68 236.83,43.17 v2(236.83,43.24)
  BOTTOM w0.102: v2(170.53,46.68) 169.72,45.87 166.28,45.87 165.69,46.46 165.69,46.73 165.35,47.07 164.94,47.07 164.5,47.51 UC1.AU37
  BOTTOM w0.157: v2(236.83,43.24) 236.83,43.16 237.18,42.8 238.78,42.8 239.01,43.03 JDIMM3.66 ; JDIMM1.66 251.84,43.03 251.3,43.57 v2(251.3,44.09)
DDR_A_D29: length 97.9
  IN1 w0.122: v2(233.94,44.28) 233.94,44.31 233.66,44.59 233.63,44.59 233.49,44.73 233.01,44.73 232.88,44.6 232.88,44.4 232.76,44.28 232.48,44.28 232.36,44.4 232.36,44.9 232.24,45.02 232,45.02 231.88,44.9 231.88,44.4 231.75,44.28 231.51,44.28 231.39,44.4 231.39,44.9 231.27,45.02 231.02,45.02 230.9,44.9 230.9,44.4 230.78,44.28 230.53,44.28 230.41,44.4 230.41,44.9 230.29,45.02 230.05,45.02 229.92,44.9 229.92,44.4 229.8,44.28 228.33,44.28 227.8,44.81 223.44,44.81 223.2,44.57 222.79,44.57 222.55,44.81 222.32,44.81 222.2,44.69 222.2,44.42 222.07,44.3 221.83,44.3 221.71,44.42 221.71,44.69 221.59,44.81 214.49,44.81 213.86,45.44 199.88,45.44 198.47,46.85 187.99,46.85 187.27,47.57 183.3,47.57 183.07,47.33 169.89,47.33 169.26,46.7 v2(169.26,46.68)
  IN3 w0.15: v2(248.06,44.35) 248.06,44.85 247.75,45.16 245.13,45.16 244.91,45.39 240.31,45.39 239.65,44.73 234.16,44.73 233.94,44.51 v2(233.94,44.28)
  BOTTOM w0.102: v2(169.26,46.68) 168.66,46.07 167.21,46.07 167.11,46.18 167.11,46.82 166.85,47.07 165.89,47.07 165.44,47.51 UC1.AV37
  BOTTOM w0.157: v2(233.94,44.28) 232.94,43.28 JDIMM3.67 ; v2(248.06,44.35) 246.99,43.28 JDIMM1.67
DDR_A_D30: length 101.8
  IN1 w0.122: v2(169.11,49.78) 169.11,50.01 169.6,50.5 196.22,50.5 196.34,50.38 196.34,49.79 196.47,49.67 196.71,49.67 196.83,49.79 196.83,50.38 196.95,50.5 197.2,50.5 197.32,50.38 197.32,49.79 197.44,49.67 197.69,49.67 197.81,49.79 197.81,50.38 197.93,50.5 198.8,50.5 200.44,48.86 212.37,48.86 212.71,48.52 227.86,48.52 227.99,48.64 227.99,48.84 228.11,48.96 228.35,48.96 228.47,48.84 228.47,48.64 228.6,48.52 228.84,48.52 228.96,48.64 228.96,48.81 229.08,48.94 229.33,48.94 229.45,48.81 229.45,48.64 229.57,48.52 229.81,48.52 229.94,48.64 229.94,48.72 230.06,48.84 230.3,48.84 230.42,48.72 230.42,48.64 230.55,48.52 230.79,48.52 230.91,48.64 230.91,48.67 231.03,48.79 231.28,48.79 231.4,48.67 231.4,48.64 231.52,48.52 234.74,48.52 234.92,48.34 v2(234.92,47.81)
  IN3 w0.15: v2(234.92,47.81) 234.43,47.33 234.43,47.05 234.77,46.71 235.24,46.71 235.75,47.22 238.82,47.22 239.46,47.86 245.01,47.86 245.49,48.33 247.5,48.33 v2(248.31,47.52)
  BOTTOM w0.102: UC1.AT35 163.81,48.91 164.52,48.91 164.65,48.78 165.54,48.78 165.77,49.01 166.34,49.01 166.34,49.01 167.6,49.01 168.38,49.78 v2(169.11,49.78)
  BOTTOM w0.157: JDIMM3.79 232.45,46.28 233.39,47.22 234.32,47.22 v2(234.92,47.81) ; JDIMM1.79 247.06,46.28 v2(248.31,47.52)
DDR_A_D31: length 100.3
  IN1 w0.102: v2(171.09,49.78) 171.46,49.41 174.15,49.41 174.27,49.53
  IN1 w0.122: v2(237.09,47.81) 237.09,47.71 236.53,47.15 232.5,47.15 231.98,47.67 212.35,47.67 212.01,48.01 200.09,48.01 199.28,48.81 190.49,48.81 190.37,48.94 190.37,49.53 190.25,49.65 190,49.65 189.88,49.53 189.88,48.94 189.76,48.81 189.52,48.81 189.39,48.94 189.39,49.53 189.27,49.65 189.03,49.65 188.91,49.53 188.91,49.19 188.79,49.07 188.54,49.07 188.42,49.19 188.42,49.53 188.3,49.65 174.39,49.65 174.27,49.53
  IN3 w0.15: v2(237.09,47.81) 237.09,47.84 238.18,48.93 244.36,48.93 244.86,49.43 249.26,49.43 250.83,47.86 v2(250.83,47.52)
  BOTTOM w0.102: UC1.AU35 164.68,49.34 165.02,49.01 165.4,49.01 165.72,49.32 165.72,49.46 165.93,49.68 166.33,49.68 166.44,49.57 167.06,49.57 167.85,50.37 170.5,50.37 v2(171.09,49.78)
  BOTTOM w0.157: v2(237.09,47.81) 237.09,47.64 237.77,46.96 238.51,46.96 238.94,46.53 JDIMM3.80 ; v2(250.83,47.52) 250.83,47.34 251.64,46.53 JDIMM1.80
DDR_A_D32: length 100.7
  IN1 w0.122: v2(168.37,76.21) 168.69,75.89 190.43,75.89 191.52,74.8 198.62,74.8 198.74,74.68 198.74,74.14 198.86,74.01 199.11,74.01 199.23,74.14 199.23,74.68 199.35,74.8 199.6,74.8 199.72,74.68 199.72,74.14 199.84,74.01 200.08,74.01 200.21,74.14 200.21,74.68 200.33,74.8 200.57,74.8 200.69,74.68 200.69,74.14 200.81,74.01 201.06,74.01 201.18,74.14 201.18,74.68 201.3,74.8 201.55,74.8 201.67,74.68 201.67,74.14 201.79,74.01 202.03,74.01 202.16,74.14 202.16,74.68 202.28,74.8 213.19,74.8 213.67,74.33 217.65,74.33 217.96,74.01 229.06,74.01 229.21,74.17 229.74,74.17 230.69,73.21 233.78,73.21 234.28,72.71 238.07,72.71 238.48,73.12 v2(238.48,73.15)
  IN3 w0.15: v2(238.48,73.15) 238.48,72.63 238.95,72.16 243.07,72.16 243.45,71.77 249.62,71.77 250.52,72.67 251.52,72.67 251.66,72.82 251.66,73.38 251.82,73.53 252.68,73.53 252.89,73.34 252.89,72.43 252.69,72.22 v2(252.47,72.22)
  BOTTOM w0.102: v2(168.37,76.21) 168.35,76.23 UC1.AY8
  BOTTOM w0.157: JDIMM3.174 238.82,72.03 238.48,72.36 v2(238.48,73.15) ; v2(252.47,72.22) 252.67,72.03 JDIMM1.174
DDR_A_D33: length 104.2
  IN1 w0.122: v2(234.97,73.15) 234.97,73.45 234.87,73.56 234.04,73.56 233.95,73.64 233.38,73.64 233.25,73.76 233.25,74.11 233.13,74.23 232.89,74.23 232.77,74.11 232.77,73.76 232.64,73.64 232.4,73.64 232.28,73.76 232.28,74.11 232.16,74.23 231.91,74.23 231.79,74.11 231.79,73.76 231.67,73.64 230.87,73.64 229.61,74.9 228.62,74.9 228.5,74.78 228.5,74.51 228.43,74.44 228,74.44 227.87,74.56 227.87,74.73 227.75,74.85 227.51,74.85 227.39,74.73 227.39,74.56 227.27,74.44 227.02,74.44 226.9,74.56 226.9,74.77 226.78,74.89 226.53,74.89 226.41,74.77 226.41,74.56 226.29,74.44 218.13,74.44 217.82,74.75 217.04,74.75 216.92,74.87 216.92,75.11 216.8,75.23 216.55,75.23 216.43,75.11 216.43,74.87 216.31,74.75 216.07,74.75 215.94,74.87 215.94,75.11 215.82,75.23 215.58,75.23 215.46,75.11 215.46,74.87 215.33,74.75 215.09,74.75 214.97,74.87 214.97,75.11 214.85,75.23 191.7,75.23 190.22,76.71 173.23,76.71 v2(171.47,78.47)
  IN3 w0.15: v2(234.97,73.15) 234.97,72.76 234.39,72.18 234.39,70.44 234.85,69.98 247.67,69.98 248.49,70.8 v2(248.49,70.82)
  BOTTOM w0.102: UC1.AW8 165.21,76.07 165.6,75.68 166.67,75.68 167.02,75.32 169.03,75.32 171.47,77.76 v2(171.47,78.47)
  BOTTOM w0.157: JDIMM1.173 247.54,71.78 v2(248.49,70.82) ; JDIMM3.173 233.6,71.78 v2(234.97,73.15)
DDR_A_D34: length 102.8
  IN1 w0.122: v2(233.88,77.15) 231.34,77.15 230.56,77.93 226.65,77.93 226.23,78.35 221.75,78.35 221.66,78.43 217.24,78.43 216.7,78.97 212.37,78.97 212.36,78.97 209.25,78.97 208.87,78.6 206.15,78.6 205.63,78.08 204.85,78.08 204.72,78.2 204.72,78.77 204.6,78.89 204.36,78.89 204.24,78.77 204.24,78.2 204.12,78.08 203.78,78.08 203.66,78.2 203.66,78.48 203.53,78.6 203.29,78.6 203.17,78.48 203.17,78.2 203.05,78.08 202.81,78.08 202.69,78.2 202.69,78.48 202.57,78.6 202.32,78.6 202.2,78.48 202.2,78.2 202.08,78.08 201.84,78.08 201.71,78.2 201.71,78.48 201.59,78.6 201.35,78.6 201.23,78.48 201.23,78.2 201.1,78.08 200.83,78.08 200.71,78.2 200.71,78.45 200.59,78.57 200.35,78.57 200.22,78.45 200.22,78.2 200.1,78.08 192.83,78.08 191.38,79.52 175.05,79.52 172.71,81.86 171.81,81.86 171.39,81.44 v2(170.58,81.44)
  IN3 w0.15: v2(233.88,77.15) 233.62,76.63 233.67,76.49 234.25,75.9 235.88,75.9 236.99,74.79 238.88,74.79 239.59,74.08 242.99,74.08 243.21,73.86 244.52,73.86 244.78,73.74 245.06,73.46 247.61,73.46 247.95,73.81 v2(248.39,74.87)
  BOTTOM w0.102: UC1.AV6 164.63,78.4 165.65,78.4 165.88,78.63 166.47,78.63 166.56,78.55 166.96,78.55 167.42,79.01 167.42,79.63 169.23,81.44 v2(170.58,81.44)
  BOTTOM w0.157: v2(233.88,77.15) 233.88,76.37 232.79,75.28 JDIMM3.187 ; v2(248.39,74.87) 248.39,74.94 247.94,75.39 246.69,75.39 246.57,75.28 JDIMM1.187
DDR_A_D35: length 104.4
  IN1 w0.122: v2(237.39,77.15) 237.39,77.75 237.13,78.01 231.69,78.01 230.25,79.45 227.5,79.45 227.38,79.33 227.38,79.27 227.26,79.14 227.01,79.14 226.89,79.27 226.89,79.33 226.77,79.45 226.34,79.45 226.11,79.67 222.37,79.67 222.14,79.44 217.89,79.44 217.46,79.86 192.25,79.86 191.74,80.38 175.4,80.38 v2(172.46,83.32)
  IN3 w0.15: v2(237.39,77.15) 237.39,76.96 237.77,76.58 238.35,76.58 238.58,76.8 240.15,76.8 240.9,76.05 243.89,76.05 244.08,75.86 251.17,75.86 251.76,75.26 251.76,74.6 251.53,74.37 251.05,74.37 250.72,74.7 v2(250.72,74.87)
  BOTTOM w0.102: v2(172.46,83.32) 172.46,83.33 170.5,83.33 166.66,79.48 166.11,79.48 165.66,79.03 165.66,78.91 165.39,78.64 164.52,78.64 164.34,78.46 163.78,78.46 UC1.AU6
  BOTTOM w0.157: JDIMM3.186 238.64,75.03 238.64,75.03 237.39,76.27 v2(237.39,77.15) ; v2(250.72,74.87) 250.72,74.98 251.05,75.31 252.68,75.31 252.96,75.03 JDIMM1.186
DDR_A_D36: length 105.7
  IN1 w0.122: v2(237.31,73.15) 237.31,73.51 237.46,73.66 238.18,73.66 238.25,73.73 238.25,74.39 238.17,74.47 234.33,74.47 233.72,75.08 230.64,75.08 229.96,75.76 225.84,75.76 225.52,76.08 192.05,76.08 190.57,77.56 173.42,77.56 171.83,79.15 170.46,79.15 170.08,78.76 170.08,78.43 169.33,77.69 v2(169.33,77.1)
  IN3 w0.15: v2(251.3,72.22) 251.3,72.16 251.69,71.78 251.69,71.52 251.4,71.24 251.08,71.24 250.89,71.44 250.41,71.44 250.32,71.35 250.32,70.79 250.17,70.64 249.68,70.64 249.55,70.76 249.55,71.12 249.39,71.28 243.62,71.28 243.36,71.02 239.39,71.02 237.31,73.1 v2(237.31,73.15)
  BOTTOM w0.102: UC1.AU8 163.81,76.66 164.77,76.66 164.89,76.79 165.68,76.79 165.9,76.57 168.21,76.57 168.74,77.1 v2(169.33,77.1)
  BOTTOM w0.157: JDIMM3.170 238.37,71.03 237.31,72.08 v2(237.31,73.15) ; v2(251.3,72.22) 251.3,71.55 251.83,71.03 JDIMM1.170
DDR_A_D37: length 106.5
  IN1 w0.102: 173.38,77.13 171.64,78.88 170.73,78.88 170.38,78.54 170.38,78.15 v2(170.27,78.04)
  IN1 w0.122: 173.38,77.13 190.4,77.13 191.87,75.65 218.9,75.65 219.02,75.53 219.02,74.99 219.14,74.87 219.39,74.87 219.51,74.99 219.51,75.53 219.63,75.65 225.31,75.65 225.63,75.33 229.78,75.33 230.46,74.65 233.54,74.65 234.15,74.05 235.8,74.05 236.14,73.71 v2(236.14,73.15)
  IN3 w0.15: v2(247.16,70.78) 247.16,70.77 246.87,70.48 246.57,70.48 246.27,70.78 245.81,70.78 245.51,70.48 245.05,70.48 244.74,70.78 244.29,70.78 243.98,70.48 237.94,70.48 237.75,70.67 237.75,71.69 237.55,71.88 237.17,71.88 236.98,71.69 236.98,70.67 236.79,70.48 236.41,70.48 236.22,70.67 236.22,71.64 236.03,71.83 235.65,71.83 235.46,71.64 235.46,70.67 235.27,70.48 235,70.48 234.85,70.63 234.85,71.99 235.47,72.62 235.99,72.62 236.14,72.77 v2(236.14,73.15)
  BOTTOM w0.102: UC1.AV8 164.68,76.23 165.02,76.57 165.4,76.57 165.72,76.25 165.72,76.11 165.93,75.89 167.09,75.89 167.19,75.79 168.58,75.79 170.27,77.49 v2(170.27,78.04)
  BOTTOM w0.157: v2(247.16,70.78) 247.15,70.78 JDIMM1.169 ; v2(236.14,73.15) 236.14,72.92 234,70.78 JDIMM3.169
DDR_A_D38: length 103.4
  IN1 w0.122: v2(235.05,77.15) 235.05,76.78 234.93,76.66 231.23,76.66 230.38,77.5 226.47,77.5 226.05,77.92 221.57,77.92 221.49,78 216.37,78 216.24,77.88 216.24,77.87 216.12,77.75 215.88,77.75 215.76,77.87 215.76,77.88 215.63,78 215.41,78 215.29,77.88 215.29,77.74 215.17,77.62 214.92,77.62 214.8,77.74 214.8,77.88 214.68,78 212.73,78 212.64,78.09 209.22,78.09 208.78,77.65 207.7,77.65 207.58,77.77 207.58,78.05 207.45,78.17 207.21,78.17 207.09,78.05 207.09,77.77 206.97,77.65 206.72,77.65 206.6,77.77 206.6,77.96 206.48,78.08 206.23,78.08 206.11,77.96 206.11,77.77 205.99,77.65 192.65,77.65 191.21,79.1 173.35,79.1 171.53,80.92 170.89,80.92 170.47,80.5 v2(169.64,80.5)
  IN3 w0.15: v2(247.22,74.87) 247.22,74.81 247.5,74.53 247.5,74.05 247.4,73.96 246.87,73.96 246.62,74.2 246.62,74.74 246.51,74.85 245.97,74.85 245.85,74.72 245.85,74.16 245.64,73.96 245.26,73.96 245.15,74.07 244.97,74.25 244.97,74.77 244.89,74.85 244.15,74.85 244.07,74.76 244.07,74.45 243.98,74.36 243.41,74.36 243.19,74.58 242.9,74.58 242.71,74.77 242.71,74.87 242.52,75.06 242.14,75.06 241.95,74.87 241.95,74.77 241.76,74.58 241.37,74.58 241.18,74.77 241.18,74.87 240.99,75.06 240.61,75.06 240.42,74.87 240.42,74.77 240.23,74.58 239.79,74.58 239.42,74.95 239.42,75.44 239.27,75.59 238.02,75.59 237.72,75.28 237.2,75.28 236.93,75.55 236.93,75.97 236.85,76.05 236.43,76.05 236.08,76.4 234.8,76.4 234.77,76.43 234.77,76.82 234.89,76.93 234.89,76.99 v2(235.05,77.15)
  BOTTOM w0.102: v2(169.64,80.5) 168.88,80.5 167.77,79.4 167.77,78.99 167.08,78.29 166.46,78.29 166.36,78.39 165.93,78.39 165.6,78.06 UC1.AW6
  BOTTOM w0.157: v2(235.05,77.15) 235.05,76.89 233.68,75.51 233.68,74.88 233.08,74.28 JDIMM3.183 ; v2(247.22,74.87) 247.42,74.67 247.42,74.6 246.82,74.01 246.59,74.01 246.32,74.28 JDIMM1.183
DDR_A_D39: length 102.9
  IN1 w0.122: v2(236.22,77.15) 236.21,77.16 236.21,77.21 235.85,77.58 231.51,77.58 230.74,78.36 226.83,78.36 225.93,79.25 222.55,79.25 222.31,79.01 217.71,79.01 217.29,79.43 192.07,79.43 191.56,79.95 175.23,79.95 172.8,82.37 171.53,82.37 v2(171.52,82.38)
  IN3 w0.15: v2(236.22,77.15) 236.22,76.96 236.48,76.7 236.95,76.7 237.56,76.08 238.77,76.08 239,76.31 239.95,76.31 240,76.25 240,75.72 240.16,75.56 242.72,75.56 243.2,75.08 243.68,75.08 243.97,75.36 249.52,75.36 249.67,75.21 249.67,74.98 v2(249.56,74.87)
  BOTTOM w0.102: UC1.AY6 167.19,78.06 168.73,79.6 169.52,79.6 171.52,81.6 v2(171.52,82.38)
  BOTTOM w0.157: JDIMM1.182 252.58,74.03 252.43,74.18 252.43,74.69 252.27,74.85 251.95,74.85 251.8,74.69 251.8,73.44 251.74,73.38 250.98,73.38 250.9,73.45 250.9,74.19 250.75,74.34 249.99,74.34 249.56,74.77 v2(249.56,74.87) ; v2(236.22,77.15) 236.22,76.22 238.42,74.03 JDIMM3.182
DDR_A_D40: length 107.9
  IN1 w0.122: v2(234.21,79.34) 231.86,79.34 230.11,81.08 218.8,81.08 218.71,80.99 214.9,80.99 214.83,80.92 210.86,80.92 210.41,81.36 204.98,81.36 204.86,81.24 204.86,81.04 204.73,80.92 204.49,80.92 204.37,81.04 204.37,81.67 204.25,81.79 204,81.79 203.88,81.67 203.88,81.04 203.76,80.92 203.52,80.92 203.39,81.04 203.39,81.67 203.27,81.79 203.03,81.79 202.91,81.67 202.91,81.04 202.78,80.92 202.54,80.92 202.42,81.04 202.42,81.67 202.3,81.79 200.09,81.79 199.96,81.67 199.96,81.04 199.84,80.92 199.6,80.92 199.48,81.04 199.48,81.67 199.35,81.79 199.11,81.79 198.99,81.67 198.99,81.04 198.87,80.92 198.62,80.92 198.5,81.04 198.5,81.67 198.38,81.79 198.14,81.79 198.01,81.67 198.01,81.04 197.89,80.92 197.65,80.92 197.53,81.04 197.53,81.67 197.4,81.79 197.16,81.79 197.04,81.67 197.04,81.04 196.92,80.92 196.67,80.92 196.55,81.04 196.55,81.67 196.43,81.79 196.19,81.79 196.06,81.67 196.06,81.04 195.94,80.92 195.7,80.92 195.58,81.04 195.58,81.67 195.45,81.79 195.21,81.79 195.09,81.67 195.09,81.04 194.97,80.92 194.72,80.92 194.6,81.04 194.6,81.67 194.48,81.79 194.23,81.79 194.11,81.67 194.11,81.04 193.99,80.92 193.77,80.92 193.65,81.04 193.65,81.56 193.52,81.68 193.28,81.68 193.16,81.56 193.16,81.04 193.04,80.92 192.69,80.92 191.82,81.79 175.55,81.79 173.41,83.94 171.19,83.94 170.47,83.22 v2(168.77,83.22)
  IN3 w0.15: v2(234.21,79.34) 234.09,79.34 233.4,78.65 233.4,78.08 233.55,77.93 235.36,77.93 235.62,77.66 238.1,77.66 238.26,77.5 244.13,77.5 244.58,77.05 v2(246.84,77.05)
  BOTTOM w0.102: UC1.AY4 166.24,79.89 168.77,82.43 v2(168.77,83.22)
  BOTTOM w0.157: v2(246.84,77.05) 246.62,77.28 JDIMM1.195 ; v2(234.21,79.34) 234.21,78.75 232.74,77.28 JDIMM3.195
DDR_A_D41: length 111.1
  IN1 w0.102: 169.44,84.55 167.64,82.75 167.64,82.48 v2(167.84,82.28)
  IN1 w0.122: 169.44,84.55 175.46,84.55 177.37,82.64 179.23,82.64 179.89,83.3 195.58,83.3 196.24,82.64 205.87,82.64 206.29,82.22 210.68,82.22 210.95,82.49 211.5,82.49 211.62,82.37 211.62,81.89 211.75,81.77 211.99,81.77 212.11,81.89 212.11,82.37 212.23,82.49 212.46,82.49 212.58,82.37 212.58,82.15 212.7,82.03 212.91,82.03 213.07,82.19 213.07,82.37 213.19,82.49 218.31,82.49 218.43,82.37 218.43,82.06 218.55,81.93 218.8,81.93 218.92,82.06 218.92,82.44 219.04,82.56 219.28,82.56 219.41,82.44 219.41,82.06 219.53,81.93 219.77,81.93 219.89,82.06 219.89,82.44 220.02,82.56 220.26,82.56 220.38,82.44 220.38,82.06 220.5,81.93 220.75,81.93 220.87,82.06 220.87,82.44 220.99,82.56 221.21,82.56 221.34,82.44 221.34,82.06 221.46,81.93 221.7,81.93 221.82,82.06 221.82,82.44 221.95,82.56 225.08,82.56 225.2,82.44 225.2,82.06 225.32,81.93 225.57,81.93 225.69,82.06 225.69,82.44 225.81,82.56 226.05,82.56 226.18,82.44 226.18,82.06 226.3,81.93 226.54,81.93 226.66,82.06 226.66,82.44 226.79,82.56 229.83,82.56 232.21,80.19 237.46,80.19 237.58,80.07 237.58,79.88 237.46,79.75 236.67,79.75 236.55,79.63 v2(236.55,79.34)
  IN3 w0.15: v2(250.35,77.05) 250.35,77.1 249.95,77.5 248.32,77.5 247.78,78.04 244.99,78.04 244.54,78.49 239.7,78.49 238.57,78.59 238.51,78.65 238.06,78.65 236.96,78.89 236.94,78.89 236.68,79.15 236.68,79.23 v2(236.55,79.34)
  BOTTOM w0.102: v2(167.84,82.28) 166.97,82.28 165.67,80.98 165.67,80.47 165.46,80.26 165,80.26 164.63,79.89 UC1.AV4
  BOTTOM w0.157: v2(236.55,79.34) 236.44,79.23 236.44,78.16 236.72,77.87 238.18,77.87 239.02,77.03 JDIMM3.194 ; v2(250.35,77.05) 250.47,76.93 252.78,76.93 252.87,77.03 JDIMM1.194
DDR_A_D42: length 108.5
  IN1 w0.122: v2(234.52,82.26) 234.27,82.01 232.55,82.01 230.21,84.35 226.23,84.35 226.06,84.53 212.32,84.53 212.14,84.36 200.76,84.36 200.16,84.96 200.16,85.8 200.04,85.93 199.79,85.93 199.67,85.8 199.67,84.96 199.55,84.84 199.31,84.84 199.18,84.96 199.18,85.8 199.06,85.93 198.82,85.93 198.7,85.8 198.7,84.96 198.57,84.84 198.33,84.84 198.21,84.96 198.21,85.8 198.09,85.93 197.84,85.93 197.72,85.8 197.72,84.96 197.6,84.84 197.35,84.84 197.23,84.96 197.23,85.8 197.11,85.93 196.87,85.93 196.75,85.8 196.75,84.96 196.62,84.84 196.37,84.84 196.24,84.96 196.24,85.28 196.12,85.41 195.88,85.41 195.76,85.28 195.76,84.96 195.63,84.84 195.37,84.84 195.25,84.96 195.25,85.37 195.13,85.49 194.89,85.49 194.76,85.37 194.76,84.96 194.64,84.84 194.4,84.84 194.28,84.96 194.28,85.75 194.15,85.88 193.91,85.88 193.79,85.75 193.79,84.96 193.67,84.84 183.2,84.84 182.48,85.56 177.39,85.56 176.86,86.09 168.47,86.09 166.15,83.77 165.11,83.77 v2(164.69,84.19)
  IN3 w0.15: v2(247.52,79.93) 245.92,79.93 245.35,80.51 234.68,80.51 234.34,80.85 234.34,82.08 v2(234.52,82.26)
  BOTTOM w0.102: UC1.AT1 162.62,82.79 162.62,83.49 163.31,84.19 v2(164.69,84.19)
  BOTTOM w0.157: v2(247.52,79.93) 247.18,80.28 JDIMM1.207 ; v2(234.52,82.26) 234.52,81.94 232.85,80.28 JDIMM3.207
DDR_A_D43: length 108.7
  IN1 w0.122: v2(167.5,87.01) 167.57,87.01 167.94,87.37 203.31,87.37 205.04,85.64 211.6,85.64 211.78,85.81 219.86,85.81 220.6,86.55 225.85,86.55 226.28,86.12 230.61,86.12 233.03,83.7 237.45,83.7 239.22,81.94 239.58,81.94 239.71,82.06 239.71,82.51 239.83,82.64 240.07,82.64 240.19,82.51 240.19,82.06 240.32,81.94 240.56,81.94 240.68,82.06 240.68,82.58 240.8,82.7 240.98,82.7 241.17,82.51 241.17,82.06 241.29,81.94 241.83,81.94 242.25,81.53 v2(242.25,81.52)
  IN3 w0.15: v2(242.25,81.52) 242.25,81.77 242.47,81.99 246.35,81.99 246.92,81.42 248.35,81.42 248.68,81.75 249.14,81.75 249.46,81.42 251.77,81.42 251.78,81.42 253.48,81.42 253.62,81.28 253.62,80.18 253.47,80.03 252.85,80.03 v2(252.47,80.41)
  BOTTOM w0.102: UC1.AT2 162.31,81.72 161.9,82.12 161.9,83.05 161.99,83.14 161.99,83.73 165.27,87.01 167.04,87.01
  BOTTOM w0.157: v2(242.25,81.52) 242.25,81.31 241.46,80.53 JDIMM3.208 ; 167.04,87.01 v2(167.5,87.01) ; v2(252.47,80.41) 252.59,80.53 JDIMM1.208
DDR_A_D44: length 111.1
  IN1 w0.122: v2(235.38,79.34) 235.38,79.65 235.27,79.76 232.03,79.76 230.29,81.51 218.63,81.51 218.53,81.41 214.72,81.41 214.65,81.34 211.03,81.34 210.58,81.79 204.85,81.79 204.42,82.22 191.73,82.22 191.6,82.34 191.6,82.64 191.48,82.76 191.24,82.76 191.12,82.64 191.12,82.34 190.99,82.22 190.75,82.22 190.63,82.34 190.63,82.75 190.51,82.87 190.26,82.87 190.14,82.75 190.14,82.34 190.02,82.22 189.78,82.22 189.65,82.34 189.65,82.75 189.53,82.87 189.29,82.87 189.17,82.75 189.17,82.34 189.04,82.22 188.8,82.22 188.68,82.34 188.68,82.75 188.56,82.87 188.31,82.87 188.19,82.75 188.19,82.34 188.07,82.22 187.82,82.22 187.7,82.34 187.7,82.75 187.58,82.87 187.34,82.87 187.21,82.75 187.21,82.34 187.09,82.22 186.85,82.22 186.73,82.34 186.73,82.75 186.61,82.87 186.36,82.87 186.24,82.75 186.24,82.34 186.12,82.22 185.87,82.22 185.75,82.34 185.75,82.75 185.63,82.87 185.39,82.87 185.26,82.75 185.26,82.34 185.14,82.22 184.9,82.22 184.78,82.34 184.78,82.75 184.65,82.87 184.41,82.87 184.29,82.75 184.29,82.34 184.17,82.22 183.92,82.22 183.8,82.34 183.8,82.75 183.68,82.87 183.44,82.87 183.31,82.75 183.31,82.34 183.19,82.22 182.95,82.22 182.83,82.34 182.83,82.75 182.7,82.87 182.46,82.87 182.34,82.75 182.34,82.34 182.22,82.22 181.97,82.22 181.85,82.34 181.85,82.75 181.73,82.87 181.48,82.87 181.36,82.75 181.36,82.34 181.24,82.22 181,82.22 180.87,82.34 180.87,82.75 180.75,82.87 180.51,82.87 180.39,82.75 180.39,82.34 180.27,82.22 175.73,82.22 173.79,84.16 v2(169.71,84.16)
  IN3 w0.15: v2(235.38,79.34) 235.38,79.28 235.25,79.16 235.25,78.76 235.86,78.15 236.17,78.15 236.37,78.36 236.98,78.36 237.18,78.15 238.31,78.15 238.46,78 244.33,78 244.78,77.55 247.57,77.55 248.01,77.1 v2(248.01,77.05)
  BOTTOM w0.102: UC1.AV3 164.3,80.8 164.77,81.27 165.55,81.27 166.03,81.75 166.03,82.41 168.34,84.72 169.16,84.72 v2(169.71,84.16)
  BOTTOM w0.157: v2(248.01,77.05) 248.21,76.85 248.21,76.15 248.11,76.05 247.69,76.05 247.47,76.27 247.19,76.27 246.97,76.05 246.68,76.05 246.45,76.28 JDIMM1.191 ; v2(235.38,79.34) 235.38,79.26 233.04,76.93 233.04,76.88 232.44,76.28 JDIMM3.191
DDR_A_D45: length 107
  IN1 w0.122: v2(241.19,76.56) 240.8,76.56 240.68,76.43 240.68,75.1 240.56,74.98 240.31,74.98 240.19,75.1 240.19,76.43 240.07,76.56 239.83,76.56 239.64,76.37 239.64,75.71 239.52,75.59 239.27,75.59 239.15,75.71 239.15,76.43 239.03,76.56 238.5,76.56 238.39,76.67 238.39,76.91 238.51,77.03 240,77.03 240.12,77.16 240.12,77.4 240,77.52 238.51,77.52 238.39,77.64 238.39,78.52 238.28,78.64 231.95,78.64 229.94,80.65 218.98,80.65 218.88,80.56 215.08,80.56 215.01,80.49 192.51,80.49 192,81.01 175.67,81.01 172.96,83.71 171.4,83.71 169.02,81.34 v2(166.9,81.34)
  IN3 w0.15: v2(249.18,77.05) 249.18,77.02 248.75,76.6 244.33,76.6 243.92,77.01 241.49,77.01 241.19,76.71 v2(241.19,76.56)
  BOTTOM w0.102: UC1.AW4 165.47,79.89 165.92,80.35 166.3,80.35 167,81.05 167,81.24 v2(166.9,81.34)
  BOTTOM w0.157: JDIMM1.190 250.8,76.03 250.22,75.44 248.86,75.44 248.74,75.56 248.74,76.25 249.18,76.69 v2(249.18,77.05) ; v2(241.19,76.56) 240.66,76.03 240.66,76.03 JDIMM3.190
DDR_A_D46: length 114.1
  IN1 w0.122: v2(165.63,85.13) 165.92,84.83 166.39,84.83 167.09,85.53 167.3,85.53 168.29,86.51 177.04,86.51 177.15,86.4 183.28,86.4 183.41,86.27 183.41,85.48 183.53,85.36 183.77,85.36 183.89,85.48 183.89,86.27 184.02,86.4 184.26,86.4 184.38,86.27 184.38,85.48 184.5,85.36 184.75,85.36 184.87,85.48 184.87,86.27 184.99,86.4 185.23,86.4 185.36,86.27 185.36,85.48 185.48,85.36 185.72,85.36 185.84,85.48 185.84,86.27 185.97,86.4 186.21,86.4 186.33,86.27 186.33,85.48 186.45,85.36 186.7,85.36 186.82,85.48 186.82,86.27 186.94,86.4 187.19,86.4 187.31,86.27 187.31,85.48 187.43,85.36 187.67,85.36 187.79,85.48 187.79,86.27 187.92,86.4 188.16,86.4 188.17,86.38 200.43,86.38 202.03,84.78 211.97,84.78 212.14,84.96 226.23,84.96 226.41,84.78 230.55,84.78 232.48,82.85 235.56,82.85 235.75,82.66 235.75,82.32 v2(235.69,82.26)
  IN3 w0.15: v2(248.7,79.93) 248.7,80.15 248.42,80.43 246.12,80.43 245.55,81 238.35,81 238.1,81.25 237.44,81.25 237.18,81 235.71,81 235.52,81.19 235.52,82.09 v2(235.69,82.26)
  BOTTOM w0.102: v2(165.63,85.13) 165.68,85.07 165.68,84.45 164.86,83.63 163.11,83.63 162.95,83.47 162.95,82.12 163.02,82.05 163.02,81.16 162.9,81.03 162.9,80.32 UC1.AT4
  BOTTOM w0.157: v2(235.69,82.26) 235.69,81.76 233.2,79.28 JDIMM3.203 ; v2(248.7,79.93) 248.7,79.74 248.24,79.28 JDIMM1.203
DDR_A_D47: length 112.3
  IN1 w0.122: v2(243.41,81.52) 243.41,81.46 243,81.05 239.5,81.05 237.28,83.28 232.75,83.28 230.82,85.21 226.59,85.21 225.68,86.12 220.93,86.12 220.2,85.39 211.96,85.39 211.78,85.21 204.86,85.21 203.13,86.94 168.11,86.94 167.24,86.07 v2(166.57,86.07)
  IN3 w0.15: v2(251.31,80.42) 251.46,80.57 251.46,80.82 251.36,80.92 250.83,80.92 250.54,80.63 250.2,80.63 249.94,80.9 249.56,80.9 249.3,80.63 248.92,80.63 248.63,80.92 246.72,80.92 246.14,81.5 243.44,81.5 v2(243.41,81.52)
  BOTTOM w0.102: 164.04,84.99 164.03,84.97 163.74,84.97 162.34,83.56 162.34,83.07 162.13,82.86 162.13,82.44 162.35,82.22 162.48,82.22 162.8,81.91 162.8,81.53 162.47,81.19 UC1.AT3
  BOTTOM w0.157: JDIMM1.204 252.67,79.53 252.12,78.97 249.96,78.97 249.73,79.2 249.73,81.33 249.86,81.46 251.15,81.46 251.31,81.3 v2(251.31,80.42) ; JDIMM3.204 240.87,79.53 241.27,79.93 242.26,79.93 243.41,81.08 v2(243.41,81.52)
  BOTTOM w0.191: 164.04,84.99 165.12,86.07 v2(166.57,86.07)
DDR_A_D48: length 115.4
  IN1 w0.102: 162.53,85.11 v2(161.95,85.11)
  IN1 w0.122: v2(241.66,84.2) 241.66,84.91 241.43,85.14 238.7,85.14 237.89,85.96 233.47,85.96 230.92,88.51 229.94,88.51 229.46,88.03 227.07,88.03 226.24,88.86 213.87,88.86 213.52,88.51 206.94,88.51 206.04,89.41 194.07,89.41 193.94,89.53 193.94,89.96 193.82,90.08 193.58,90.08 193.46,89.96 193.46,89.53 193.33,89.41 193.09,89.41 192.97,89.53 192.97,89.96 192.85,90.08 192.6,90.08 192.48,89.96 192.48,89.6 192.36,89.48 192.11,89.48 191.99,89.6 191.99,89.96 191.87,90.08 191.63,90.08 191.5,89.96 191.5,89.58 191.38,89.46 191.14,89.46 191.02,89.58 191.02,89.96 190.9,90.08 190.65,90.08 190.53,89.96 190.53,89.6 190.41,89.48 190.04,89.48 189.44,90.08 183.3,90.08 182.5,89.28 167.14,89.28 162.98,85.11 162.53,85.11
  IN3 w0.15: v2(241.66,84.2) 241.66,83.91 241.88,83.68 247.05,83.68 247.58,83.14 248.46,83.14 248.86,82.75 248.86,82.75 249.15,82.46 249.47,82.46 249.78,82.14 250.24,82.14 250.56,82.46 251.09,82.46 251.18,82.37 251.18,82.12 v2(251.05,81.99)
  BOTTOM w0.102: v2(161.95,85.11) 160.39,83.56 160.39,82.92 160.28,82.81 160.28,82.48 160.3,82.46 160.3,82.44 160.64,82.1 UC1.AP2
  BOTTOM w0.157: v2(241.66,84.2) 241.66,83.46 240.72,82.53 JDIMM3.216 ; v2(251.05,81.99) 250.72,82.32 250.72,82.41 251.12,82.8 251.28,82.8 251.66,82.43 251.84,82.43 252.07,82.65 252.07,83.39 251.74,83.72 251.74,84.28 251.91,84.45 252.38,84.45 252.7,84.13 252.7,82.7 252.88,82.53 JDIMM1.216
DDR_A_D49: length 119.5
  IN1 w0.122: v2(235.86,85.03) 235.46,85.03 235.34,84.91 235.34,84.88 235.22,84.76 234.97,84.76 234.85,84.88 234.85,84.91 234.73,85.03 234.49,85.03 234.36,84.91 234.36,84.88 234.24,84.76 234,84.76 233.88,84.88 233.88,84.91 233.75,85.03 233.19,85.03 231.05,87.18 226.72,87.18 225.89,88.01 218.15,88.01 218.03,87.88 218.03,87.73 217.91,87.61 217.66,87.61 217.54,87.73 217.54,87.88 217.42,88.01 217.18,88.01 217.05,87.88 217.05,87.73 216.93,87.61 216.69,87.61 216.57,87.73 216.57,87.88 216.44,88.01 216.2,88.01 216.08,87.88 216.08,87.73 215.96,87.61 215.71,87.61 215.59,87.73 215.59,87.88 215.47,88.01 215.22,88.01 215.1,87.88 215.1,87.73 214.98,87.61 214.74,87.61 214.62,87.73 214.62,87.88 214.49,88.01 214.23,88.01 213.22,87 212.72,87 212.6,87.12 212.6,87.53 212.48,87.66 212.24,87.66 212.11,87.53 212.11,87.12 211.99,87 211.75,87 211.63,87.12 211.63,87.53 211.51,87.66 211.26,87.66 211.14,87.53 211.14,87.12 211.02,87 210.77,87 210.65,87.12 210.65,87.53 210.53,87.66 210.29,87.66 210.16,87.53 210.16,87.12 210.04,87 206.99,87 206.87,87.12 206.87,87.53 206.75,87.66 206.5,87.66 206.38,87.53 206.38,87.12 206.26,87 205.25,87 205.13,87.12 205.13,87.29 205.91,88.08 205.91,88.25 205.74,88.42 205.57,88.42 204.88,87.73 204.43,87.73 203.74,88.42 167.5,88.42 163.29,84.21 161.86,84.21 160.4,82.75 160.4,82.42 159.58,81.6 159.58,81.43 159.63,81.38 159.63,81.21 159.46,81.03 159.29,81.03 159.24,81.08 159.06,81.08 v2(158.33,80.35)
  IN3 w0.15: v2(247.2,82.12) 247.2,82.13 246.64,82.69 241.32,82.69 241.13,82.5 241.13,81.89 240.94,81.7 240.55,81.7 240.36,81.89 240.36,82.5 240.17,82.69 239.79,82.69 239.6,82.5 239.6,81.89 239.41,81.7 239.03,81.7 238.84,81.89 238.84,82.5 238.65,82.69 237.83,82.69 237.81,82.71 235.95,82.71 235.86,82.79 235.3,82.79 234.72,83.37 234.72,84.94 234.89,85.1 235.8,85.1 v2(235.86,85.03)
  BOTTOM w0.102: v2(158.33,80.35) 158.78,79.89 UC1.AM4
  BOTTOM w0.157: JDIMM1.215 247.04,82.28 v2(247.2,82.12) ; JDIMM3.215 233.26,82.28 235.86,84.88 v2(235.86,85.03)
DDR_A_D50: length 116.3
  IN1 w0.122: v2(164.97,89.86) 164.97,89.94 167.11,92.07 204.7,92.07 204.83,91.94 210.97,91.94 211.09,91.82 211.09,91.49 211.21,91.37 211.46,91.37 211.58,91.49 211.58,91.82 211.7,91.94 211.95,91.94 212.07,91.82 212.07,91.65 212.19,91.53 212.43,91.53 212.56,91.65 212.56,91.82 212.68,91.94 224.35,91.94 224.92,91.37 226.67,91.37 227.15,90.9 231.31,90.9 233.54,88.66 236.7,88.66 238.92,86.45 239.15,86.45 239.27,86.57 239.27,87.33 239.39,87.45 239.63,87.45 239.76,87.33 239.76,86.57 239.88,86.45 240.12,86.45 240.24,86.57 240.24,87.33 240.36,87.45 240.61,87.45 240.73,87.33 240.73,86.57 240.85,86.45 v2(241.92,86.45)
  IN3 w0.15: v2(241.92,86.45) 241.92,86.06 242.09,85.9 247.92,85.9 248.34,85.48 250.35,85.48 251.32,84.52 251.32,84.09 251.42,83.99 252.48,83.99 253.59,85.1 253.59,86 253.44,86.15 252.62,86.15 252.48,86.02 v2(252.48,85.39)
  BOTTOM w0.102: 164.91,88.79 164.26,88.14 164.26,86.59 160.97,83.3 160.97,81.14 UC1.AP3
  BOTTOM w0.157: JDIMM3.228 241,85.53 v2(241.92,86.45) ; JDIMM1.228 252.61,85.53 v2(252.48,85.39) ; 164.91,88.79 165.07,88.95 165.07,89.76 v2(164.97,89.86)
DDR_A_D51: length 120.8
  IN1 w0.122: v2(236.18,89.24) 234.78,89.24 234.66,89.36 234.66,89.78 234.54,89.9 234.3,89.9 234.17,89.78 234.17,89.36 234.05,89.24 233.57,89.24 233.2,89.6 233.2,89.77 233.86,90.43 233.86,90.6 233.63,90.83 233.45,90.83 232.8,90.18 232.63,90.18 231.48,91.32 228.85,91.32 227.8,92.37 226.74,92.37 226.61,92.25 226.61,91.99 226.49,91.86 226.25,91.86 226.13,91.99 226.13,92.25 226,92.37 225.76,92.37 225.64,92.25 225.64,91.99 225.52,91.86 225.27,91.86 225.15,91.99 225.15,92.25 225.03,92.37 219.44,92.37 219.32,92.49 219.32,92.61 219.2,92.73 218.95,92.73 218.83,92.61 218.83,92.49 218.71,92.37 218.47,92.37 218.34,92.49 218.34,92.8 218.22,92.92 217.98,92.92 217.86,92.8 217.86,92.49 217.73,92.37 205.01,92.37 204.88,92.5 166.93,92.5 163.75,89.32 v2(163.29,89.32)
  IN3 w0.15: v2(248.72,86.51) 248.34,86.9 246.29,86.9 246.01,87.18 243.86,87.18 243.58,86.9 241.59,86.9 241.35,86.66 237.95,86.66 237.31,87.3 235.17,87.3 234.85,87.63 234.85,89.18 235.29,89.62 235.8,89.62 v2(236.18,89.24)
  BOTTOM w0.102: 161.78,88.79 158.43,85.44 158.43,83.87 158.7,83.6 158.7,83.09 158.47,82.86 158.47,82.44 158.69,82.22 158.83,82.22 159.14,81.91 159.14,81.53 158.81,81.19 UC1.AM3
  BOTTOM w0.157: v2(163.29,89.32) 163.25,89.28 162.27,89.28 161.78,88.79 ; JDIMM3.229 233,85.78 236.18,88.96 v2(236.18,89.24) ; JDIMM1.229 247.99,85.78 v2(248.72,86.51)
DDR_A_D52: length 120.6
  IN1 w0.122: v2(237.03,85.03) 237.03,84.48 236.89,84.33 233.29,84.33 230.87,86.75 226.54,86.75 225.71,87.58 220.17,87.58 219.77,87.18 219.34,87.18 219.21,87.06 219.21,86.56 219.09,86.44 218.85,86.44 218.73,86.56 218.73,87.06 218.61,87.18 218.36,87.18 218.24,87.06 218.24,86.56 218.12,86.44 217.87,86.44 217.75,86.56 217.75,87.06 217.63,87.18 214,87.18 213.39,86.57 204.99,86.57 203.57,88 167.67,88 162.65,82.98 162.65,82.8 164.2,81.25 164.2,81.08 164.03,80.91 163.86,80.91 162.13,82.64 161.95,82.64 160.48,81.16 160.48,80.99 v2(161.09,80.37)
  IN3 w0.15: v2(248.37,82.12) 248.37,82.49 248.21,82.65 247.38,82.65 246.84,83.19 241.68,83.19 241.3,83.56 241.02,83.56 240.66,83.2 240.31,83.2 240.12,83.39 240.12,84.02 239.93,84.21 239.55,84.21 239.36,84.02 239.36,83.39 239.17,83.2 238.79,83.2 238.6,83.39 238.6,84.62 238.41,84.81 238.03,84.81 237.84,84.62 237.84,83.39 237.65,83.2 236.82,83.2 236.5,83.53 236.5,84.41 237.03,84.95 v2(237.03,85.03)
  BOTTOM w0.102: v2(161.09,80.37) 160.64,79.91 UC1.AP4
  BOTTOM w0.157: JDIMM1.211 247.8,81.28 248.37,81.84 v2(248.37,82.12) ; JDIMM3.211 232.91,81.28 235.71,84.07 236.22,84.07 237.03,84.89 v2(237.03,85.03)
DDR_A_D53: length 117.1
  IN1 w0.122: v2(158.05,84.1) 158.05,84.33 158.32,84.61 163.08,84.61 167.32,88.85 206,88.85 206.76,88.08 213.7,88.08 214.05,88.43 226.06,88.43 226.89,87.6 231.22,87.6 233.3,85.53 237.71,85.53 239.45,83.79 242.61,83.79 242.82,84 v2(242.82,84.2)
  IN3 w0.15: v2(252.22,81.99) 252.35,82.12 254.41,82.12 254.58,82.29 254.58,84.3 254.34,84.54 253.73,84.54 253.31,84.12 253.31,83.11 253.16,82.95 249.35,82.95 248.67,83.64 247.79,83.64 247.25,84.18 242.85,84.18 v2(242.82,84.2)
  BOTTOM w0.102: v2(158.05,84.1) 158.05,83.96 158.45,83.56 158.45,83.12 158.23,82.91 158.23,82.14 158.65,81.72 UC1.AM2
  BOTTOM w0.157: JDIMM3.212 241.01,81.53 242.82,83.34 v2(242.82,84.2) ; v2(252.22,81.99) 252.69,81.53 JDIMM1.212
DDR_A_D54: length 116.9
  IN1 w0.122: v2(243.09,86.45) 243.09,86.44 242.67,86.02 241.97,86.02 241.85,85.9 241.85,85.69 241.72,85.57 241.48,85.57 241.36,85.69 241.36,85.9 241.24,86.02 240.99,86.02 240.87,85.9 240.87,85.69 240.75,85.57 240.5,85.57 240.38,85.69 240.38,85.9 240.26,86.02 240.02,86.02 239.89,85.9 239.89,85.69 239.77,85.57 239.53,85.57 239.41,85.69 239.41,85.9 239.28,86.02 238.57,86.02 236.42,88.16 233.44,88.16 231.56,90.04 227.4,90.04 226.5,90.94 209.97,90.94 209.85,91.06 204.58,91.06 204.01,91.62 197.88,91.62 197.86,91.62 167.31,91.62 164.52,88.82 164.34,88.82 v2(164.14,89.02)
  IN3 w0.15: v2(251.32,85.39) 251.52,85.6 251.52,85.84 251.36,86 248.52,86 248.13,86.4 246.08,86.4 245.8,86.68 245.38,86.68 245.1,86.4 244.73,86.4 244.45,86.68 244.07,86.68 243.79,86.4 243.14,86.4 v2(243.09,86.45)
  BOTTOM w0.102: UC1.AP1 160.64,83.25 162.99,85.6 162.99,87.87 163.9,88.79
  BOTTOM w0.157: 163.9,88.79 v2(164.14,89.02) ; JDIMM1.224 252.96,84.53 252.57,84.91 251.56,84.91 251.28,84.63 251.28,84.22 251.12,84.06 249.39,84.06 249.05,84.4 249.05,84.82 249.24,85.01 249.47,85.01 249.82,84.66 250.04,84.66 250.26,84.88 250.26,85.11 249.91,85.46 249.91,85.68 250.31,86.08 251.1,86.08 251.32,85.87 v2(251.32,85.39) ; JDIMM3.224 240.69,84.53 242.06,85.9 242.62,85.9 243.09,86.37 v2(243.09,86.45)

# Allegro board Alienware Area-51M LA-G881P.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CNV_BRI_PRX_DTX_R: length 7.3
  TOP w0.112: RN109.1 337.68,38.03 RN1.2 337.04,37.93 336.91,38.06 335.25,38.06 335,37.82 335,37.31 335.14,37.17 335.5,37.17 v1(335.82,37.49) v2(336.39,37.49)
  BOTTOM w0.112: v2(336.39,37.49) 336.39,37.87 336.16,38.1 JWLAN.22
CNV_BRI_PTX_DRX: length 125.2
  TOP w0.089: RH603.2 295.41,61.57 v2(295.08,61.24) 294.99,61.24 293.42,59.67 291.82,59.67 291.81,59.65 291.47,59.65 291.39,59.74 290.95,59.74 UH1.AV4
  TOP w0.112: v2(336.91,38.69) 336.8,38.59 RH1021.2
  IN1 w0.084: v2(348.2,32.92) 347.76,32.47 346.49,32.47 345.78,33.18 345.33,33.18 345.03,32.88 345.03,30.85 346.51,29.37 346.51,26.66 346.28,26.43 346.28,23.54 341.18,18.44 334.64,18.44 332.84,20.24 329.59,20.24 326.78,17.42 314.87,17.42 314.75,17.55 313.87,18.43 313.02,18.43 312.68,18.76 310.42,18.76 308.87,20.31 308.87,23.24 306.75,25.36 306.75,27.69 307.37,28.32 307.37,36.88 304.08,40.16 304.08,45.72 303.19,46.62 303.19,52.24 298.48,56.96 298.48,57.05 295.68,59.85 295.68,60.66 295.1,61.24 v2(295.08,61.24)
  IN4 w0.084: v2(348.2,32.92) 347.8,33.32 346.07,33.32 345.58,33.81 342.61,33.81 341.46,34.95 341.46,36.73 339.18,39.01 337.22,39.01 v2(336.91,38.69)
CNV_BRI_PTX_DRX_R: length 7.2
  TOP w0.112: RH1021.1 336.24,39.18 335.56,38.5 334.99,38.5 334.55,38.06 v1(334.36,38.06) 333.86,38.56 333.86,40.93 v2(334.09,41.17)
  BOTTOM w0.112: v2(334.09,41.17) 334.52,41.6 JWLAN.36
CNV_PRX_DTX_N0: length 111.7
  TOP w0.089: UH1.BB3 291.95,61.97 292.17,61.97 292.24,61.9 292.51,61.9 292.89,62.28 292.89,62.65 293.09,62.85 293.37,62.85 293.78,63.26 v2(293.78,63.32)
  IN1 w0.084: v2(293.78,63.32) 293.78,63.22 293.98,63.02 294.12,63.02 295.51,64.41 297.93,64.41 298.79,63.55 298.79,60.81 304.67,54.93 304.67,48.69 305.71,47.65 305.71,40.63 308.98,37.35 308.98,25.21 310.35,23.85 310.35,22.35 310.97,21.73 311.8,21.73 313.63,19.9 325.01,19.9 326.83,21.72 333.45,21.72 334.72,20.45 340.61,20.45 344.79,24.63 344.79,27.84 344.66,27.97 344.66,29.11 344.33,29.45 344.33,29.47 343.56,30.24 343.56,33.49 345.11,35.05 347.27,35.05 347.47,34.85 348.14,34.85 348.22,34.93 348.22,35.02 348.14,35.1 348.14,35.14 348.01,35.27 v2(347.81,35.27)
  BOTTOM w0.112: RN103.1 346.95,36.39 346.99,36.39 347.13,36.53 347.64,36.53 348.32,35.85 348.32,35.66 347.92,35.27 v2(347.81,35.27)
CNV_PRX_DTX_N0_R: length 3.6
  BOTTOM w0.112: RN103.2 345.93,36.38 345.32,36.38 345.3,36.36 344.75,36.36 344.73,36.38 344.29,36.38 344.14,36.53 343.87,36.53 343.69,36.35 JWLAN.15
CNV_PRX_DTX_N1: length 110.8
  TOP w0.089: UH1.BA3 291.77,61.57 292.05,61.57 292.09,61.53 292.78,61.53 293.14,61.89 293.45,61.89 v2(293.65,62.09)
  IN1 w0.084: v2(293.65,62.09) 293.85,61.9 294.16,61.9 294.5,62.24 294.5,62.51 295.77,63.78 297.67,63.78 298.16,63.29 298.16,60.55 304.03,54.67 304.03,48.43 305.07,47.39 305.07,40.37 308.35,37.09 308.35,24.95 309.71,23.59 309.71,21.56 310.21,21.06 311.58,21.06 313.37,19.27 314.22,19.27 315.22,18.27 324.27,18.27 327.09,21.08 333.19,21.08 334.52,19.75 341.29,19.75 345.43,23.89 345.43,26.78 345.67,27.01 345.67,29.02 344.19,30.5 344.19,33.23 344.98,34.02 346.13,34.02 346.37,33.78 347.09,33.78 347.18,33.87 347.18,34.01 v2(346.96,34.22)
  BOTTOM w0.112: RN105.1 346.89,35.17 347.04,35.17 347.15,35.06 347.15,34.4 v2(346.96,34.22)
CNV_PRX_DTX_N1_R: length 3.6
  BOTTOM w0.112: RN105.2 345.93,35.2 345.66,35.2 345.45,34.99 v4(344.96,34.99) 343.81,34.99 343.67,34.85 JWLAN.9
CNV_PRX_DTX_P0: length 111.8
  TOP w0.089: UH1.BB4 291.74,61.8 292.09,61.8 292.17,61.72 292.58,61.72 293.07,62.2 293.07,62.57 293.17,62.68 v2(293.78,62.68)
  IN1 w0.084: v2(293.78,62.68) 293.96,62.85 294.19,62.85 295.58,64.25 297.86,64.25 298.63,63.48 298.63,60.74 304.5,54.86 304.5,48.62 305.54,47.58 305.54,40.56 308.82,37.28 308.82,25.14 310.18,23.78 310.18,22.28 310.9,21.56 311.73,21.56 313.56,19.73 325.08,19.73 326.9,21.55 333.38,21.55 334.65,20.28 340.68,20.28 344.95,24.56 344.95,27.91 344.83,28.04 344.83,29.18 344.49,29.52 344.49,29.54 343.72,30.31 343.72,33.43 345.18,34.88 347.2,34.88 347.41,34.68 348.21,34.68 348.39,34.86 348.39,35.12 v2(348.54,35.27)
  BOTTOM w0.112: v2(348.54,35.27) 348.54,35.95 347.73,36.75 RN104.1
CNV_PRX_DTX_P0_R: length 3.5
  BOTTOM w0.112: JWLAN.17 343.75,36.85 343.85,36.75 344.23,36.75 344.38,36.6 v4(345.02,36.6) 345.99,36.6 RN104.2
CNV_PRX_DTX_P1: length 110.9
  TOP w0.089: v2(293.65,61.51) 293.45,61.71 293.21,61.71 292.85,61.35 291.93,61.35 UH1.BA2
  IN1 w0.084: v2(347.55,34.22) 347.34,34.01 347.34,33.8 347.16,33.61 346.3,33.61 346.06,33.86 345.05,33.86 344.36,33.16 344.36,30.57 345.83,29.09 345.83,26.94 345.6,26.71 345.6,23.82 341.36,19.58 334.46,19.58 333.13,20.91 327.16,20.91 324.34,18.1 315.15,18.1 314.15,19.1 313.3,19.1 311.51,20.89 310.14,20.89 309.55,21.49 309.55,23.52 308.18,24.88 308.18,37.02 304.91,40.3 304.91,47.32 303.87,48.36 303.87,54.6 297.99,60.48 297.99,63.22 297.6,63.61 295.84,63.61 294.67,62.44 294.67,62.17 294.23,61.73 293.88,61.73 v2(293.65,61.51)
  BOTTOM w0.112: RN106.1 346.91,35.39 347.13,35.39 347.37,35.15 347.37,34.4 v2(347.55,34.22)
CNV_PRX_DTX_P1_R: length 3.6
  BOTTOM w0.112: RN106.2 345.98,35.42 345.57,35.42 345.37,35.23 344.69,35.23 344.67,35.21 343.81,35.21 343.67,35.35 JWLAN.11
CNV_PTX_C_DRX_N0: length 3.5
  BOTTOM w0.112: RN125.2 345.87,48.92 345.25,48.92 345.23,48.9 344.69,48.9 344.67,48.92 344.26,48.92 344.17,49.01 343.84,49.01 343.67,48.85 JWLAN.65
CNV_PTX_C_DRX_N1: length 3.7
  BOTTOM w0.112: RN123.2 345.95,47 345.38,47 345.36,46.98 344.82,46.98 344.8,47 344.53,47 344.04,47.49 343.81,47.49 343.67,47.35 JWLAN.59
CNV_PTX_C_DRX_P0: length 3.4
  BOTTOM w0.112: RN126.2 345.9,49.14 v4(344.96,49.14) 344.35,49.14 344.26,49.24 343.79,49.24 343.67,49.35 JWLAN.67
CNV_PTX_C_DRX_P1: length 3.7
  BOTTOM w0.112: JWLAN.61 343.67,47.85 343.81,47.71 344.13,47.71 344.62,47.22 v4(345.09,47.22) 345.95,47.22 RN124.2
CNV_PTX_DRX_N0: length 132.4
  TOP w0.089: 292.34,68.71 292.24,68.71 292.15,68.62 292.15,66.88 291.85,66.57 291.41,66.57 289.53,64.7 289.53,63.59 289.43,63.48 289.43,63.14 289.46,63.11 UH1.BE6
  TOP w0.112: v2(292.6,68.53) 292.6,68.6 292.49,68.71 292.34,68.71
  IN1 w0.084: v2(348,48.7) 348,48.72 347.72,49 347.57,49 347.31,48.74 347.31,46.64 347.53,46.41 347.53,40.31 349.13,38.72 349.13,37.53 347.95,36.36 344.61,36.36 344.53,36.29 343.26,36.29 341.46,34.49 341.46,32.47 340.58,31.59 340.58,29.81 341.4,28.98 341.4,23.74 340.48,22.82 336.98,22.82 336.93,22.87 326.36,22.87 324.49,21 314.09,21 311.77,23.31 311.77,23.97 310.24,25.51 310.24,38.82 312.23,40.81 312.23,43.34 310.34,45.22 309.83,45.22 305.76,49.29 305.76,55.39 299.89,61.26 299.89,65.42 296.16,69.15 295.05,69.15 294.85,68.95 293.02,68.95 v2(292.6,68.53)
  BOTTOM w0.112: RN125.1 346.86,48.94 346.91,48.94 347.04,49.07 347.64,49.07 348,48.7 v2(348,48.7)
CNV_PTX_DRX_N1: length 125.1
  TOP w0.089: UH1.BG6 289.87,64.07 289.75,64.18 289.75,64.31 289.82,64.37 290,64.37 290.16,64.54 290.16,64.79 291.61,66.24 292.38,66.24 v2(292.58,66.44)
  IN1 w0.084: v2(292.58,66.44) 292.99,66.03 294.63,66.03 295.42,66.82 297.7,66.82 299.43,65.09 299.43,61.07 305.3,55.2 305.3,48.95 306.34,47.91 306.34,40.89 309.78,37.46 309.78,25.31 311.31,23.78 311.31,23.12 313.89,20.53 324.68,20.53 326.56,22.41 336.73,22.41 336.79,22.35 341.62,22.35 344.15,24.89 344.15,27.58 344.03,27.71 344.03,28.85 342.92,29.95 342.92,34.37 344.01,35.45 344.35,35.45 344.8,35.9 348.15,35.9 349.64,37.39 349.64,38.87 348.35,40.16 348.35,47.02 348.26,47.1 348.2,47.1 v2(347.93,46.84)
  BOTTOM w0.112: RN123.1 346.77,46.82 347.12,47.17 347.59,47.17 v2(347.93,46.84)
CNV_PTX_DRX_P0: length 132.6
  TOP w0.089: UH1.BD7 289.45,62.87 289.25,63.07 289.25,63.55 289.36,63.66 289.36,64.77 291.34,66.75 291.77,66.75 291.98,66.95 291.98,68.69 292.17,68.88
  TOP w0.112: v2(292.6,69.12) 292.41,68.93 292.21,68.93 292.17,68.88
  IN1 w0.084: v2(348,49.29) 347.89,49.17 347.5,49.17 347.14,48.81 347.14,46.57 347.37,46.34 347.37,40.24 348.96,38.65 348.96,37.6 347.89,36.53 344.54,36.53 344.46,36.46 343.19,36.46 341.29,34.56 341.29,32.54 340.41,31.66 340.41,29.74 341.23,28.91 341.23,23.81 340.41,22.98 337.05,22.98 337,23.04 326.3,23.04 324.42,21.17 314.16,21.17 311.94,23.38 311.94,24.04 310.41,25.58 310.41,38.75 312.39,40.74 312.39,43.41 310.41,45.39 309.9,45.39 305.93,49.36 305.93,55.46 300.06,61.33 300.06,65.49 296.23,69.32 294.98,69.32 294.78,69.12 v2(292.6,69.12)
  BOTTOM w0.112: RN126.1 346.66,49.29 v2(348,49.29)
CNV_PTX_DRX_P1: length 125.1
  TOP w0.089: UH1.BF6 290.19,63.94 290.19,64.31 290.34,64.47 290.34,64.72 291.68,66.06 292.37,66.06 v2(292.58,65.86)
  IN1 w0.084: v2(292.58,65.86) 292.59,65.86 294.7,65.86 295.49,66.65 297.63,66.65 299.26,65.02 299.26,61 305.13,55.13 305.13,48.88 306.17,47.84 306.17,40.82 309.61,37.39 309.61,25.24 311.14,23.71 311.14,23.05 313.82,20.37 324.75,20.37 326.63,22.24 336.66,22.24 336.72,22.18 341.69,22.18 344.32,24.82 344.32,27.65 344.19,27.78 344.19,28.92 343.09,30.02 343.09,34.3 344.08,35.29 344.42,35.29 344.87,35.73 348.22,35.73 349.81,37.32 349.81,38.94 348.52,40.23 348.52,47.08 348.33,47.27 348.09,47.27 v2(347.93,47.42)
  BOTTOM w0.112: RN124.1 347.91,47.39 v2(347.93,47.42)
CNV_RF_RESET#: length 122.3
  TOP w0.089: UH1.BE16 285.23,63 v2(285.23,65.73)
  IN3 w0.104: v2(337.85,30.69) 337.64,30.48 335.18,30.48 333.3,28.6 333.3,25.11 330.58,22.39 328.48,22.39 327.4,21.3 316.58,21.3 315.68,22.2 315.35,22.2 314.29,22.2 309.03,27.46 308.07,27.46 305.96,29.57 303.7,29.57 302.1,31.18 302.1,31.67 299.16,34.61 296.54,34.61 295.48,35.68 295.48,41.13 294.54,42.07 294.54,44.76 292.28,47.02 292.28,52.92 292.46,53.11 292.46,56.81 292.33,56.94 291.82,57.44 291.82,62.65 291.54,62.93 290.45,62.93 289.42,63.97 285.86,63.97 285.36,64.48 285.36,65.61 v2(285.23,65.73)
  IN4 w0.084: v2(337.85,30.69) 338.56,31.41 342.68,31.41 344.09,30 348.45,30 349.47,31.01 356.01,31.01 357.33,32.33 v2(357.33,34.25)
  BOTTOM w0.112: v2(285.23,65.73) v1(285.23,66.3) ; QN8.2 356.57,36.92 RN6.1 356.65,36.12 RH724.1 356.92,35.37 357.33,34.96 v2(357.33,34.25)
CNV_RF_RESET#_D: length 27.2
  IN4 w0.084: v2(356.01,34.2) 355,34.2 352.45,31.65 349.21,31.65 347.77,30.21 344.18,30.21 342.77,31.62 339.4,31.62 v2(336.58,34.44)
  BOTTOM w0.112: JWLAN.10 336.24,35.1 336.58,34.76 v2(336.58,34.44) ; v2(356.01,34.2) 355.86,34.35 RH722.1 355.86,35.47 356.07,35.69 356.07,36.09 355.9,36.27 QN8.3
CNV_RGI_PRX_DTX: length 111.3
  TOP w0.089: RH182.2 295.11,60.78 v2(294.99,60.66) 294.79,60.66 293.61,59.48 291.9,59.48 291.89,59.46 291.39,59.46 291.34,59.51 291.25,59.51 291.25,59.51 UH1.AV3
  TOP w0.112: RN111.2 334.86,40.16 334.79,40.09 v2(334.35,40.09)
  BOTTOM w0.112: v2(334.35,40.09) 334.65,40.09 334.93,39.81 334.93,39.25 332.41,36.73 332.41,35.17 329.19,31.96 v1(329.19,21.88) 326.85,19.54 326.85,17.73 325.8,16.68 318.19,16.68 316.58,18.29 316.58,19.48 315.95,20.1 315.95,21.61 315.49,22.07 314.08,22.07 313.09,23.06 313.09,24.09 311.85,25.33 311.85,28.47 309.89,30.43 309.89,36 314.13,40.24 314.13,48.34 310.63,51.83 310.63,54.67 308.89,56.41 304.64,56.41 301.68,59.37 301.52,59.37 300.85,58.7 300.7,58.7 300.46,58.94 300.46,59.1 301.13,59.77 301.13,59.92 300.19,60.86 300.19,61.37 298.29,63.27 294.99,63.27 294.48,62.76 294.48,61.17 v2(294.99,60.66)
CNV_RGI_PRX_DTX_R: length 2.8
  TOP w0.112: RN111.1 336.55,40.92 336.61,40.92 v2(336.72,41.03)
  BOTTOM w0.112: JWLAN.34 336.65,41.1 v2(336.72,41.03)
CNV_RGI_PTX_DRX: length 110.5
  TOP w0.089: UH1.BA4 291.04,61.22 291.43,60.83 293.77,60.83 294.22,61.27 294.22,61.69 294.57,62.05 294.57,65.08 295.15,65.65 295.39,65.65
  TOP w0.112: v2(297.78,65.68) 297.17,65.68 297.15,65.65 295.39,65.65 ; RH200.2 334.42,39.52 v2(334.35,39.46)
  BOTTOM w0.112: v2(297.78,65.68) 300.07,65.68 301.73,64.02 301.73,60.54 305.36,56.9 309.09,56.9 311.13,54.87 311.13,52.04 314.62,48.55 314.62,40.03 310.38,35.79 310.38,30.63 312.34,28.67 312.34,25.54 313.58,24.29 313.58,23.27 314.29,22.57 315.7,22.57 316.45,21.82 316.45,20.31 317.07,19.68 317.07,18.49 318.39,17.17 325.59,17.17 326.36,17.93 326.36,19.74 328.7,22.09 328.7,32.16 331.91,35.37 331.91,37.78 333.59,39.46 v2(334.35,39.46)
CNV_RGI_PTX_DRX_R: length 86
  TOP w0.112: RH200.1 335.88,39.52 336.71,40.34 v2(336.71,40.41) 337.41,40.41 337.71,40.12 RN120.2
  IN4 w0.084: v2(307.75,55.01) 307.75,58.82 309.91,60.98 309.91,61.75 310.54,62.38 312.13,62.38 314.35,60.16 314.35,56.86 v2(315.62,55.59)
  BOTTOM w0.112: RH219.2 RH220.2 284.83,54.2 284.83,53.68 285.54,52.97 291.19,52.97 292.14,53.93 296.14,53.93 296.57,53.49 297.18,53.49 297.53,53.84 297.53,54.37 298.81,55.64 299.89,55.64 300.52,55.01 v2(307.75,55.01) ; v2(336.71,40.41) 336.32,40.41 336.13,40.6 JWLAN.32 332.32,40.6 332.1,40.82 332.1,43.3 333.7,44.89 333.7,52.43 332.64,53.49 329.47,53.49 328.77,54.19 324.77,54.19 323.37,55.59 v2(315.62,55.59)
CNV_WT_RCOMP: length 7.8
  TOP w0.089: UH1.BA1 292.59,61.07 292.6,61.06 293.74,61.06 294.03,61.35 294.03,62.39 294.29,62.65 294.29,65.06 294.72,65.49 294.72,65.75 295.01,66.04
  TOP w0.112: RH213.1 295.78,66.16 295.13,66.16 295.01,66.04
COMP_CHG: length 3.3
  TOP w0.203: PU703.10 208.03,142.92 209.06,143.95 PC751.2 209.06,144.8 209.06,144.8 PR754.2
COMP_ISL95338_1: length 3.3
  TOP w0.112: v2(129.07,145.38) 129.07,145.04 v1(128.63,144.6)
  TOP w0.254: v2(129.07,145.38) 129.12,145.34 129.48,145.34 PCS27.1
  BOTTOM w0.203: v2(129.07,145.38) 128.97,145.48 PUS1.28
  BOTTOM w0.254: PRS20.1 129.23,145.54 v2(129.07,145.38)
COMP_ISL95338_2: length 3.7
  TOP w0.112: PCS56.1 152.05,142.13 v3(152.3,141.88)
  TOP w0.254: v2(151.41,142.92) 151.5,143.02 PCS56.1
  BOTTOM w0.203: PRS40.2 152.16,142.9 151.44,142.9 v2(151.41,142.92) 151.34,142.92 151.3,142.97 PUS2.28
CORE_V1N: length 82.9
  TOP w0.254: PRI201.1 89.58,29.22 v2(89.69,29.11) ; v2(112.16,48.79) 112.17,48.79 112.17,48.67 113,47.84 v1(115.66,47.84) 116.74,47.84 119.21,50.32 122.52,50.32 122.99,50.78 PRI20.2 ; v2(115.91,35.71) 115.91,36.85 115.14,37.63 PRI102.1 ; v2(116.04,57.62) 116.04,62.18 116.61,62.75 PRI62.1
  IN1 w0.254: v2(109.56,36.73) 109.71,36.88 109.71,38.67 110.13,39.09 110.13,41.74 109.88,42 109.88,42.7 110.32,43.14 110.32,45.17 112.16,47.01 112.16,48.79 ; 112.16,48.79 112.17,48.79 112.17,49.05 112.48,49.36 112.48,55.14 114.27,56.92 114.64,56.92 115.4,57.68 115.98,57.68 v2(116.04,57.62) ; 112.16,48.79 v2(112.16,48.79)
  IN4 w0.254: v2(89.69,29.11) 89.81,28.99 91.79,28.99 95.41,32.61 98.04,32.61 101.2,35.77 103.78,35.77 104.61,36.6 109.37,36.6 109.5,36.73 v2(109.56,36.73) 109.69,36.6 110.13,36.6 110.93,37.4 115.31,37.4 115.79,36.92 115.79,35.84 v2(115.91,35.71)
  BOTTOM w0.254: PCI205.1 89.58,29.21 v2(89.69,29.11) ; PLI01.3 v2(115.91,35.71)
CORE_V1P: length 39.4
  TOP w0.254: PRI18.2 112.4,32.58 PRI19.1 112.54,32.73 114.52,32.73 115.28,33.49 v1(115.28,34.69) v2(115.28,35.71)
  IN4 w0.254: v2(115.28,35.71) 115.4,35.84 115.4,36.76 115.15,37.02 111.09,37.02 110.29,36.22 104.77,36.22 103.94,35.39 101.36,35.39 98.2,32.23 95.57,32.23 91.95,28.6 89.76,28.6 v2(89.66,28.5)
  BOTTOM w0.254: v2(89.66,28.5) 89.51,28.36 PRI210.1 ; PLI01.2 v2(115.28,35.71)
CORE_V2N: length 91.9
  TOP w0.254: v2(116.36,27.92) v1(116.85,27.43) 116.97,27.31 116.97,26.94 118.61,25.3 123.97,25.3 124.04,25.22 PRI36.2 ; PRI117.1 117.69,59.91 117.5,60.1 117.5,60.22 v2(117.47,60.22) ; v2(117.13,71.71) 117.16,71.74 PRI77.1 ; v2(89.18,26.06) 89.23,26.11 PRI204.1
  IN1 w0.254: v2(113.88,29.68) 113.2,29.68 112.61,30.26 112.61,34.76 111.59,35.78 111.59,38.25 111.66,38.32 111.66,40.58 111.85,40.77 111.85,44.53 114.01,46.69 114.01,54.5 114.9,55.4 117.12,55.4 118.22,56.5 118.22,58.32 117.47,59.07 v2(117.47,60.22) 117.56,60.31 117.56,65.71 117.25,66.03 117.25,71.6 v2(117.13,71.71)
  IN4 w0.254: v2(116.36,27.92) 116.26,28.02 116.26,28.5 115.27,29.49 114.07,29.49 v2(113.88,29.68) 112.94,29.68 112.75,29.49 112.43,29.49 110.52,27.58 108.5,27.58 108.46,27.62 104.83,27.62 103.17,25.97 89.27,25.97 v2(89.18,26.06)
  BOTTOM w0.254: PCI203.1 89.22,26.1 v2(89.18,26.06) ; v2(116.36,27.92) 116.29,27.85 116.29,27.46 116.54,27.2 PLI02.3
CORE_V2P: length 35.7
  TOP w0.254: PRI33.2 112.14,28 PRI34.1 v1(113.57,28.37) 114.46,28.37 114.77,28.05 v2(114.77,27.26)
  IN4 w0.254: v2(89.18,25.47) 89.29,25.59 103.33,25.59 104.98,27.24 108.3,27.24 108.34,27.2 110.68,27.2 112.59,29.11 114.61,29.11 114.86,28.85 114.86,27.35 v2(114.77,27.26)
  BOTTOM w0.254: v2(114.77,27.26) 114.71,27.2 PLI02.2 ; PRI203.1 88.69,25.87 88.98,25.58 89.08,25.58 v2(89.18,25.47)
CORE_V3N: length 82
  TOP w0.254: v2(89.75,43.39) 89.6,43.54 89.3,43.54 PRI218.1 ; PRI103.1 v1(112.53,35.65) 112.53,34.43 PRI22.1 113.15,34.35 v2(114.13,33.36) ; v2(119.66,62.32) 119.07,62.9 PRI61.2
  IN1 w0.254: v2(119.66,62.32) 119.47,62.32 118.58,61.43 118.58,60.06 118.46,59.94 118.46,59.58 118.99,59.05 118.99,56.1 117.52,54.63 115.21,54.63 114.77,54.19 114.77,46.38 112.61,44.22 112.61,40.46 112.42,40.27 112.42,36.03 114.13,34.31 v2(114.13,33.36)
  IN4 w0.254: v2(89.75,43.39) 89.85,43.29 90.6,43.29 91.66,44.35 91.66,45.14 99.37,52.86 101.82,52.86 103.4,54.44 103.4,55.3 106.29,58.19 111.91,58.19 113.44,59.71 115.28,59.71 116.65,61.08 117.28,61.08 117.56,61.36 118.71,61.36 v2(119.66,62.32)
  BOTTOM w0.254: PLI03.3 119.48,62.49 v2(119.66,62.32) ; PCI209.1 89.61,43.53 v2(89.75,43.39)
CORE_V3P: length 42.9
  TOP w0.254: PRI60.1 118.49,60.84 PRI59.2 119.15,60.18 v2(119.15,59.65)
  IN4 w0.254: v2(119.15,59.65) 119.15,60.45 118.62,60.98 117.72,60.98 117.44,60.7 116.81,60.7 115.44,59.33 113.59,59.33 112.07,57.81 106.45,57.81 103.78,55.14 103.78,54.28 101.97,52.47 99.53,52.47 92.04,44.98 92.04,44.19 90.76,42.91 89.85,42.91 v2(89.75,42.81)
  BOTTOM w0.254: v2(89.75,42.81) 89.62,42.68 PRI220.1 ; PLI03.2 119.48,59.32 v2(119.15,59.65)
CORE_V4N: length 103.7
  TOP w0.254: v2(119.4,70.76) 119.4,68.11 PRI76.2 ; PRI37.1 113.21,30.08 v2(113.5,30.38) ; PRI118.1 118.45,59.65 118.06,60.04 v2(118.06,60.22) ; v2(89.5,40.35) 89.5,40.8 PRI211.1
  IN1 w0.254: v2(113.5,30.38) 113.18,30.7 113.18,34.73 112.04,35.87 112.04,40.42 112.23,40.62 112.23,44.38 114.39,46.53 114.39,54.35 115.06,55.01 117.36,55.01 118.6,56.26 118.6,58.89 118.01,59.49 118.01,60.03 118.06,60.08 v2(118.06,60.22) 117.96,60.32 117.96,65.86 117.67,66.15 117.67,69.02 v2(119.4,70.76)
  IN4 w0.254: v2(89.5,40.35) 88.9,40.94 88.9,43.75 99.09,53.93 100.29,53.93 102.01,55.65 102.01,59.69 108.35,66.04 108.35,67.27 109.66,68.57 116.26,68.57 118.55,70.86 119.3,70.86 v2(119.4,70.76)
  BOTTOM w0.254: v2(119.4,70.76) PLI04.3 ; v2(89.5,40.35) 89.43,40.41 89.43,40.72 PCI207.1
CORE_V4P: length 53.8
  TOP w0.254: PRI74.2 118.63,70.19 PRI75.1 119.08,71.27 119.33,71.27 v2(119.4,71.35)
  IN4 w0.254: v2(119.4,71.35) 119.3,71.24 118.39,71.24 116.1,68.95 109.5,68.95 107.97,67.43 107.97,66.2 101.62,59.85 101.62,55.81 100.13,54.32 98.93,54.32 88.52,43.91 88.52,40.79 88.92,40.38 v2(88.92,40.16)
  BOTTOM w0.254: PLI04.2 v2(119.4,71.35) ; PRI215.1 v2(88.92,40.16)
CORE_V5N: length 80.9
  TOP w0.254: v2(112.74,48.85) 113.35,48.25 116.61,48.25 119.06,50.7 121.9,50.7 PRI101.2 ; PRI23.1 111.54,34.96 111.02,34.44 v2(111.02,34.38) ; PRI230.1 89.27,36.91 89.55,36.91 v2(89.63,36.99) ; PRI63.1 117.63,64.66 v1(117.57,64.6) 116.86,63.9 116.86,63.54 115.66,62.34 115.66,58.81 115.4,58.55 115.4,57.3 v2(115.56,57.14)
  IN1 w0.254: v2(111.02,34.38) 111.02,34.73 110.1,35.65 110.1,38.51 110.51,38.93 110.51,42.32 v2(110.41,42.42) 110.71,42.71 110.71,45.01 112.74,47.04 v2(112.74,48.85) 112.86,48.98 112.86,54.98 114.42,56.54 114.88,56.54 114.96,56.54 v2(115.56,57.14)
  IN4 w0.254: v2(89.63,36.99) 89.76,36.85 96.96,36.85 100.77,40.66 108.83,40.66 110.41,42.24 v2(110.41,42.42) 110.59,42.42 113.09,44.92 115.24,44.92 115.85,44.31 115.85,43.89 v2(116,43.74)
  BOTTOM w0.254: PCI214.1 89.24,36.95 89.6,36.95 v2(89.63,36.99) ; v2(116,43.74) PLI05.3
CORE_V5P: length 46
  TOP w0.254: v2(115.31,43.74) 114.81,43.23 113.78,43.23 v1(112.42,41.87) 112.42,41.87 112.3,41.74 PRI99.2 112.3,40.73 112.45,40.57 115.5,40.57 115.92,40.16 115.92,38.89 115.56,38.53 PRI100.1
  IN4 w0.254: v2(89.69,36.35) 89.81,36.47 97.12,36.47 100.93,40.28 108.99,40.28 113.25,44.54 115.09,44.54 115.42,44.2 115.42,43.84 v2(115.31,43.74)
  BOTTOM w0.254: PRI221.1 89.19,36.49 89.55,36.49 v2(89.69,36.35) ; PLI05.2 v2(115.31,43.74)
CORE_V6N: length 105.9
  TOP w0.254: PRI116.2 117.67,54.87 117.63,54.87 117.49,55.02 117.49,55.06 117.31,55.23 v2(117.31,56.28) ; v2(111.02,30.19) 111.13,30.08 PRI38.1 ; v2(89.62,34.51) 89.62,34.5 89.45,34.68 89.28,34.68 PRI223.1 ; PRI78.1 117.22,72.51 116.55,71.84 v2(116.55,71.71)
  IN1 w0.254: v2(111.02,30.19) 111.82,30.19 112.23,30.6 112.23,34.6 111.15,35.68 111.15,38.35 111.28,38.47 111.28,40.74 111.47,40.93 111.47,44.69 113.63,46.85 113.63,54.66 114.74,55.78 115.06,55.78 116.8,55.78 v2(117.31,56.28) 117.84,56.82 117.84,58.16 116.99,59.01 116.99,60.62 117.18,60.81 117.18,65.56 117.06,65.68 117.06,65.68 116.86,65.87 116.86,71.3 116.55,71.62 v2(116.55,71.71)
  IN4 w0.254: v2(117.31,56.28) 117.18,56.42 116.06,56.42 115.92,56.28 114.46,56.28 110.51,52.33 110.51,49.74 109.56,48.79 102.97,48.79 102.34,48.16 96.86,48.16 93.62,44.92 93.62,40.98 92.42,39.77 90.7,39.77 88.33,37.4 88.33,34.82 88.71,34.44 89.55,34.44 v2(89.62,34.51)
  BOTTOM w0.254: v2(117.31,56.28) 117.18,56.16 117.18,52.58 117.82,51.94 PLI06.3 ; v2(89.62,34.51) 89.47,34.67 PCI212.1
CORE_V6P: length 54.5
  TOP w0.254: v2(117.25,56.92) 118.1,56.92 PRI114.2 118.18,57.46 PRI115.1
  IN4 w0.254: v2(89.57,33.93) 89.44,34.06 88.42,34.06 87.95,34.54 87.95,37.56 90.55,40.16 91.02,40.16 92.26,40.16 93.24,41.14 93.24,45.08 96.7,48.54 102.18,48.54 102.82,49.17 109.4,49.17 110.13,49.9 110.13,52.49 114.3,56.66 115.76,56.66 115.9,56.8 117.13,56.8 v2(117.25,56.92)
  BOTTOM w0.254: v2(117.25,56.92) 116.8,56.47 116.8,52.2 116.55,51.94 PLI06.2 ; v2(89.57,33.93) 89.56,33.93 89.46,33.83 PRI227.1
CPU_2_PCH_TRIG_C: length 14.8
  BOTTOM w0.102: 129.95,84.99 130.43,84.5 130.43,81.74 UC1.B3
  BOTTOM w0.112: RC36.2 122.83,89.62 v1(123.03,89.81) 123.85,89.81 126.52,87.15 127.79,87.15 129.95,84.99
CPU_24MHZ_N: length 228
  TOP w0.089: UH1.C6 289.65,42.38 289.65,41.82 289.67,41.8 289.67,41.11 289.92,40.87 289.92,39.37 288.67,38.13 288.67,35.84 287.21,34.38 286.51,34.38 286.5,34.39 286.45,34.39 286.43,34.39
  TOP w0.112: v2(282.78,32.44) 282.59,32.63 282.59,33.72 283.26,34.39 v4(285.78,34.39) 286.43,34.39
  IN1 w0.084: v2(282.78,32.44) 282.57,32.66 282.57,32.84 282.39,33.02 281.87,33.02 279.76,30.91 275.88,30.91 274.46,32.34 272.37,32.34 271.93,32.77 263.51,32.77 263.04,33.24 260.35,33.24 256.46,37.13 254.67,37.13 253.92,37.88 253.92,55.52 253.09,56.35 253.09,76.43 251.71,77.81 246.35,77.81 244.52,79.65 244.52,87.37 243.44,88.45 241.23,88.45 237.38,92.29 232.4,92.29 232.04,92.65 229.4,92.65 228.35,93.7 227.41,93.7 226.59,94.52 224.26,94.52 223.21,95.57 222.39,95.57 221.52,94.7 210.08,94.7 209.22,95.56 204.67,95.56 202.94,93.83 166.35,93.83 163.81,91.29 163.26,91.29 160.33,88.36 160.33,87.15 157.46,84.28 157.46,83.05 156.37,81.95 153.71,81.95 151.37,79.61 151.37,76.45 151.19,76.26 141.26,76.26 140.4,75.41 138.81,75.41 138.62,75.22 138.62,75.04 138.54,74.95 138.32,74.95 v2(138.24,74.87)
  BOTTOM w0.112: v2(138.24,74.87) 137.79,75.32 UC1.J9
CPU_24MHZ_P: length 228.1
  TOP w0.089: UH1.D7 289.35,42.54 289.35,42.27 289.46,42.16 289.46,41.74 289.47,41.73 289.48,41.38 289.48,41.17 289.49,41.16 289.5,41.04 289.74,40.8 289.74,39.44 288.49,38.2 288.49,35.91 287.14,34.55 286.58,34.55 286.57,34.57 286.52,34.57 286.5,34.58 286.49,34.58
  TOP w0.112: v2(282.2,32.44) 282.39,32.64 282.39,33.81 283.18,34.59 285.51,34.59 285.52,34.6 286.04,34.6 286.05,34.59 286.48,34.59 286.49,34.58
  IN1 w0.084: v2(282.2,32.44) 282.4,32.65 282.4,32.77 282.32,32.85 281.94,32.85 279.83,30.75 275.81,30.75 274.39,32.17 272.3,32.17 271.86,32.6 263.44,32.6 262.97,33.07 260.28,33.07 256.39,36.96 254.6,36.96 253.76,37.81 253.76,55.45 252.92,56.28 252.92,76.36 251.64,77.65 246.28,77.65 244.35,79.58 244.35,87.3 243.37,88.28 241.16,88.28 237.31,92.12 232.33,92.12 231.97,92.49 229.33,92.49 228.28,93.54 227.34,93.54 226.52,94.35 224.19,94.35 223.14,95.4 222.46,95.4 221.59,94.53 210.01,94.53 209.15,95.39 204.74,95.39 203.01,93.66 166.42,93.66 163.88,91.12 163.33,91.12 160.5,88.3 160.5,87.08 157.63,84.21 157.63,82.98 156.44,81.79 153.78,81.79 151.54,79.54 151.54,76.38 151.26,76.1 141.33,76.1 140.47,75.24 138.88,75.24 138.79,75.15 138.79,75.04 138.88,74.95 139.1,74.95 139.18,74.87 v2(139.18,74.84)
  BOTTOM w0.112: UC1.K9 139.17,74.84 v2(139.18,74.84)
CPU_B+: length 47.9
  TOP w0.508: PRZ04.2 58.51,32.92 57.87,33.55 57.87,35.85 59.19,37.16 61.19,37.16 61.84,36.51 62.55,36.51 63.85,37.81 70.95,37.81 73.25,40.1 v2(73.81,40.1)
  BOTTOM w0.508: 96.35,42.76 93.88,45.24 78.95,45.24 v2(73.81,40.1)
  vias: v1(104.36,52.73) v2(95.53,41.74) v2(95.53,41.16) v2(95.66,38.82) v2(95.66,38.24) v2(95.78,34.69) v2(95.78,34.11) v2(95.78,31.58) v2(95.78,31) v2(95.85,27.52) v2(95.85,26.93) v2(96.11,41.74) v2(96.11,41.16) v2(96.24,38.82) v2(96.24,38.24) v2(96.37,34.69) v2(96.37,34.11) v2(96.37,31.58) v2(96.37,31) v2(96.43,27.52) v2(96.43,26.93) v2(96.7,41.74) v2(96.7,41.16) v2(96.82,38.82) v2(96.82,38.24) v2(96.95,34.69) v2(96.95,34.11) v2(96.95,31.58) v2(96.95,31) v2(97.01,27.52) v2(97.01,26.93) v2(101.26,28) v2(101.26,27.42) v2(102.64,27.87) v2(102.64,27.29) v2(102.64,26.71) v2(102.7,47.84) v2(102.7,47.25) v2(102.7,46.67) v2(102.7,46.09) v2(102.7,45.5) v2(102.82,38.69) v2(102.95,37.06) v2(103.2,36.54) v2(103.23,26.71) v2(103.29,47.84) v2(103.29,47.25) v2(103.29,46.67) v2(103.29,46.09) v2(103.29,45.5) v2(103.4,38.69) v2(103.53,37.06) v2(103.78,36.54) v2(104.11,37.06) v2(104.99,55.4) v2(104.99,54.81) v2(104.99,54.23) v2(104.99,53.64) v2(105.21,44.96) v2(105.21,43.34) v2(105.19,35.73) v2(105.19,34.1) v2(105.39,26.76) v2(105.39,25.14) v2(105.57,55.4) v2(105.57,54.81) v2(105.57,54.23) v2(105.57,53.64) v2(106.16,55.4) v2(106.16,54.81) v2(106.66,53.33) v2(106.66,51.71) v2(106.98,63.78) v2(106.98,63.19) v2(106.98,62.61) v2(107.57,63.19) v2(107.57,62.61) v2(108.67,62.22) v2(108.67,60.6) v2(109.14,75.46) v2(109.14,74.88) v2(109.14,74.29) v2(109.73,75.46) v2(109.73,74.88) v2(109.73,74.29) v2(110.8,73.45) v2(110.8,71.82) v2(111.86,88.24) v2(111.86,87.6) v2(111.86,86.97) v2(111.86,86.33) v2(112.5,88.24) v2(112.5,87.6) v2(112.5,86.97) v2(112.5,86.33) v2(113.13,88.24) v2(113.13,87.6) v2(113.13,86.97) v2(113.13,86.33) v2(113.77,88.24) v2(113.77,87.6) v2(113.77,86.97) v2(113.77,86.33) v2(124.84,14.56) v2(125.18,13.99) v2(125.75,14.12) v2(126.09,15.59) v2(127.72,15.59) v2(142.62,16.17) v2(143.31,16.29) v2(143.31,15.66) v2(143.31,15.02) v2(143.31,14.39) v2(143.94,16.29) v2(143.94,15.66) v2(143.94,15.02) v2(143.94,14.39) v2(145.55,15.88) v2(147.17,15.88)
CPU_DDC1CLK: length 8.1
  TOP w0.076: v2(28.13,45.83) 28.36,45.83 28.85,46.31 29.68,46.31 30.31,46.95 v1(30.57,46.95) 31.52,46.95 32.16,47.58 32.16,49.3 32.35,49.49 v2(32.35,49.87)
  BOTTOM w0.076: v2(28.13,45.83) 28.14,45.83 28.14,45.83 UT1.Y5
  BOTTOM w0.112: v2(32.35,49.87) 32.36,49.88 RT127.1
CPU_DDC1DATA: length 13.8
  TOP w0.076: v2(26.17,46.47) 26.21,46.47 26.57,46.82 26.57,47.27 25.36,48.47 25.36,49.49 25.81,49.93 25.81,50.44
  TOP w0.112: v2(32.36,51.64) v1(31.78,52.22) 27.02,52.22 25.81,51.01 25.81,50.44
  BOTTOM w0.076: UT1.R4 v2(26.17,46.47)
  BOTTOM w0.112: RT126.1 v2(32.36,51.64)
CPU_DDC2CLK: length 9.9
  TOP w0.112: RT129.1 34,48.81 33.74,48.55 33.74,47.65 34.06,47.34 v1(34.06,47.08) 34.06,46.76 32.92,45.62 32.41,45.62
  TOP w0.127: v2(28.76,44.51) 28.78,44.51 28.78,44.52 29.12,44.87 29.43,44.87 29.82,45.25 32.04,45.25 32.41,45.62
  BOTTOM w0.076: UT1.Y8 28.76,44.52 28.78,44.52 28.78,44.51 v2(28.76,44.51)
CPU_DDC2DATA: length 13.6
  TOP w0.112: RT128.1 v2(34,50.84)
  IN1 w0.084: v2(25.52,46.47) 24.99,47 24.99,48.01 25.29,48.3 25.29,48.63 25.15,48.78 25.15,48.99 26.98,50.83 33.99,50.83 v2(34,50.84)
  BOTTOM w0.102: UT1.N4 v2(25.52,46.47)
CPU_DISPA_BCLK: length 214.4
  TOP w0.112: RH38.1 v1(300.32,57.99) 300.82,57.48 v2(300.82,56.95)
  IN4 w0.084: v2(143.63,96.63) 143.92,96.63 145.96,94.58 150.54,94.58 156.09,100.13 161.46,100.13 164.3,102.98 169.29,102.98 174.52,108.2 180.17,108.2 184.71,103.67 211.65,103.67 212.35,102.97 227.54,102.97 229.46,104.89 245.68,104.89 246.92,103.65 267.67,103.65 295.95,75.36 295.95,72.86 300.23,68.58 300.23,57.54 v2(300.82,56.95)
  BOTTOM w0.102: UC1.V3 145.57,81.23 145.57,81.88 145.42,82.03 145.42,82.82 145.34,82.9 145.34,83.44 145.89,83.99 145.89,84.13 146.01,84.25 146.01,84.99
  BOTTOM w0.112: 146.01,84.99 146.01,94.6 143.99,96.63 v2(143.63,96.63)
CPU_DISPA_BCLK_R: length 8.1
  TOP w0.089: UH1.AM3 291.51,56.85 291.77,57.11 292.2,57.11 292.72,57.63 293.52,57.63 294.2,58.32 v1(294.36,58.32) 294.92,58.88 297.28,58.88 297.88,58.28
  TOP w0.112: 297.88,58.28 298.17,57.99 RH38.2
CPU_DISPA_SDI: length 24.7
  BOTTOM w0.102: UC1.U1 144.96,82.77 144.96,83.46 145.71,84.21 145.71,84.99
  BOTTOM w0.112: RC1.1 141.79,104.41 141.79,102.7 141.47,102.38 141.47,94.03 145.71,89.78 145.71,84.99
CPU_DISPA_SDI_R: length 198.4
  TOP w0.089: UH1.AN3 291.95,57.32 292.37,57.74 v2(292.37,57.81)
  TOP w0.112: v2(196.09,108) v1(196.09,108.58)
  IN2 w0.104: v2(292.37,57.81) 292.09,57.81 289.22,60.68 289.22,63.35 289.78,63.9 289.78,68.11 289.22,68.67 289.22,72.38 287.91,73.69 287.91,74.45 286.97,75.39 286.97,75.99 285.98,76.98 285.98,78.81 277.82,86.97 277.82,95.94 268.7,105.07 263.74,105.07 263.15,105.66 238.86,105.66 238.35,106.17 222.23,106.17 221.93,106.46 214.29,106.46 214.1,106.66 213.71,106.66 197.02,106.66 196.09,107.59 v2(196.09,108)
  IN3 w0.104: v2(140.98,102.19) 141.36,101.82 145.94,101.82 146.54,102.42 156.03,102.42 156.77,101.68 169.23,101.68 174.43,96.48 183.56,96.48 195.08,108 v2(196.09,108)
  BOTTOM w0.112: v2(140.98,102.19) 140.98,103.62 RC1.2
CPU_DISPA_SDO: length 214.8
  TOP w0.112: RH39.1 299.86,57.2 v1(300.43,56.63) 300.66,56.4 v2(301.01,56.4)
  IN4 w0.084: v2(143.63,97.21) 146.05,94.79 150.45,94.79 156,100.34 161.37,100.34 164.21,103.19 169.2,103.19 174.43,108.42 180.26,108.42 184.8,103.88 211.74,103.88 212.43,103.18 227.45,103.18 229.37,105.1 245.77,105.1 247,103.86 267.75,103.86 296.16,75.45 296.16,72.95 300.44,68.67 300.44,57.89 301.22,57.11 301.22,56.6 v2(301.01,56.4)
  BOTTOM w0.102: 146.25,84.99 146.25,84.2 146.1,84.04 146.1,83.89 145.66,83.45 145.66,82.37 146.01,82.02 UC1.V2
  BOTTOM w0.112: v2(143.63,97.21) 143.74,97.21 146.25,94.7 146.25,84.99
CPU_DISPA_SDO_R: length 7.7
  TOP w0.089: UH1.AM2 292.18,56.82 292.76,57.4 293.56,57.4 293.98,57.83 294.29,57.83 295.04,58.58 v1(295.69,58.58) 296.89,58.58 297.88,57.58
  TOP w0.112: RH39.2 298.08,57.39 298.07,57.39 297.88,57.58
CPU_DP1_AUXN: length 131.2
  TOP w0.112: CT26.1 34.39,43.49 34.63,43.49 34.71,43.57 34.82,43.57 34.93,43.68 34.93,43.78 v2(34.7,44.01)
  IN4 w0.084: v2(34.7,44.01) 34.91,43.8 34.91,43.61 35.14,43.38 36.1,43.38 37.62,41.86 41.07,41.86 41.36,41.58 48.25,41.58 50.11,43.44 54.02,43.44 60.8,50.22 83.52,50.22 101.41,68.11 101.41,77.19 107.59,83.37 123.69,83.37 127.93,79.13 127.93,76.47 129.07,75.33 129.07,72.34 129.59,71.82 130.09,71.82 130.36,71.55 131.47,71.55 v2(131.8,71.22)
  BOTTOM w0.112: UC1.C13 132.24,71.66 v2(131.8,71.22)
CPU_DP1_AUXN_C: length 7.3
  TOP w0.112: CT26.2 33.13,43.68 RT76.1 31.58,43.78 30.8,44.57 29.85,44.57 29.56,44.28 29.47,44.28 29.06,44.28 28.91,44.14 28.48,44.14 28.27,44.22 28.01,44.22 27.48,43.88 v2(27.47,43.86)
  BOTTOM w0.076: UT1.W11 v2(27.47,43.86)
CPU_DP1_AUXP: length 131.2
  TOP w0.112: CT25.1 34.36,43.27 34.72,43.27 34.8,43.35 34.91,43.35 35.15,43.59 35.15,43.87 v2(35.29,44.01)
  IN4 w0.084: v2(35.29,44.01) 35.08,43.8 35.08,43.68 35.21,43.55 36.17,43.55 37.68,42.03 41.14,42.03 41.43,41.74 48.18,41.74 50.04,43.61 53.95,43.61 60.73,50.38 83.45,50.38 101.24,68.18 101.24,77.26 107.52,83.53 123.76,83.53 128.1,79.2 128.1,76.54 129.24,75.4 129.24,72.41 129.66,71.99 130.16,71.99 130.43,71.72 131.43,71.72 v2(131.8,72.1)
  BOTTOM w0.112: v2(131.8,72.1) 131.8,72.08 UC1.B13
CPU_DP1_AUXP_C: length 7.3
  TOP w0.112: CT25.2 33.59,43.12 RT78.1 32.59,43.56 v4(31.97,43.56) 31.49,43.56 30.7,44.35 29.94,44.35 29.65,44.06 29.15,44.06 28.92,43.84 28.92,43.58 28.86,43.52 28.67,43.52 28.59,43.6 28.59,43.74 28.48,43.85 v2(28.12,43.85)
  BOTTOM w0.076: v2(28.12,43.85) 28.12,43.67 28.25,43.54 UT1.Y11
CPU_DP1_CTRL_CLK: length 16
  TOP w0.089: v2(285.84,56.35) 285.87,56.31 285.89,56.31 UH1.AL13 ; v2(297.43,60.3) 297.57,60.44 297.88,60.44
  TOP w0.112: RH604.2 298,60.44 297.88,60.44
  BOTTOM w0.112: v2(297.43,60.3) 297.43,59.81 296.31,58.7 v1(294.29,58.7) 293.84,58.7 293.16,59.38 292.65,59.38 290.85,57.58 289,57.58 288.49,57.07 288.49,56.67 287.97,56.15 286.6,56.15 286.4,56.35 v2(285.84,56.35)
CPU_DP1_CTRL_DATA: length 11.6
  TOP w0.089: v2(289.48,58.02) 289.47,58.02 289.47,58.03 289.28,58.22 UH1.AR8 ; 297.88,60.68 297.56,60.68 297.43,60.81 v2(297.43,60.89)
  TOP w0.112: 297.88,60.68 297.99,60.68 RH605.2
  BOTTOM w0.112: v2(289.48,58.02) 289.57,58.1 290.68,58.1 292.45,59.87 293.36,59.87 294.04,59.19 296.11,59.19 v1(296.89,59.97) 296.94,60.02 296.94,60.51 297.23,60.8 297.29,60.8 297.36,60.86 297.41,60.86 v2(297.43,60.89)
CPU_DP1_HPD: length 339
  TOP w0.089: UH1.AT6 289.55,58.41 v2(289.24,58.73)
  IN3 w0.104: v2(30.46,49.08) 30.15,49.08 29.68,48.6 29.68,47.72 29.97,47.42 29.97,47.18 30.85,46.3 30.85,45.39 30.52,45.06 30.52,44.88 31.23,44.17 31.23,41.92 32.09,41.06 32.09,35.54 31.58,35.04 31.58,31.88 35.8,27.67 35.8,26.1 36.97,24.93 45.19,24.93 45.78,24.34 50.18,24.34 51.18,23.34 57.62,23.34 60.02,20.93 60.96,20.93 62.69,19.21 66.47,19.21 69.01,16.66 69.06,16.66 70.17,15.55 78.78,15.55 82.84,19.61 82.84,20.38 83.13,20.67 85.65,20.67 86.08,20.24 88.46,20.24 89.07,20.85 90.96,20.85 91.57,20.24 103.13,20.24 103.48,19.89 103.57,19.81 108.23,19.81 109.52,18.51 110.44,18.51 110.96,17.99 110.96,17.29 111.2,17.05 111.23,17.05 113.1,15.17 116.82,15.17 117.75,16.11 121.35,16.11 121.88,15.58 125.52,15.58 125.93,15.18 141.06,15.18 142.58,16.7 144.11,16.7 144.3,16.51 149.72,16.51 152.32,19.12 168.16,19.12 171.16,22.11 184.76,22.11 188.28,18.59 219.95,18.59 220.32,18.22 225.13,18.22 226.41,19.5 228.29,19.5 230.91,22.11 237.99,22.11 238.42,22.55 245.46,22.55 246.09,21.92 257.11,21.92 265.57,30.38 280.22,30.38 280.9,31.06 284.32,31.06 284.54,31.28 287.53,31.28 288.78,30.04 v2(288.82,30.04)
  IN4 w0.084: v2(288.82,30.04) 288.96,30.04 289.93,31 289.93,40.09 291.53,41.7 291.53,48.3 290.53,49.3 290.53,50.91 288.53,52.92 287.75,53.7 287.75,54.25 287.1,54.9 287.1,55.63 288.22,56.75 288.22,57.72 288.31,57.81 288.31,57.81 v2(289.24,58.73)
  BOTTOM w0.089: 29.37,48.5 29.3,48.5 28.93,48.12 28.93,48.11 28.92,48.1 28.92,47.86 28.92,47.72 UT1.AA2
  BOTTOM w0.102: 29.37,48.5 29.47,48.5
  BOTTOM w0.112: 29.47,48.5 30,49.02 30.41,49.02 v2(30.46,49.08) 30.46,49.46 30.51,49.51 RT38.1
CPU_DP1_N0: length 147.2
  IN4 w0.084: v2(126.37,71.02) 126.58,70.81 126.58,70.73 126.49,70.64 125.21,70.64 122.94,72.92 121.81,72.92 117.18,77.54 108.69,77.54 106.3,75.16 106.3,65.54 85.84,45.08 78.69,45.08 77.24,43.62 73.61,43.62 66.47,36.48 62.41,36.48 62.08,36.16 60.01,36.16 59.55,36.62 52.95,36.62 50.99,34.65 45.47,34.65 44.37,33.55 40.84,33.55 38.71,35.68 35.91,35.68 35.43,35.2 34.33,35.2 32.27,37.26 32.27,41.16 32.41,41.29 32.41,43.87 32.82,44.28 32.82,45.35 32.9,45.44 33.51,45.44 v2(33.71,45.24)
  BOTTOM w0.102: 129.82,63.96 129.84,63.96 129.85,63.96 130.58,63.96 130.63,63.91 131.74,63.91 131.87,63.78 132.65,63.78 132.9,64.03 132.9,64.16 133.08,64.34 UC1.D21
  BOTTOM w0.112: v2(33.71,45.24) 33.36,45.59 33.2,45.59 32.94,45.32 32.86,45.32 CT7.1 ; v2(126.37,71.02) 126.55,70.83 126.55,66.93 129.52,63.96 129.82,63.96
CPU_DP1_N0_C: length 2.9
  BOTTOM w0.076: UT1.AC7 29.58,45.19 29.47,45.08 29.47,45.02 29.54,44.95 29.76,44.95 30.01,45.2 v4(30.9,45.2) 31.56,45.2 31.77,44.99
  BOTTOM w0.112: CT7.2 31.77,44.99
CPU_DP1_N1: length 147.7
  IN4 w0.084: v2(34.27,45.41) 34.48,45.21 34.48,44.77 32.88,43.16 32.88,41.1 32.74,40.96 32.74,37.45 34.05,36.14 38.91,36.14 40.99,34.06 44.16,34.06 45.22,35.12 50.3,35.12 52.26,37.09 65.25,37.09 65.39,37.09 67.36,39.06 68.38,39.06 73.42,44.09 77.04,44.09 78.49,45.54 85.61,45.54 105.84,65.78 105.84,75.35 108.62,78.14 117.25,78.14 122,73.38 123.13,73.38 124.27,72.24 125.53,72.24 v2(125.74,72.04)
  BOTTOM w0.102: UC1.E22 134.12,63.36 133.62,62.86 131.24,62.86 130.85,63.25 129.84,63.25 129.84,63.24 129.82,63.24
  BOTTOM w0.112: v2(125.74,72.04) 125.92,72.21 126.02,72.21 126.13,72.1 126.13,71.7 125.74,71.31 125.74,66.73 129.23,63.24 129.82,63.24 ; CT9.1 34.02,44.39 34.18,44.39 34.47,44.68 34.47,45.22 v2(34.27,45.41)
CPU_DP1_N1_C: length 4.3
  BOTTOM w0.076: 31.77,44.47 31.52,44.47 31.52,44.46 29.92,44.46 29.87,44.51 29.46,44.51 29.39,44.44 29.39,44.34 29.46,44.27 UT1.AC9
  BOTTOM w0.112: 31.77,44.47 32.06,44.47 32.11,44.42 32.87,44.42 33.13,44.68 CT9.2
CPU_DP1_N2: length 144.9
  IN4 w0.084: v2(125.75,74.51) 122.01,74.51 117.58,78.94 108.29,78.94 105.04,75.68 105.04,66.11 85.27,46.34 78.16,46.34 76.71,44.89 73.09,44.89 68.05,39.86 67.03,39.86 65.06,37.89 51.93,37.89 50.77,36.72 48.55,36.72 47.75,35.92 40.26,35.92 39.18,37 34.33,37 33.54,37.78 33.54,40.63 33.96,41.05 34.66,41.76 35.03,41.76 35.56,42.28 v2(35.56,42.94)
  BOTTOM w0.102: 129.82,62.53 129.82,62.53 129.84,62.54 129.97,62.54 130.27,62.84 130.69,62.84 130.83,62.7 130.83,62.59 130.76,62.51 UC1.A23
  BOTTOM w0.112: v2(35.56,42.94) 35.46,43.03 35.46,43.34 35.22,43.58 32.67,43.58 CT23.1 ; v2(125.75,74.51) 125.63,74.39 125.27,74.39 124.98,74.1 124.98,66.48 128.93,62.53 129.82,62.53
CPU_DP1_N2_C: length 3
  BOTTOM w0.076: 31.77,43.73 31.56,43.52 31.35,43.52 31.31,43.55 30.54,43.55 30.53,43.54 30,43.54 29.96,43.59 29.46,43.59 29.39,43.52 29.39,43.42 29.46,43.35 UT1.AC11
  BOTTOM w0.112: CT23.2 31.77,43.73
CPU_DP1_N3: length 148.8
  IN4 w0.084: v2(38.13,41.21) 38.12,41.2 37.53,41.2 37.44,41.29 34.86,41.29 34.03,40.46 34.03,39.87 34,39.84 34,37.98 34.52,37.46 40.62,37.46 41.7,36.38 46.66,36.38 47.46,37.18 50.57,37.18 52.39,39 65.52,39 66.98,40.47 68.01,40.47 72.89,45.35 76.01,45.35 77.47,46.81 85.08,46.81 104.57,66.3 104.57,75.88 108.1,79.4 117.77,79.4 121.71,75.46 123.64,75.46 v2(123.79,75.32)
  BOTTOM w0.102: UC1.D23 133.06,62.36 133.06,62.17 132.81,61.93 130.27,61.93 130.02,61.68 129.84,61.68 129.84,61.67 129.82,61.67
  BOTTOM w0.112: v2(38.13,41.21) 37.67,41.21 37.55,41.33 37.55,41.35 37.17,41.73 37.14,41.73 36.35,42.53 34.49,42.53 34.23,42.79 33.92,42.79 CT24.1 ; 129.82,61.67 128.57,61.67 124.26,65.97 124.26,75.29 124.15,75.4 123.87,75.4 v2(123.79,75.32)
CPU_DP1_N3_C: length 4.2
  BOTTOM w0.076: 31.77,42.68 31.76,42.68 31.75,42.67 31.69,42.67 31.67,42.66 31.3,42.66 31.2,42.55 30.02,42.55 29.9,42.67 29.53,42.67 29.46,42.6 29.46,42.5 29.53,42.43 UT1.AC13
  BOTTOM w0.112: CT24.2 32.81,42.68 32.74,42.68 31.77,42.68
CPU_DP1_P0: length 147.2
  IN4 w0.084: v2(33.71,45.82) 33.49,45.61 32.83,45.61 32.65,45.42 32.65,44.35 32.24,43.94 32.24,41.36 32.11,41.22 32.11,37.19 34.26,35.03 35.5,35.03 35.98,35.51 38.64,35.51 40.77,33.38 44.44,33.38 45.54,34.49 51.06,34.49 53.02,36.45 59.48,36.45 59.94,35.99 62.15,35.99 62.48,36.31 66.54,36.31 73.68,43.46 77.31,43.46 78.76,44.91 85.91,44.91 106.47,65.47 106.47,75.09 108.76,77.38 117.11,77.38 121.74,72.75 122.87,72.75 125.14,70.48 126.56,70.48 126.74,70.66 126.74,70.81 v2(126.95,71.02)
  BOTTOM w0.102: UC1.C21 132.62,64.34 132.7,64.27 132.7,64.12 132.56,63.99 131.95,63.99 131.82,64.11 130.72,64.11 130.66,64.17 129.84,64.17 129.84,64.18 129.82,64.18
  BOTTOM w0.112: 129.82,64.18 129.61,64.18 126.77,67.02 126.77,70.83 v2(126.95,71.02) ; CT6.1 32.84,45.54 33.11,45.81 33.69,45.81 v2(33.71,45.82)
CPU_DP1_P0_C: length 2.9
  BOTTOM w0.076: 31.77,45.45 31.7,45.38 30.66,45.38 30.64,45.36 29.82,45.36 29.77,45.41 29.42,45.41 29.2,45.19 UT1.AB7
  BOTTOM w0.112: CT6.2 31.77,45.45
CPU_DP1_P1: length 147.7
  IN4 w0.084: v2(34.86,45.41) 34.65,45.21 34.65,44.7 33.04,43.09 33.04,41.03 32.91,40.89 32.91,37.52 34.12,36.31 38.98,36.31 41.06,34.23 44.09,34.23 45.15,35.29 50.23,35.29 52.19,37.25 65.32,37.25 67.29,39.22 68.31,39.22 73.35,44.26 76.97,44.26 78.42,45.71 85.54,45.71 105.67,65.85 105.67,75.42 108.56,78.31 117.32,78.31 122.07,73.55 123.2,73.55 124.34,72.41 125.53,72.41 v2(125.74,72.62)
  BOTTOM w0.102: 129.82,63.46 129.84,63.46 129.85,63.45 130.94,63.45 131.33,63.07 133.54,63.07 133.66,63.18 133.66,63.33 133.55,63.43 UC1.D22
  BOTTOM w0.112: CT8.1 33.92,44.17 34.27,44.17 34.69,44.59 34.69,45.24 v2(34.86,45.41) ; v2(125.74,72.62) 125.93,72.43 126.11,72.43 126.35,72.19 126.35,71.61 125.96,71.22 125.96,66.82 129.32,63.46 129.82,63.46
CPU_DP1_P1_C: length 4.3
  BOTTOM w0.076: UT1.AB9 29.42,44.05 29.84,44.05 30.08,44.3 31.5,44.3 31.55,44.24 31.77,44.24
  BOTTOM w0.112: CT8.2 32.89,44.2 32.02,44.2 31.97,44.24 31.77,44.24
CPU_DP1_P2: length 144.8
  IN4 w0.084: v2(34.98,42.94) 35,42.94 35.39,42.54 35.39,42.35 34.96,41.92 34.59,41.92 33.79,41.12 33.37,40.7 33.37,37.71 34.26,36.83 39.11,36.83 40.19,35.75 47.82,35.75 48.62,36.55 50.84,36.55 52,37.72 65.13,37.72 67.1,39.69 68.12,39.69 73.16,44.72 76.78,44.72 78.23,46.18 85.34,46.18 105.21,66.04 105.21,75.61 108.36,78.77 117.51,78.77 121.94,74.34 125.33,74.34 v2(125.75,73.92)
  BOTTOM w0.102: UC1.B23 131.13,62.51 131.03,62.61 131.03,62.79 130.77,63.05 130.19,63.05 129.88,62.74 129.84,62.74 129.83,62.75 129.82,62.75
  BOTTOM w0.112: CT10.1 32.73,43.36 35.13,43.36 35.24,43.25 35.24,43.2 v2(34.98,42.94) ; 129.82,62.75 129.03,62.75 125.2,66.57 125.2,74 125.36,74.17 125.52,74.17 125.75,73.94 v2(125.75,73.92)
CPU_DP1_P2_C: length 3
  BOTTOM w0.076: 31.77,43.16 31.6,43.33 31.27,43.33 31.24,43.36 v4(30.9,43.36) 30.58,43.36 30.57,43.36 30,43.36 29.77,43.13 29.36,43.13 UT1.AB11
  BOTTOM w0.112: CT10.2 31.77,43.16
CPU_DP1_P3: length 148.7
  IN4 w0.084: v2(38.13,40.62) 37.72,41.03 37.46,41.03 37.37,41.12 34.93,41.12 34.2,40.39 34.2,39.8 34.17,39.77 34.17,38.05 34.59,37.63 40.69,37.63 41.77,36.55 46.59,36.55 47.39,37.35 50.5,37.35 52.32,39.17 65.45,39.17 66.91,40.64 67.94,40.64 72.82,45.52 75.95,45.52 77.4,46.98 85.01,46.98 104.41,66.37 104.41,75.95 108.03,79.57 117.84,79.57 121.78,75.63 123.51,75.63 v2(123.79,75.9)
  BOTTOM w0.102: UC1.C23 132.72,62.51 132.85,62.38 132.85,62.26 132.73,62.13 130.19,62.13 129.94,61.88 129.85,61.88 129.84,61.89 129.82,61.89
  BOTTOM w0.112: CT11.1 33.92,42.57 34.14,42.57 34.4,42.31 36.25,42.31 v4(37.19,41.37) 37.57,40.99 37.76,40.99 v2(38.13,40.62) ; 129.82,61.89 128.66,61.89 124.48,66.06 124.48,75.38 124.24,75.62 124.07,75.62 v2(123.79,75.9)
CPU_DP1_P3_C: length 4.2
  BOTTOM w0.076: 31.77,42.46 31.76,42.46 31.75,42.47 31.38,42.47 31.27,42.36 29.92,42.36 29.77,42.21 29.45,42.21 29.23,42.43 UT1.AB13
  BOTTOM w0.112: CT11.2 33.03,42.46 32.81,42.46 32.74,42.46 31.77,42.46
CPU_DP2_AUXN: length 132.5
  TOP w0.112: v2(36.63,44.03) 36.37,43.76 36.37,42.65 35.89,42.17 34.66,42.17 34.03,41.54 33.78,41.54 CT36.1
  IN4 w0.084: v2(36.63,44.03) 36.63,44.34 37.09,44.8 37.7,44.8 40,42.49 41.33,42.49 41.62,42.21 46.21,42.21 48.07,44.07 51.16,44.07 51.51,44.42 53.8,44.42 60.22,50.85 83.14,50.85 100.78,68.49 100.78,77.45 107.33,84 123.95,84 128.56,79.39 128.56,76.73 130.29,75.01 130.29,73.31 130.13,73.15 130.01,73.15 129.7,73.46 v2(129.7,73.48)
  BOTTOM w0.102: UC1.B12 131.08,72.57 130.96,72.69 130.96,72.9 130.73,73.12 130.26,73.12 130.14,73.24 129.94,73.24 129.87,73.31
  BOTTOM w0.112: 129.87,73.31 v2(129.7,73.48)
CPU_DP2_AUXN_C: length 6.9
  TOP w0.112: v2(27.49,43.21) 27.65,43.05 27.65,42.84 27.89,42.6 v4(29.56,42.6) 30.29,42.6 31.14,41.75 31.4,41.75 31.8,41.35 RT77.1 32.47,41.37 CT36.2
  BOTTOM w0.076: v2(27.49,43.21) 27.49,43.2 UT1.W12
CPU_DP2_AUXP: length 132.5
  TOP w0.112: v2(36.05,44.03) 36.15,43.93 36.15,42.74 35.8,42.39 34.57,42.39 33.94,41.76 33.78,41.76 CT35.1
  IN4 w0.084: v2(129.7,72.9) 129.79,72.98 130.2,72.98 130.45,73.24 130.45,75.08 128.73,76.8 128.73,79.46 124.02,84.17 107.26,84.17 100.61,77.52 100.61,68.56 83.07,51.02 60.15,51.02 53.73,44.59 51.44,44.59 51.09,44.24 48,44.24 46.14,42.38 41.69,42.38 41.4,42.66 40.07,42.66 37.77,44.96 37.02,44.96 36.48,44.43 36.45,44.43 v2(36.05,44.03)
  BOTTOM w0.102: UC1.A12 130.65,72.57 130.76,72.68 130.76,72.81 130.65,72.92 130.18,72.92 130.06,73.04 129.86,73.04 129.86,73.04
  BOTTOM w0.112: v2(129.7,72.9) 129.85,73.04 129.86,73.04
CPU_DP2_AUXP_C: length 6.9
  TOP w0.112: v2(28.11,43.21) 27.99,43.21 27.87,43.09 27.87,42.93 27.98,42.82 30.38,42.82 v4(31.02,42.19) 31.24,41.97 31.49,41.97 31.89,41.57 32.05,41.57 RT79.1 32.47,41.93 CT35.2
  BOTTOM w0.076: UT1.Y12 28.35,42.89 28.11,43.12 v2(28.11,43.21)
CPU_DP2_CTRL_CLK: length 16.6
  TOP w0.089: UH1.AN13 286.22,57.48 v2(286.04,57.66)
  TOP w0.112: RH607.2 298,63.08 297.86,63.08 297.58,62.79 v2(297.5,62.79)
  BOTTOM w0.112: v2(297.5,62.79) 297.43,62.73 296.35,62.73 295.55,61.93 295.55,60.56 295.55,60.55 294.93,59.92 294.39,59.92 293.71,60.6 291.87,60.6 291.13,59.86 v1(290.1,59.86) 289.8,59.86 289.45,59.51 288.84,59.51 287.77,58.44 287.41,58.44 286.62,57.66 v2(286.04,57.66)
CPU_DP2_CTRL_DATA: length 16.1
  TOP w0.089: UH1.AL10 287.72,56.3 v2(287.45,56.56)
  TOP w0.112: v2(297.5,62.21) 297.67,62.38 297.69,62.38 297.86,62.38 298.07,62.59 298.23,62.59 298.27,62.54 RH606.2
  BOTTOM w0.112: v2(297.5,62.21) 297.48,62.23 296.55,62.23 296.05,61.73 296.05,60.82 296.05,60.34 295.13,59.43 294.19,59.43 293.51,60.11 292.07,60.11 v1(291.74,59.78) 291.34,59.37 289.65,59.37 289.55,59.27 289.45,59.27 289.44,59.26 288.93,59.26 288.29,58.62 288.29,57.68 287.72,57.11 287.72,56.82 v2(287.45,56.56)
CPU_DP2_HPD: length 331
  TOP w0.089: UH1.AN10 287.72,57.9 287.58,58.03 v2(287.58,58.03)
  TOP w0.099: v2(28.12,45.19) 28.12,45.27 28.35,45.49 v1(29.11,45.49) 29.62,45.49 30.34,46.21 30.82,46.21 30.97,46.06 v2(31.33,46.06) 31.52,46.25 31.72,46.25 RT39.1
  IN3 w0.104: v2(288.89,30.62) 287.74,31.77 284.34,31.77 284.12,31.55 280.6,31.55 279.92,30.87 265.37,30.87 256.91,22.41 247.26,22.41 246.64,23.03 238.22,23.03 237.79,22.6 230.7,22.6 228.08,19.98 226.21,19.98 224.93,18.71 220.52,18.71 220.15,19.08 188.48,19.08 184.96,22.6 170.96,22.6 170.73,22.37 160.22,22.37 159.62,22.98 134.39,22.98 132.29,20.87 122.52,20.87 120.57,18.92 119.07,18.92 116.37,21.63 112.49,21.63 111.73,20.87 111.73,20.48 111.21,19.96 111.21,19.87 110.33,19 109.73,19 108.43,20.29 103.77,20.29 103.34,20.73 94.34,20.73 93.02,22.05 89.58,22.05 88.26,20.73 86.31,20.73 85.85,21.18 81.75,21.18 80.07,19.5 78.57,19.5 76.69,17.63 69.12,17.63 67.05,19.69 62.89,19.69 61.16,21.42 60.22,21.42 57.82,23.82 51.38,23.82 50.38,24.83 45.98,24.83 45.39,25.41 37.17,25.41 36.28,26.3 36.28,27.87 32.07,32.08 32.07,34.83 32.58,35.34 32.58,41.26 31.71,42.12 31.71,45.72 31.37,46.06 v2(31.33,46.06)
  IN4 w0.084: v2(288.89,30.62) 289.33,31.07 289.33,40.16 291.07,41.89 291.07,48.1 290.07,49.11 290.07,50.72 287.28,53.51 287.28,54.06 286.21,55.14 286.21,55.91 287.68,57.39 287.68,57.93 v2(287.58,58.03)
  BOTTOM w0.076: UT1.Y6 28.43,45.49 v2(28.12,45.19)
CPU_DP2_N0: length 135.6
  IN4 w0.084: v2(36.57,40.53) 36.59,40.53 36.86,40.26 36.86,40.17 37.04,39.99 38.3,39.99 38.93,40.62 41.51,40.62 41.83,40.94 48.63,40.94 50.5,42.81 54.29,42.81 61.06,49.58 83.78,49.58 102.04,67.84 102.04,76.93 107.85,82.73 123.43,82.73 127.3,78.86 127.3,76.21 128.44,75.07 128.44,70.96 128.74,70.66 129.31,70.66 v2(129.58,70.4)
  BOTTOM w0.102: UC1.A18 130.84,67.09 130.94,67.19 130.94,67.35 130.83,67.46 130.2,67.46 129.88,67.78 129.88,70.09 130,70.21 130,70.39 129.91,70.48 129.9,70.48 129.83,70.55 129.83,70.55 129.82,70.54
  BOTTOM w0.112: v2(129.58,70.4) 129.72,70.54 129.82,70.54 ; CT28.1 32.74,41.65 34.05,41.65 34.1,41.59 35.96,41.59 36.75,40.8 36.75,40.71 v2(36.57,40.53)
CPU_DP2_N0_C: length 3.1
  BOTTOM w0.076: 31.77,41.48 31.73,41.52 31.29,41.52 31.14,41.67 30.66,41.67 30.43,41.44 29.93,41.44 29.77,41.28 29.48,41.28 29.41,41.35 29.41,41.44 29.48,41.51 UT1.AC15
  BOTTOM w0.112: 31.77,41.48 31.86,41.39 CT28.2
CPU_DP2_N1: length 136.3
  IN4 w0.084: v2(127.97,73.07) 127.78,73.26 127.62,73.26 127.43,73.44 127.43,75.18 125.89,76.72 125.89,78.87 124.86,79.89 120.06,79.89 118.65,81.3 107.31,81.3 102.68,76.66 102.68,67.56 83.83,48.71 72.53,48.71 64.84,41.01 50.37,41.01 49.67,40.31 42.1,40.31 41.77,39.99 39.19,39.99 38.56,39.36 36.28,39.36 35.61,40.02 35.61,40.26 v2(35.41,40.46)
  BOTTOM w0.102: 129.82,66.8 129.84,66.78 129.85,66.78 130.1,66.54 133.54,66.54 133.76,66.76 133.76,66.98 133.87,67.09 UC1.E18
  BOTTOM w0.112: v2(127.97,73.07) 128.16,73.25 128.46,73.25 128.94,72.76 128.94,70.13 129.14,69.94 129.14,67.48 129.82,66.8 ; v2(35.41,40.46) 35.54,40.59 35.54,40.76 35.42,40.88 34.79,40.88 34.48,40.57 33.83,40.57 CT30.1
CPU_DP2_N1_C: length 4.4
  BOTTOM w0.076: UT1.AC17 29.46,40.59 29.4,40.54 29.4,40.43 29.47,40.36 29.77,40.36 29.96,40.55 30.49,40.55 30.64,40.41 31.39,40.41 31.61,40.63 31.77,40.63
  BOTTOM w0.112: 31.77,40.63 32.06,40.63 32.15,40.63 32.95,40.63 CT30.2
CPU_DP2_N2: length 137
  IN4 w0.084: v2(34.6,39.51) 34.88,39.79 34.95,39.79 36.01,38.73 41.34,38.73 42.39,37.68 45.99,37.68 46.94,38.63 48.88,38.63 50.52,40.27 64.99,40.27 72.8,48.07 84.09,48.07 103.31,67.29 103.31,76.4 107.58,80.67 118.3,80.67 119.71,79.26 124.6,79.26 125.26,78.6 125.26,76.46 126.8,74.91 126.8,73.17 127.3,72.67 127.3,72.33 127.49,72.14 127.6,72.14 v2(127.84,71.9)
  BOTTOM w0.102: 129.82,65.8 129.99,65.63 131.92,65.63 131.93,65.62 132.82,65.62 133.04,65.84 133.04,66.01 UC1.D19
  BOTTOM w0.112: 129.82,65.8 129.79,65.83 129.78,65.83 128.43,67.18 128.43,69.64 128.23,69.84 128.23,71.94 128.12,72.05 127.99,72.05 v2(127.84,71.9) ; CT32.1 32.65,39.65 33.29,39.65 33.38,39.74 34.36,39.74 v2(34.6,39.51)
CPU_DP2_N2_C: length 3.1
  BOTTOM w0.076: 31.77,39.52 31.67,39.63 31.32,39.63 31.17,39.78 30.78,39.78 30.63,39.63 29.96,39.63 29.77,39.45 29.48,39.45 29.41,39.51 29.41,39.61 29.48,39.67 UT1.AC19
  BOTTOM w0.112: CT32.2 31.77,39.52
CPU_DP2_N3: length 136.2
  IN4 w0.084: v2(34.57,38.34) 34.67,38.44 35.33,38.44 35.68,38.09 41.08,38.09 42.13,37.04 46.25,37.04 47.21,38 50.19,38 51.83,39.63 65.25,39.63 73.06,47.44 84.35,47.44 103.94,67.03 103.94,76.14 107.84,80.04 118.03,80.04 121.66,76.41 124.41,76.41 126.17,74.65 126.17,72.91 126.67,72.41 126.67,71.9 127.44,71.13 127.44,70.68 v2(127.23,70.47)
  BOTTOM w0.102: 129.82,64.68 131.32,64.68 131.33,64.67 131.86,64.67 131.9,64.71 133.54,64.71 133.76,64.93 133.76,65.13 133.89,65.26 UC1.E20
  BOTTOM w0.112: CT34.1 32.55,38.28 33.25,38.28 33.35,38.38 34.53,38.38 v2(34.57,38.34) ; 129.82,64.68 129.81,64.68 127.28,67.2 127.28,70.42 v2(127.23,70.47)

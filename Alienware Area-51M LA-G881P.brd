# Allegro board Alienware Area-51M LA-G881P.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
CVILU_CH31052VA00-NH_5P
  round 1.6 hole 1.194: 1(0,0) 2(2.54,0) 3(5.08,0) 4(7.62,0) 5(10.16,0)
CVILU_CH51102M100-0P_10P-T
  oval 0.762x2.388 smd: 1(0,0) 2(0,3.9) 3(1.27,0) 4(1.27,3.9) 5(2.54,0) 6(2.54,3.9) 7(3.81,0) 8(3.81,3.9) 9(5.08,0) 10(5.08,3.9)
CVILU_CI1110M2VR0-NH_10P
  oval 0.61x1.549 smd: 1(0,0) 2(-1,0) 3(-2,0) 4(-3,0) 5(-4,0) 6(-5,0) 7(-6,0) 8(-7,0) 9(-8,0) 10(-9,0)
  rect 1.194x1.803 smd: 11(1.3,-2.525) 12(-10.3,-2.525)
CYNTE_PCMB042T-1R0MS_2P
  rect 1.499x2.489 smd: 1(0,0) 2(3.7,0)
CYNTE_PCMB063T-1R0MS_2P
  rect 2.362x3.505 smd: 1(0,0) 2(6.05,0)
D_SOD323-2
  rect 0.787x0.889 smd: 1(0,0) 2(2.14,0)
DMN65D8LDW-7_SOT363-6
  oval 0.432x0.61 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0.65,1.9) 6(0,1.9)
DMN66D0LDW-7_SOT363-6
  oval 0.432x0.61 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0.65,1.9) 6(0,1.9)
DS80PCI402SQNOPB_WQFN54_10X5P5
  oval 0.254x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0) 28(8.5,5.6) 29(8,5.6) 30(7.5,5.6) 31(7,5.6) 32(6.5,5.6) 33(6,5.6) 34(5.5,5.6) 35(5,5.6) 36(4.5,5.6) 37(4,5.6) 38(3.5,5.6) 39(3,5.6) 40(2.5,5.6) 41(2,5.6) 42(1.5,5.6) 43(1,5.6) 44(0.5,5.6) 45(0,5.6)
  oval 0.889x0.254 smd: 19(9.3,0.8) 20(9.3,1.3) 21(9.3,1.8) 22(9.3,2.3) 23(9.3,2.8) 24(9.3,3.3) 25(9.3,3.8) 26(9.3,4.3) 27(9.3,4.8) 46(-0.8,4.8) 47(-0.8,4.3) 48(-0.8,3.8) 49(-0.8,3.3) 50(-0.8,2.8) 51(-0.8,2.3) 52(-0.8,1.8) 53(-0.8,1.3) 54(-0.8,0.8)
  rect 7.493x3.505 smd: 55(4.25,2.8)
EMB04N03H_EDFN5X6-8-5
  oval 0.61x1.27 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0)
  custom 1.105x1.105 smd: 5(1.905,3.715)
EMIST_SQ-42G-2_1P
  rect 6.198x2.997 smd: 1(0,0)
EN25F80-75HCP_SO8
  oval 0.635x1.676 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,7.25) 6(2.54,7.25) 7(1.27,7.25) 8(0,7.25)
F75305M_MSOP10
  oval 0.254x1.626 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2,4.3) 7(1.5,4.3) 8(1,4.3) 9(0.5,4.3) 10(0,4.3)
  rect 1.6x1.727 smd: 11(1,2.15)
F75397M_MSOP8
  oval 0.381x1.626 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(1.95,4.3) 6(1.3,4.3) 7(0.65,4.3) 8(0,4.3)
FDV301N_NL_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
FIDUCIAL_C40M80
  round 1.016 smd: 1(0,0)
G517AH1TP1U_TSOT23-6
  oval 0.508x1.194 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,3) 5(0.95,3) 6(0,3)
H_3P0-G
  round 3.505 hole 2.997: 1(0,0)
H_3P0N
  round 2.997 hole 2.997 unplated: (0,0)
H_3P2
  round 3.708 hole 3.2: 1(0,0)
H_3P3
  round 3.81 hole 3.302: 1(0,0)
H_3P8
  round 4.318 hole 3.81: 1(0,0)
H_3P8-G
  round 4.318 hole 3.81: 1(0,0)
H_4P0X3P0N
  oval 3.988x2.997 hole 3.988x2.997 unplated: (0,0)
INTEL_CMC_PRIMARY_36P-T
  round 0.889 hole 0.889 unplated: (-0.876,-0.658) (0.774,-6.054)
  round 0.368 smd: 1(0,0) 2(0.477,-0.275) 3(0.885,0.093) 4(1.268,-0.302) 5(1.763,-0.062) 6(2.021,-0.547) 7(2.563,-0.452) 8(2.677,-0.99) 9(3.224,-1.048) 10(3.186,-1.596) 11(3.696,-1.803) 12(3.509,-2.32) 13(3.942,-2.659) 14(3.619,-3.104) 15(3.942,-3.549) 16(3.509,-3.888) 17(3.696,-4.405) 18(3.186,-4.611) 19(3.224,-5.16) 20(2.677,-5.218) 21(2.563,-5.756) 22(2.021,-5.661) 23(-0.491,-5.652) 24(-1.034,-5.743) 25(-1.145,-5.205) 26(-1.691,-5.143) 27(-1.649,-4.595) 28(-2.157,-4.385) 29(-1.966,-3.869) 30(-2.397,-3.527) 31(-2.071,-3.084) 32(-2.391,-2.637) 33(-1.955,-2.301) 34(-2.139,-1.782) 35(-1.631,-1.578)
  round 4.597 hole 2.286: 36(0.774,-3.104)
ISL6617CRZ-T_DFN10_3X3
  custom 0.104x0.104 smd: 1(0,0) 5(0,-2) 6(2.85,-2) 10(2.85,0)
  oval 0.533x0.229 smd: 2(-0.1,-0.5) 3(-0.1,-1) 4(-0.1,-1.5) 7(2.95,-1.5) 8(2.95,-1) 9(2.95,-0.5)
  rect 1.6x2.007 smd: 11(1.425,-1)
ISL95338HRTZ-T_TQFN32_4X4
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 17(4.1,-2.8) 18(4.1,-2.4) 19(4.1,-2) 20(4.1,-1.6) 21(4.1,-1.2) 22(4.1,-0.8) 23(4.1,-0.4) 24(4.1,0)
  oval 0.203x0.889 smd: 9(0.65,-3.45) 10(1.05,-3.45) 11(1.45,-3.45) 12(1.85,-3.45) 13(2.25,-3.45) 14(2.65,-3.45) 15(3.05,-3.45) 16(3.45,-3.45) 25(3.45,0.65) 26(3.05,0.65) 27(2.65,0.65) 28(2.25,0.65) 29(1.85,0.65) 30(1.45,0.65) 31(1.05,0.65) 32(0.65,0.65)
  rect 2.642x2.642 smd: 33(2.05,-1.4)
ISL95520HRZ-T_QFN32_4X4
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 17(4.1,-2.8) 18(4.1,-2.4) 19(4.1,-2) 20(4.1,-1.6) 21(4.1,-1.2) 22(4.1,-0.8) 23(4.1,-0.4) 24(4.1,0)
  oval 0.203x0.889 smd: 9(0.65,-3.45) 10(1.05,-3.45) 11(1.45,-3.45) 12(1.85,-3.45) 13(2.25,-3.45) 14(2.65,-3.45) 15(3.05,-3.45) 16(3.45,-3.45) 25(3.45,0.65) 26(3.05,0.65) 27(2.65,0.65) 28(2.25,0.65) 29(1.85,0.65) 30(1.45,0.65) 31(1.05,0.65) 32(0.65,0.65)
  rect 2.642x2.642 smd: 33(2.05,-1.4)
ISL95829CHRTZ-T_TQFN48_6X6
  oval 0.94x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 9(0,-3.2) 10(0,-3.6) 11(0,-4) 12(0,-4.4) 25(6.05,-4.4) 26(6.05,-4) 27(6.05,-3.6) 28(6.05,-3.2) 29(6.05,-2.8) 30(6.05,-2.4) 31(6.05,-2) 32(6.05,-1.6) 33(6.05,-1.2) 34(6.05,-0.8) 35(6.05,-0.4) 36(6.05,0)
  oval 0.203x0.94 smd: 13(0.825,-5.225) 14(1.225,-5.225) 15(1.625,-5.225) 16(2.025,-5.225) 17(2.425,-5.225) 18(2.825,-5.225) 19(3.225,-5.225) 20(3.625,-5.225) 21(4.025,-5.225) 22(4.425,-5.225) 23(4.825,-5.225) 24(5.225,-5.225) 37(5.225,0.825) 38(4.825,0.825) 39(4.425,0.825) 40(4.025,0.825) 41(3.625,0.825) 42(3.225,0.825) 43(2.825,0.825) 44(2.425,0.825) 45(2.025,0.825) 46(1.625,0.825) 47(1.225,0.825) 48(0.825,0.825)
  rect 4.394x4.394 smd: 49(3.025,-2.2)
ISL95870BHRZ-T_QFN20_3X4
  oval 0.254x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 11(2.5,3.1) 12(2,3.1) 13(1.5,3.1) 14(1,3.1) 15(0.5,3.1) 16(0,3.1)
  oval 0.889x0.254 smd: 7(3.3,0.8) 8(3.3,1.3) 9(3.3,1.8) 10(3.3,2.3) 17(-0.8,2.3) 18(-0.8,1.8) 19(-0.8,1.3) 20(-0.8,0.8)
  rect 2.642x1.651 smd: 21(1.25,1.55)
JAE_DX07S024JJ5R1200_24P
  round 0.66 hole 0.66 unplated: (-0.975,-2.7)
  oval 0.838x0.66 hole 0.838x0.66 unplated: (6.225,-2.635)
  oval 1.295x2.489 hole 0.711x1.905: 1(-1.695,-5.75) 3(6.945,-5.75)
  oval 1.194x2.108 hole 0.61x1.702: 2(-1.695,-0.7) 4(6.945,-0.7)
  oval 1.651x1.092 hole 1.245x0.711: 5(-1.37,-1.2) 6(6.62,-1.2)
  oval 0.279x0.889 smd: A1(0,0) A2(0.5,0) A3(1,0) A4(1.5,0) A5(2,0) A6(2.5,0) A7(3,0) A8(3.5,0) A9(4,0) A10(4.5,0) A11(5,0) A12(5.5,0)
  oval 0.279x0.787 smd: B1(5.25,-1.6) B2(4.75,-1.6) B3(4.25,-1.6) B4(3.75,-1.6) B5(3.25,-1.6) B6(2.75,-1.6) B7(2.25,-1.6) B8(1.75,-1.6) B9(1.25,-1.6) B10(0.75,-1.6) B11(0.25,-1.6) B12(-0.25,-1.6)
JUMP_43X39
  custom 0.191x0.191 smd: 1(0,0) 2(0.914,0)
JUMP_43X79
  custom 0.188x0.188 smd: 1(0,0) 2(1.1,0)
JUMP_43X118
  custom 0.187x0.187 smd: 1(0,0) 2(1.1,0)
JUMP_43X118-NPM
  custom 0.187x0.187 smd: 1(0,0) 2(1.1,0)
KB9542Q-B_LQFP128_14X14
  oval 1.803x0.254 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 9(0,-3.2) 10(0,-3.6) 11(0,-4) 12(0,-4.4) 13(0,-4.8) 14(0,-5.2) 15(0,-5.6) 16(0,-6) 17(0,-6.4) 18(0,-6.8) 19(0,-7.2) 20(0,-7.6) 21(0,-8) 22(0,-8.4) 23(0,-8.8) 24(0,-9.2) 25(0,-9.6) 26(0,-10) 27(0,-10.4) 28(0,-10.8) 29(0,-11.2) 30(0,-11.6) 31(0,-12) 32(0,-12.4) 65(15.654,-12.4) 66(15.654,-12) 67(15.654,-11.6) 68(15.654,-11.2) 69(15.654,-10.8) 70(15.654,-10.4) 71(15.654,-10) 72(15.654,-9.6) 73(15.654,-9.2) 74(15.654,-8.8) 75(15.654,-8.4) 76(15.654,-8) 77(15.654,-7.6) 78(15.654,-7.2) 79(15.654,-6.8) 80(15.654,-6.4) 81(15.654,-6) 82(15.654,-5.6) 83(15.654,-5.2) 84(15.654,-4.8) 85(15.654,-4.4) 86(15.654,-4) 87(15.654,-3.6) 88(15.654,-3.2) 89(15.654,-2.8) 90(15.654,-2.4) 91(15.654,-2) 92(15.654,-1.6) 93(15.654,-1.2) 94(15.654,-0.8) 95(15.654,-0.4) 96(15.654,0)
  oval 0.254x1.803 smd: 33(1.627,-14.027) 34(2.027,-14.027) 35(2.427,-14.027) 36(2.827,-14.027) 37(3.227,-14.027) 38(3.627,-14.027) 39(4.027,-14.027) 40(4.427,-14.027) 41(4.827,-14.027) 42(5.227,-14.027) 43(5.627,-14.027) 44(6.027,-14.027) 45(6.427,-14.027) 46(6.827,-14.027) 47(7.227,-14.027) 48(7.627,-14.027) 49(8.027,-14.027) 50(8.427,-14.027) 51(8.827,-14.027) 52(9.227,-14.027) 53(9.627,-14.027) 54(10.027,-14.027) 55(10.427,-14.027) 56(10.827,-14.027) 57(11.227,-14.027) 58(11.627,-14.027) 59(12.027,-14.027) 60(12.427,-14.027) 61(12.827,-14.027) 62(13.227,-14.027) 63(13.627,-14.027) 64(14.027,-14.027) 97(14.027,1.627) 98(13.627,1.627) 99(13.227,1.627) 100(12.827,1.627) 101(12.427,1.627) 102(12.027,1.627) 103(11.627,1.627) 104(11.227,1.627) 105(10.827,1.627) 106(10.427,1.627) 107(10.027,1.627) 108(9.627,1.627) 109(9.227,1.627) 110(8.827,1.627) 111(8.427,1.627) 112(8.027,1.627) 113(7.627,1.627) 114(7.227,1.627) 115(6.827,1.627) 116(6.427,1.627) 117(6.027,1.627) 118(5.627,1.627) 119(5.227,1.627) 120(4.827,1.627) 121(4.427,1.627) 122(4.027,1.627) 123(3.627,1.627) 124(3.227,1.627) 125(2.827,1.627) 126(2.427,1.627) 127(2.027,1.627) 128(1.627,1.627)
KC3810NF-A0_QFN24_4X4
  oval 0.889x0.254 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 5(0,-2) 6(0,-2.5) 13(4.1,-2.5) 14(4.1,-2) 15(4.1,-1.5) 16(4.1,-1) 17(4.1,-0.5) 18(4.1,0)
  oval 0.254x0.889 smd: 7(0.8,-3.3) 8(1.3,-3.3) 9(1.8,-3.3) 10(2.3,-3.3) 11(2.8,-3.3) 12(3.3,-3.3) 19(3.3,0.8) 20(2.8,0.8) 21(2.3,0.8) 22(1.8,0.8) 23(1.3,0.8) 24(0.8,0.8)
  rect 2.438x2.438 smd: 25(2.05,-1.25)
KC_FBMA-L11-160808-800LMT_2P
  rect 0.889x1.092 smd: 1(0,0) 2(1.5,0)
KC_FBMA-L11-453215800LMA90T_2P
  rect 1.803x3.404 smd: 1(0,0) 2(3.8,0)
L2N7002DW1T1G_SC88-6
  oval 0.406x0.508 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0.65,1.9) 6(0,1.9)
L2N7002WT1G_SC-70-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
L_7X7X3_M_2P
  rect 2.362x3.505 smd: 1(0,0) 2(6.05,0)
L_7X7X4_M
  custom 0.591x0.591 smd: 1(0,0) 4(6.05,0)
  rect 0.762x0.508 smd: 2(0.8,0) 3(5.25,0)
L_10X10X4_M_2P
  rect 3.81x3.988 smd: 1(0,0) 2(9.2,0)
LIS2DH12TR_LGA12_2X2
  oval 0.406x0.305 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 7(1.525,-1.5) 8(1.525,-1) 9(1.525,-0.5) 10(1.525,0)
  oval 0.254x0.406 smd: 5(0.513,-1.513) 6(1.012,-1.513) 11(1.012,0.012) 12(0.513,0.012)
LMUN5113T1G_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(0.65,1.9) 3(-0.65,1.9)
LNG3DMTR_LGA16_3X3
  oval 0.305x0.864 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 9(2,2.96) 10(1.5,2.96) 11(1,2.96) 12(0.5,2.96) 13(0,2.96)
  oval 0.864x0.305 smd: 6(2.48,0.98) 7(2.48,1.48) 8(2.48,1.98) 14(-0.48,1.98) 15(-0.48,1.48) 16(-0.48,0.98)
LOTES_ADDR0069-P009A_260P-T
  round 1.6 hole 1.6 unplated: (-1.025,4.1)
  round 1.092 hole 1.092 unplated: (67.775,4.1)
  oval 0.305x1.753 smd: 1(0,0) 2(0.25,8.2) 3(0.5,0) 4(0.75,8.2) 5(1,0) 6(1.25,8.2) 7(1.5,0) 8(1.75,8.2) 9(2,0) 10(2.25,8.2) 11(2.5,0) 12(2.75,8.2) 13(3,0) 14(3.25,8.2) 15(3.5,0) 16(3.75,8.2) 17(4,0) 18(4.25,8.2) 19(4.5,0) 20(4.75,8.2) 21(5,0) 22(5.25,8.2) 23(5.5,0) 24(5.75,8.2) 25(6,0) 26(6.25,8.2) 27(6.5,0) 28(6.75,8.2) 29(7,0) 30(7.25,8.2) 31(7.5,0) 32(7.75,8.2) 33(8,0) 34(8.25,8.2) 35(8.5,0) 36(8.75,8.2) 37(9,0) 38(9.25,8.2) 39(9.5,0) 40(9.75,8.2) 41(10,0) 42(10.25,8.2) 43(10.5,0) 44(10.75,8.2) 45(11,0) 46(11.25,8.2) 47(11.5,0) 48(11.75,8.2) 49(12,0) 50(12.25,8.2) 51(12.5,0) 52(12.75,8.2) 53(13,0) 54(13.25,8.2) 55(13.5,0) 56(13.75,8.2) 57(14,0) 58(14.25,8.2) 59(14.5,0) 60(14.75,8.2) 61(15,0) 62(15.25,8.2) 63(15.5,0) 64(15.75,8.2) 65(16,0) 66(16.25,8.2) 67(16.5,0) 68(16.75,8.2) 69(17,0) 70(17.25,8.2) 71(17.5,0) 72(17.75,8.2) 73(18,0) 74(18.25,8.2) 75(18.5,0) 76(18.75,8.2) 77(19,0) 78(19.25,8.2) 79(19.5,0) 80(19.75,8.2) 81(20,0) 82(20.25,8.2) 83(20.5,0) 84(20.75,8.2) 85(21,0) 86(21.25,8.2) 87(21.5,0) 88(21.75,8.2) 89(22,0) 90(22.25,8.2) 91(22.5,0) 92(22.75,8.2) 93(23,0) 94(23.25,8.2) 95(23.5,0) 96(23.75,8.2) 97(24,0) 98(24.25,8.2) 99(24.5,0) 100(24.75,8.2) 101(25,0) 102(25.25,8.2) 103(25.5,0) 104(25.75,8.2) 105(26,0) 106(26.25,8.2) 107(26.5,0) 108(26.75,8.2) 109(27,0) 110(27.25,8.2) 111(27.5,0) 112(27.75,8.2) 113(28,0) 114(28.25,8.2) 115(28.5,0) 116(28.75,8.2) 117(29,0) 118(29.25,8.2) 119(29.5,0) 120(29.75,8.2) 121(30,0) 122(30.25,8.2) 123(30.5,0) 124(30.75,8.2) 125(31,0) 126(31.25,8.2) 127(31.5,0) 128(31.75,8.2) 129(32,0) 130(32.25,8.2) 131(32.5,0) 132(32.75,8.2) 133(33,0) 134(33.25,8.2) 135(33.5,0) 136(33.75,8.2) 137(34,0) 138(34.25,8.2) 139(34.5,0) 140(34.75,8.2) 141(35,0) 142(35.25,8.2) 143(35.5,0) 144(35.75,8.2) 145(38,0) 146(38.25,8.2) 147(38.5,0) 148(38.75,8.2) 149(39,0) 150(39.25,8.2) 151(39.5,0) 152(39.75,8.2) 153(40,0) 154(40.25,8.2) 155(40.5,0) 156(40.75,8.2) 157(41,0) 158(41.25,8.2) 159(41.5,0) 160(41.75,8.2) 161(42,0) 162(42.25,8.2) 163(42.5,0) 164(42.75,8.2) 165(43,0) 166(43.25,8.2) 167(43.5,0) 168(43.75,8.2) 169(44,0) 170(44.25,8.2) 171(44.5,0) 172(44.75,8.2) 173(45,0) 174(45.25,8.2) 175(45.5,0) 176(45.75,8.2) 177(46,0) 178(46.25,8.2) 179(46.5,0) 180(46.75,8.2) 181(47,0) 182(47.25,8.2) 183(47.5,0) 184(47.75,8.2) 185(48,0) 186(48.25,8.2) 187(48.5,0) 188(48.75,8.2) 189(49,0) 190(49.25,8.2) 191(49.5,0) 192(49.75,8.2) 193(50,0) 194(50.25,8.2) 195(50.5,0) 196(50.75,8.2) 197(51,0) 198(51.25,8.2) 199(51.5,0) 200(51.75,8.2) 201(52,0) 202(52.25,8.2) 203(52.5,0) 204(52.75,8.2) 205(53,0) 206(53.25,8.2) 207(53.5,0) 208(53.75,8.2) 209(54,0) 210(54.25,8.2) 211(54.5,0) 212(54.75,8.2) 213(55,0) 214(55.25,8.2) 215(55.5,0) 216(55.75,8.2) 217(56,0) 218(56.25,8.2) 219(56.5,0) 220(56.75,8.2) 221(57,0) 222(57.25,8.2) 223(57.5,0) 224(57.75,8.2) 225(58,0) 226(58.25,8.2) 227(58.5,0) 228(58.75,8.2) 229(59,0) 230(59.25,8.2) 231(59.5,0) 232(59.75,8.2) 233(60,0) 234(60.25,8.2) 235(60.5,0) 236(60.75,8.2) 237(61,0) 238(61.25,8.2) 239(61.5,0) 240(61.75,8.2) 241(62,0) 242(62.25,8.2) 243(62.5,0) 244(62.75,8.2) 245(63,0) 246(63.25,8.2) 247(63.5,0) 248(63.75,8.2) 249(64,0) 250(64.25,8.2) 251(64.5,0) 252(64.75,8.2) 253(65,0) 254(65.25,8.2) 255(65.5,0) 256(65.75,8.2) 257(66,0) 258(66.25,8.2) 259(66.5,0) 260(66.75,8.2)
  rect 2.007x3.505 smd: 261(-4.375,16.1) 262(71.125,12.1)
LOTES_ADDR0070-P025A_260P
  round 1.092 hole 1.092 unplated: (-67.775,-4.1)
  round 1.6 hole 1.6 unplated: (1.025,-4.1)
  oval 0.305x1.753 smd: 1(0,0) 2(-0.25,-8.2) 3(-0.5,0) 4(-0.75,-8.2) 5(-1,0) 6(-1.25,-8.2) 7(-1.5,0) 8(-1.75,-8.2) 9(-2,0) 10(-2.25,-8.2) 11(-2.5,0) 12(-2.75,-8.2) 13(-3,0) 14(-3.25,-8.2) 15(-3.5,0) 16(-3.75,-8.2) 17(-4,0) 18(-4.25,-8.2) 19(-4.5,0) 20(-4.75,-8.2) 21(-5,0) 22(-5.25,-8.2) 23(-5.5,0) 24(-5.75,-8.2) 25(-6,0) 26(-6.25,-8.2) 27(-6.5,0) 28(-6.75,-8.2) 29(-7,0) 30(-7.25,-8.2) 31(-7.5,0) 32(-7.75,-8.2) 33(-8,0) 34(-8.25,-8.2) 35(-8.5,0) 36(-8.75,-8.2) 37(-9,0) 38(-9.25,-8.2) 39(-9.5,0) 40(-9.75,-8.2) 41(-10,0) 42(-10.25,-8.2) 43(-10.5,0) 44(-10.75,-8.2) 45(-11,0) 46(-11.25,-8.2) 47(-11.5,0) 48(-11.75,-8.2) 49(-12,0) 50(-12.25,-8.2) 51(-12.5,0) 52(-12.75,-8.2) 53(-13,0) 54(-13.25,-8.2) 55(-13.5,0) 56(-13.75,-8.2) 57(-14,0) 58(-14.25,-8.2) 59(-14.5,0) 60(-14.75,-8.2) 61(-15,0) 62(-15.25,-8.2) 63(-15.5,0) 64(-15.75,-8.2) 65(-16,0) 66(-16.25,-8.2) 67(-16.5,0) 68(-16.75,-8.2) 69(-17,0) 70(-17.25,-8.2) 71(-17.5,0) 72(-17.75,-8.2) 73(-18,0) 74(-18.25,-8.2) 75(-18.5,0) 76(-18.75,-8.2) 77(-19,0) 78(-19.25,-8.2) 79(-19.5,0) 80(-19.75,-8.2) 81(-20,0) 82(-20.25,-8.2) 83(-20.5,0) 84(-20.75,-8.2) 85(-21,0) 86(-21.25,-8.2) 87(-21.5,0) 88(-21.75,-8.2) 89(-22,0) 90(-22.25,-8.2) 91(-22.5,0) 92(-22.75,-8.2) 93(-23,0) 94(-23.25,-8.2) 95(-23.5,0) 96(-23.75,-8.2) 97(-24,0) 98(-24.25,-8.2) 99(-24.5,0) 100(-24.75,-8.2) 101(-25,0) 102(-25.25,-8.2) 103(-25.5,0) 104(-25.75,-8.2) 105(-26,0) 106(-26.25,-8.2) 107(-26.5,0) 108(-26.75,-8.2) 109(-27,0) 110(-27.25,-8.2) 111(-27.5,0) 112(-27.75,-8.2) 113(-28,0) 114(-28.25,-8.2) 115(-28.5,0) 116(-28.75,-8.2) 117(-29,0) 118(-29.25,-8.2) 119(-29.5,0) 120(-29.75,-8.2) 121(-30,0) 122(-30.25,-8.2) 123(-30.5,0) 124(-30.75,-8.2) 125(-31,0) 126(-31.25,-8.2) 127(-31.5,0) 128(-31.75,-8.2) 129(-32,0) 130(-32.25,-8.2) 131(-32.5,0) 132(-32.75,-8.2) 133(-33,0) 134(-33.25,-8.2) 135(-33.5,0) 136(-33.75,-8.2) 137(-34,0) 138(-34.25,-8.2) 139(-34.5,0) 140(-34.75,-8.2) 141(-35,0) 142(-35.25,-8.2) 143(-35.5,0) 144(-35.75,-8.2) 145(-38,0) 146(-38.25,-8.2) 147(-38.5,0) 148(-38.75,-8.2) 149(-39,0) 150(-39.25,-8.2) 151(-39.5,0) 152(-39.75,-8.2) 153(-40,0) 154(-40.25,-8.2) 155(-40.5,0) 156(-40.75,-8.2) 157(-41,0) 158(-41.25,-8.2) 159(-41.5,0) 160(-41.75,-8.2) 161(-42,0) 162(-42.25,-8.2) 163(-42.5,0) 164(-42.75,-8.2) 165(-43,0) 166(-43.25,-8.2) 167(-43.5,0) 168(-43.75,-8.2) 169(-44,0) 170(-44.25,-8.2) 171(-44.5,0) 172(-44.75,-8.2) 173(-45,0) 174(-45.25,-8.2) 175(-45.5,0) 176(-45.75,-8.2) 177(-46,0) 178(-46.25,-8.2) 179(-46.5,0) 180(-46.75,-8.2) 181(-47,0) 182(-47.25,-8.2) 183(-47.5,0) 184(-47.75,-8.2) 185(-48,0) 186(-48.25,-8.2) 187(-48.5,0) 188(-48.75,-8.2) 189(-49,0) 190(-49.25,-8.2) 191(-49.5,0) 192(-49.75,-8.2) 193(-50,0) 194(-50.25,-8.2) 195(-50.5,0) 196(-50.75,-8.2) 197(-51,0) 198(-51.25,-8.2) 199(-51.5,0) 200(-51.75,-8.2) 201(-52,0) 202(-52.25,-8.2) 203(-52.5,0) 204(-52.75,-8.2) 205(-53,0) 206(-53.25,-8.2) 207(-53.5,0) 208(-53.75,-8.2) 209(-54,0) 210(-54.25,-8.2) 211(-54.5,0) 212(-54.75,-8.2) 213(-55,0) 214(-55.25,-8.2) 215(-55.5,0) 216(-55.75,-8.2) 217(-56,0) 218(-56.25,-8.2) 219(-56.5,0) 220(-56.75,-8.2) 221(-57,0) 222(-57.25,-8.2) 223(-57.5,0) 224(-57.75,-8.2) 225(-58,0) 226(-58.25,-8.2) 227(-58.5,0) 228(-58.75,-8.2) 229(-59,0) 230(-59.25,-8.2) 231(-59.5,0) 232(-59.75,-8.2) 233(-60,0) 234(-60.25,-8.2) 235(-60.5,0) 236(-60.75,-8.2) 237(-61,0) 238(-61.25,-8.2) 239(-61.5,0) 240(-61.75,-8.2) 241(-62,0) 242(-62.25,-8.2) 243(-62.5,0) 244(-62.75,-8.2) 245(-63,0) 246(-63.25,-8.2) 247(-63.5,0) 248(-63.75,-8.2) 249(-64,0) 250(-64.25,-8.2) 251(-64.5,0) 252(-64.75,-8.2) 253(-65,0) 254(-65.25,-8.2) 255(-65.5,0) 256(-65.75,-8.2) 257(-66,0) 258(-66.25,-8.2) 259(-66.5,0) 260(-66.75,-8.2)
  rect 2.007x3.505 smd: 261(-71.125,7.9) 262(4.375,3.9)
LOTES_ADDR0205-P001A02_260P
  round 1.6 hole 1.6 unplated: (-1.025,4.1)
  round 1.092 hole 1.092 unplated: (67.775,4.1)
  oval 0.305x1.753 smd: 1(0,0) 2(0.25,8.2) 3(0.5,0) 4(0.75,8.2) 5(1,0) 6(1.25,8.2) 7(1.5,0) 8(1.75,8.2) 9(2,0) 10(2.25,8.2) 11(2.5,0) 12(2.75,8.2) 13(3,0) 14(3.25,8.2) 15(3.5,0) 16(3.75,8.2) 17(4,0) 18(4.25,8.2) 19(4.5,0) 20(4.75,8.2) 21(5,0) 22(5.25,8.2) 23(5.5,0) 24(5.75,8.2) 25(6,0) 26(6.25,8.2) 27(6.5,0) 28(6.75,8.2) 29(7,0) 30(7.25,8.2) 31(7.5,0) 32(7.75,8.2) 33(8,0) 34(8.25,8.2) 35(8.5,0) 36(8.75,8.2) 37(9,0) 38(9.25,8.2) 39(9.5,0) 40(9.75,8.2) 41(10,0) 42(10.25,8.2) 43(10.5,0) 44(10.75,8.2) 45(11,0) 46(11.25,8.2) 47(11.5,0) 48(11.75,8.2) 49(12,0) 50(12.25,8.2) 51(12.5,0) 52(12.75,8.2) 53(13,0) 54(13.25,8.2) 55(13.5,0) 56(13.75,8.2) 57(14,0) 58(14.25,8.2) 59(14.5,0) 60(14.75,8.2) 61(15,0) 62(15.25,8.2) 63(15.5,0) 64(15.75,8.2) 65(16,0) 66(16.25,8.2) 67(16.5,0) 68(16.75,8.2) 69(17,0) 70(17.25,8.2) 71(17.5,0) 72(17.75,8.2) 73(18,0) 74(18.25,8.2) 75(18.5,0) 76(18.75,8.2) 77(19,0) 78(19.25,8.2) 79(19.5,0) 80(19.75,8.2) 81(20,0) 82(20.25,8.2) 83(20.5,0) 84(20.75,8.2) 85(21,0) 86(21.25,8.2) 87(21.5,0) 88(21.75,8.2) 89(22,0) 90(22.25,8.2) 91(22.5,0) 92(22.75,8.2) 93(23,0) 94(23.25,8.2) 95(23.5,0) 96(23.75,8.2) 97(24,0) 98(24.25,8.2) 99(24.5,0) 100(24.75,8.2) 101(25,0) 102(25.25,8.2) 103(25.5,0) 104(25.75,8.2) 105(26,0) 106(26.25,8.2) 107(26.5,0) 108(26.75,8.2) 109(27,0) 110(27.25,8.2) 111(27.5,0) 112(27.75,8.2) 113(28,0) 114(28.25,8.2) 115(28.5,0) 116(28.75,8.2) 117(29,0) 118(29.25,8.2) 119(29.5,0) 120(29.75,8.2) 121(30,0) 122(30.25,8.2) 123(30.5,0) 124(30.75,8.2) 125(31,0) 126(31.25,8.2) 127(31.5,0) 128(31.75,8.2) 129(32,0) 130(32.25,8.2) 131(32.5,0) 132(32.75,8.2) 133(33,0) 134(33.25,8.2) 135(33.5,0) 136(33.75,8.2) 137(34,0) 138(34.25,8.2) 139(34.5,0) 140(34.75,8.2) 141(35,0) 142(35.25,8.2) 143(35.5,0) 144(35.75,8.2) 145(38,0) 146(38.25,8.2) 147(38.5,0) 148(38.75,8.2) 149(39,0) 150(39.25,8.2) 151(39.5,0) 152(39.75,8.2) 153(40,0) 154(40.25,8.2) 155(40.5,0) 156(40.75,8.2) 157(41,0) 158(41.25,8.2) 159(41.5,0) 160(41.75,8.2) 161(42,0) 162(42.25,8.2) 163(42.5,0) 164(42.75,8.2) 165(43,0) 166(43.25,8.2) 167(43.5,0) 168(43.75,8.2) 169(44,0) 170(44.25,8.2) 171(44.5,0) 172(44.75,8.2) 173(45,0) 174(45.25,8.2) 175(45.5,0) 176(45.75,8.2) 177(46,0) 178(46.25,8.2) 179(46.5,0) 180(46.75,8.2) 181(47,0) 182(47.25,8.2) 183(47.5,0) 184(47.75,8.2) 185(48,0) 186(48.25,8.2) 187(48.5,0) 188(48.75,8.2) 189(49,0) 190(49.25,8.2) 191(49.5,0) 192(49.75,8.2) 193(50,0) 194(50.25,8.2) 195(50.5,0) 196(50.75,8.2) 197(51,0) 198(51.25,8.2) 199(51.5,0) 200(51.75,8.2) 201(52,0) 202(52.25,8.2) 203(52.5,0) 204(52.75,8.2) 205(53,0) 206(53.25,8.2) 207(53.5,0) 208(53.75,8.2) 209(54,0) 210(54.25,8.2) 211(54.5,0) 212(54.75,8.2) 213(55,0) 214(55.25,8.2) 215(55.5,0) 216(55.75,8.2) 217(56,0) 218(56.25,8.2) 219(56.5,0) 220(56.75,8.2) 221(57,0) 222(57.25,8.2) 223(57.5,0) 224(57.75,8.2) 225(58,0) 226(58.25,8.2) 227(58.5,0) 228(58.75,8.2) 229(59,0) 230(59.25,8.2) 231(59.5,0) 232(59.75,8.2) 233(60,0) 234(60.25,8.2) 235(60.5,0) 236(60.75,8.2) 237(61,0) 238(61.25,8.2) 239(61.5,0) 240(61.75,8.2) 241(62,0) 242(62.25,8.2) 243(62.5,0) 244(62.75,8.2) 245(63,0) 246(63.25,8.2) 247(63.5,0) 248(63.75,8.2) 249(64,0) 250(64.25,8.2) 251(64.5,0) 252(64.75,8.2) 253(65,0) 254(65.25,8.2) 255(65.5,0) 256(65.75,8.2) 257(66,0) 258(66.25,8.2) 259(66.5,0) 260(66.75,8.2)
  rect 3.505x4.597 smd: 261(-0.425,16.1) 262(67.175,16.1)
LOTES_ADDR0206-P001A02_260P
  round 1.092 hole 1.092 unplated: (-67.775,-4.1)
  round 1.6 hole 1.6 unplated: (1.025,-4.1)
  oval 0.305x1.753 smd: 1(0,0) 2(-0.25,-8.2) 3(-0.5,0) 4(-0.75,-8.2) 5(-1,0) 6(-1.25,-8.2) 7(-1.5,0) 8(-1.75,-8.2) 9(-2,0) 10(-2.25,-8.2) 11(-2.5,0) 12(-2.75,-8.2) 13(-3,0) 14(-3.25,-8.2) 15(-3.5,0) 16(-3.75,-8.2) 17(-4,0) 18(-4.25,-8.2) 19(-4.5,0) 20(-4.75,-8.2) 21(-5,0) 22(-5.25,-8.2) 23(-5.5,0) 24(-5.75,-8.2) 25(-6,0) 26(-6.25,-8.2) 27(-6.5,0) 28(-6.75,-8.2) 29(-7,0) 30(-7.25,-8.2) 31(-7.5,0) 32(-7.75,-8.2) 33(-8,0) 34(-8.25,-8.2) 35(-8.5,0) 36(-8.75,-8.2) 37(-9,0) 38(-9.25,-8.2) 39(-9.5,0) 40(-9.75,-8.2) 41(-10,0) 42(-10.25,-8.2) 43(-10.5,0) 44(-10.75,-8.2) 45(-11,0) 46(-11.25,-8.2) 47(-11.5,0) 48(-11.75,-8.2) 49(-12,0) 50(-12.25,-8.2) 51(-12.5,0) 52(-12.75,-8.2) 53(-13,0) 54(-13.25,-8.2) 55(-13.5,0) 56(-13.75,-8.2) 57(-14,0) 58(-14.25,-8.2) 59(-14.5,0) 60(-14.75,-8.2) 61(-15,0) 62(-15.25,-8.2) 63(-15.5,0) 64(-15.75,-8.2) 65(-16,0) 66(-16.25,-8.2) 67(-16.5,0) 68(-16.75,-8.2) 69(-17,0) 70(-17.25,-8.2) 71(-17.5,0) 72(-17.75,-8.2) 73(-18,0) 74(-18.25,-8.2) 75(-18.5,0) 76(-18.75,-8.2) 77(-19,0) 78(-19.25,-8.2) 79(-19.5,0) 80(-19.75,-8.2) 81(-20,0) 82(-20.25,-8.2) 83(-20.5,0) 84(-20.75,-8.2) 85(-21,0) 86(-21.25,-8.2) 87(-21.5,0) 88(-21.75,-8.2) 89(-22,0) 90(-22.25,-8.2) 91(-22.5,0) 92(-22.75,-8.2) 93(-23,0) 94(-23.25,-8.2) 95(-23.5,0) 96(-23.75,-8.2) 97(-24,0) 98(-24.25,-8.2) 99(-24.5,0) 100(-24.75,-8.2) 101(-25,0) 102(-25.25,-8.2) 103(-25.5,0) 104(-25.75,-8.2) 105(-26,0) 106(-26.25,-8.2) 107(-26.5,0) 108(-26.75,-8.2) 109(-27,0) 110(-27.25,-8.2) 111(-27.5,0) 112(-27.75,-8.2) 113(-28,0) 114(-28.25,-8.2) 115(-28.5,0) 116(-28.75,-8.2) 117(-29,0) 118(-29.25,-8.2) 119(-29.5,0) 120(-29.75,-8.2) 121(-30,0) 122(-30.25,-8.2) 123(-30.5,0) 124(-30.75,-8.2) 125(-31,0) 126(-31.25,-8.2) 127(-31.5,0) 128(-31.75,-8.2) 129(-32,0) 130(-32.25,-8.2) 131(-32.5,0) 132(-32.75,-8.2) 133(-33,0) 134(-33.25,-8.2) 135(-33.5,0) 136(-33.75,-8.2) 137(-34,0) 138(-34.25,-8.2) 139(-34.5,0) 140(-34.75,-8.2) 141(-35,0) 142(-35.25,-8.2) 143(-35.5,0) 144(-35.75,-8.2) 145(-38,0) 146(-38.25,-8.2) 147(-38.5,0) 148(-38.75,-8.2) 149(-39,0) 150(-39.25,-8.2) 151(-39.5,0) 152(-39.75,-8.2) 153(-40,0) 154(-40.25,-8.2) 155(-40.5,0) 156(-40.75,-8.2) 157(-41,0) 158(-41.25,-8.2) 159(-41.5,0) 160(-41.75,-8.2) 161(-42,0) 162(-42.25,-8.2) 163(-42.5,0) 164(-42.75,-8.2) 165(-43,0) 166(-43.25,-8.2) 167(-43.5,0) 168(-43.75,-8.2) 169(-44,0) 170(-44.25,-8.2) 171(-44.5,0) 172(-44.75,-8.2) 173(-45,0) 174(-45.25,-8.2) 175(-45.5,0) 176(-45.75,-8.2) 177(-46,0) 178(-46.25,-8.2) 179(-46.5,0) 180(-46.75,-8.2) 181(-47,0) 182(-47.25,-8.2) 183(-47.5,0) 184(-47.75,-8.2) 185(-48,0) 186(-48.25,-8.2) 187(-48.5,0) 188(-48.75,-8.2) 189(-49,0) 190(-49.25,-8.2) 191(-49.5,0) 192(-49.75,-8.2) 193(-50,0) 194(-50.25,-8.2) 195(-50.5,0) 196(-50.75,-8.2) 197(-51,0) 198(-51.25,-8.2) 199(-51.5,0) 200(-51.75,-8.2) 201(-52,0) 202(-52.25,-8.2) 203(-52.5,0) 204(-52.75,-8.2) 205(-53,0) 206(-53.25,-8.2) 207(-53.5,0) 208(-53.75,-8.2) 209(-54,0) 210(-54.25,-8.2) 211(-54.5,0) 212(-54.75,-8.2) 213(-55,0) 214(-55.25,-8.2) 215(-55.5,0) 216(-55.75,-8.2) 217(-56,0) 218(-56.25,-8.2) 219(-56.5,0) 220(-56.75,-8.2) 221(-57,0) 222(-57.25,-8.2) 223(-57.5,0) 224(-57.75,-8.2) 225(-58,0) 226(-58.25,-8.2) 227(-58.5,0) 228(-58.75,-8.2) 229(-59,0) 230(-59.25,-8.2) 231(-59.5,0) 232(-59.75,-8.2) 233(-60,0) 234(-60.25,-8.2) 235(-60.5,0) 236(-60.75,-8.2) 237(-61,0) 238(-61.25,-8.2) 239(-61.5,0) 240(-61.75,-8.2) 241(-62,0) 242(-62.25,-8.2) 243(-62.5,0) 244(-62.75,-8.2) 245(-63,0) 246(-63.25,-8.2) 247(-63.5,0) 248(-63.75,-8.2) 249(-64,0) 250(-64.25,-8.2) 251(-64.5,0) 252(-64.75,-8.2) 253(-65,0) 254(-65.25,-8.2) 255(-65.5,0) 256(-65.75,-8.2) 257(-66,0) 258(-66.25,-8.2) 259(-66.5,0) 260(-66.75,-8.2)
  rect 3.505x4.597 smd: 261(-67.175,7.9) 262(0.425,7.9)
LOTES_APCI0096-P002A_75P
  round 1.092 hole 1.092 unplated: (-0.75,-4.725)
  round 1.6 hole 1.6 unplated: (19.25,-4.725)
  oval 0.305x1.549 smd: 1(0,0) 2(0.25,-6.45) 3(0.5,0) 4(0.75,-6.45) 5(1,0) 6(1.25,-6.45) 7(1.5,0) 8(1.75,-6.45) 9(2,0) 10(2.25,-6.45) 11(2.5,0) 12(2.75,-6.45) 13(3,0) 14(3.25,-6.45) 15(3.5,0) 16(3.75,-6.45) 17(4,0) 18(4.25,-6.45) 19(4.5,0) 20(4.75,-6.45) 21(5,0) 22(5.25,-6.45) 23(5.5,0) 24(5.75,-6.45) 25(6,0) 26(6.25,-6.45) 27(6.5,0) 28(6.75,-6.45) 29(7,0) 30(7.25,-6.45) 31(7.5,0) 32(7.75,-6.45) 33(8,0) 34(8.25,-6.45) 35(8.5,0) 36(8.75,-6.45) 37(9,0) 38(9.25,-6.45) 39(9.5,0) 40(9.75,-6.45) 41(10,0) 42(10.25,-6.45) 43(10.5,0) 44(10.75,-6.45) 45(11,0) 46(11.25,-6.45) 47(11.5,0) 48(11.75,-6.45) 49(12,0) 50(12.25,-6.45) 51(12.5,0) 52(12.75,-6.45) 53(13,0) 54(13.25,-6.45) 55(13.5,0) 56(13.75,-6.45) 57(14,0) 58(14.25,-6.45) 67(16.5,0) 68(16.75,-6.45) 69(17,0) 70(17.25,-6.45) 71(17.5,0) 72(17.75,-6.45) 73(18,0) 74(18.25,-6.45) 75(18.5,0)
  rect 1.194x2.743 smd: 76(-1.1,-0.225) 77(19.6,-0.225)
LOTES_APCI0128-P005A_75P
  round 1.092 hole 1.092 unplated: (-0.75,-5.275)
  round 1.6 hole 1.6 unplated: (19.25,-5.275)
  oval 0.305x1.549 smd: 1(0,0) 2(0.25,-7.55) 3(0.5,0) 4(0.75,-7.55) 5(1,0) 6(1.25,-7.55) 7(1.5,0) 8(1.75,-7.55) 9(2,0) 10(2.25,-7.55) 11(2.5,0) 12(2.75,-7.55) 13(3,0) 14(3.25,-7.55) 15(3.5,0) 16(3.75,-7.55) 17(4,0) 18(4.25,-7.55) 19(4.5,0) 20(4.75,-7.55) 21(5,0) 22(5.25,-7.55) 23(5.5,0) 32(7.75,-7.55) 33(8,0) 34(8.25,-7.55) 35(8.5,0) 36(8.75,-7.55) 37(9,0) 38(9.25,-7.55) 39(9.5,0) 40(9.75,-7.55) 41(10,0) 42(10.25,-7.55) 43(10.5,0) 44(10.75,-7.55) 45(11,0) 46(11.25,-7.55) 47(11.5,0) 48(11.75,-7.55) 49(12,0) 50(12.25,-7.55) 51(12.5,0) 52(12.75,-7.55) 53(13,0) 54(13.25,-7.55) 55(13.5,0) 56(13.75,-7.55) 57(14,0) 58(14.25,-7.55) 59(14.5,0) 60(14.75,-7.55) 61(15,0) 62(15.25,-7.55) 63(15.5,0) 64(15.75,-7.55) 65(16,0) 66(16.25,-7.55) 67(16.5,0) 68(16.75,-7.55) 69(17,0) 70(17.25,-7.55) 71(17.5,0) 72(17.75,-7.55) 73(18,0) 74(18.25,-7.55) 75(18.5,0)
  rect 1.194x2.743 smd: 76(-1.1,-0.775) 77(19.6,-0.775)
LOTES_APCI0181-P001A_75P
  round 1.092 hole 1.092 unplated: (-1.75,-1.7)
  round 1.6 hole 1.6 unplated: (20.25,-1.7)
  oval 0.305x1.499 smd: 1(0,0) 3(0.5,0) 5(1,0) 7(1.5,0) 9(2,0) 11(2.5,0) 13(3,0) 15(3.5,0) 17(4,0) 19(4.5,0) 21(5,0) 23(5.5,0) 25(6,0) 27(6.5,0) 29(7,0) 31(7.5,0) 33(8,0) 35(8.5,0) 37(9,0) 39(9.5,0) 41(10,0) 43(10.5,0) 45(11,0) 47(11.5,0) 49(12,0) 51(12.5,0) 53(13,0) 55(13.5,0) 57(14,0) 67(16.5,0) 69(17,0) 71(17.5,0) 73(18,0) 75(18.5,0)
  round 0.762 hole 0.508: 2(0.25,-2.59) 4(0.75,-1.79) 6(1.25,-2.59) 8(1.75,-1.79) 10(2.25,-2.59) 12(2.75,-1.79) 14(3.25,-2.59) 16(3.75,-1.79) 18(4.25,-2.59) 20(4.75,-1.79) 22(5.25,-2.59) 24(5.75,-1.79) 26(6.25,-2.59) 28(6.75,-1.79) 30(7.25,-2.59) 32(7.75,-1.79) 34(8.25,-2.59) 36(8.75,-1.79) 38(9.25,-2.59) 40(9.75,-1.79) 42(10.25,-2.59) 44(10.75,-1.79) 46(11.25,-2.59) 48(11.75,-1.79) 50(12.25,-2.59) 52(12.75,-1.79) 54(13.25,-2.59) 56(13.75,-1.79) 58(14.25,-2.59) 68(16.75,-1.79) 70(17.25,-2.59) 72(17.75,-1.79) 74(18.25,-2.59)
  oval 0.889x2.159 hole 0.508x1.753: 76(-2,-5.75) 77(20.5,-5.75)
LOTES_AZIF0049-P001C_1151P-T
  round 0.508 smd: A4(2.743,0) A5(3.658,0) AT40(37.861,-32.918) AU1(0,-32.918) AU39(36.947,-33.833) AU40(37.861,-33.833) AV1(0,-33.833) AV2(0.914,-33.833) AV38(36.032,-34.747) AV39(36.947,-34.747) AW2(0.914,-34.747) AW3(1.829,-34.747) AW37(35.118,-35.662) AW38(36.032,-35.662) AY3(1.829,-35.662) AY4(2.743,-35.662) B3(1.829,-0.914) B4(2.743,-0.914) B37(35.118,-1.829) B38(36.032,-1.829) B39(36.947,-1.829) C2(0.914,-1.829) C3(1.829,-1.829) C39(36.947,-2.743) C40(37.861,-2.743) D1(0,-2.743) D2(0.914,-2.743) D40(37.861,-3.658) E40(37.861,-4.572)
  round 0.432 smd: A6(4.572,0) A7(5.486,0) A25(21.946,0) A26(22.86,0) A27(23.774,0) A28(24.689,0) A29(25.603,0) A30(26.518,0) AA5(3.658,-18.288) AA6(4.572,-18.288) AA7(5.486,-18.288) AA8(6.401,-18.288) AA33(31.46,-19.202) AA34(32.375,-19.202) AA35(33.289,-19.202) AA36(34.204,-19.202) AA37(35.118,-19.202) AA38(36.032,-19.202) AB5(3.658,-19.202) AB6(4.572,-19.202) AB7(5.486,-19.202) AB8(6.401,-19.202) AB33(31.46,-20.117) AB34(32.375,-20.117) AB35(33.289,-20.117) AB36(34.204,-20.117) AB37(35.118,-20.117) AC5(3.658,-20.117) AC6(4.572,-20.117) AC7(5.486,-20.117) AC8(6.401,-20.117) AC33(31.46,-21.031) AC34(32.375,-21.031) AC35(33.289,-21.031) AC36(34.204,-21.031) AC37(35.118,-21.031) AD3(1.829,-21.031) AD4(2.743,-21.031) AD5(3.658,-21.031) AD6(4.572,-21.031) AD7(5.486,-21.031) AD8(6.401,-21.031) AD33(31.46,-21.946) AD34(32.375,-21.946) AD35(33.289,-21.946) AD36(34.204,-21.946) AD37(35.118,-21.946) AE3(1.829,-21.946) AE4(2.743,-21.946) AE5(3.658,-21.946) AE6(4.572,-21.946) AE7(5.486,-21.946) AE8(6.401,-21.946) AE33(31.46,-22.86) AE34(32.375,-22.86) AE35(33.289,-22.86) AE36(34.204,-22.86) AE37(35.118,-22.86) AE38(36.032,-22.86) AF4(2.743,-22.86) AF5(3.658,-22.86) AF6(4.572,-22.86) AF7(5.486,-22.86) AF8(6.401,-22.86) AF33(31.46,-23.774) AF34(32.375,-23.774) AF35(33.289,-23.774) AF36(34.204,-23.774) AF37(35.118,-23.774) AF38(36.032,-23.774) AG4(2.743,-23.774) AG5(3.658,-23.774) AG6(4.572,-23.774) AG7(5.486,-23.774) AG8(6.401,-23.774) AG33(31.46,-24.689) AG34(32.375,-24.689) AG35(33.289,-24.689) AG36(34.204,-24.689) AG37(35.118,-24.689) AG38(36.032,-24.689) AH3(1.829,-24.689) AH4(2.743,-24.689) AH5(3.658,-24.689) AH6(4.572,-24.689) AH7(5.486,-24.689) AH8(6.401,-24.689) AH33(31.46,-25.603) AH34(32.375,-25.603) AH35(33.289,-25.603) AH36(34.204,-25.603) AH37(35.118,-25.603) AH38(36.032,-25.603) AJ3(1.829,-25.603) AJ4(2.743,-25.603) AJ5(3.658,-25.603) AJ6(4.572,-25.603) AJ7(5.486,-25.603) AJ8(6.401,-25.603) AJ9(7.315,-25.603) AJ11(11.344,-26.518) AJ12(12.258,-26.518) AJ13(13.172,-26.518) AJ14(14.087,-26.518) AJ15(15.001,-26.518) AJ16(15.916,-26.518) AJ17(16.83,-26.518) AJ18(17.744,-26.518) AJ19(18.659,-26.518) AJ20(19.573,-26.518) AJ21(20.488,-26.518) AJ22(21.402,-26.518) AJ23(22.316,-26.518) AJ24(23.231,-26.518) AJ25(24.145,-26.518) AJ26(25.06,-26.518) AJ27(25.974,-26.518) AJ28(26.888,-26.518) AJ29(27.803,-26.518) AJ30(28.717,-26.518) AJ31(29.632,-26.518) AJ32(30.546,-26.518) AJ33(31.46,-26.518) AJ34(32.375,-26.518) AJ35(33.289,-26.518) AJ36(34.204,-26.518) AJ37(35.118,-26.518) AJ38(36.032,-26.518) AK3(1.829,-26.518) AK4(2.743,-26.518) AK5(3.658,-26.518) AK6(4.572,-26.518) AK7(5.486,-26.518) AK8(6.401,-26.518) AK9(7.315,-26.518) AK10(8.23,-26.518) AK11(11.344,-27.432) AK12(12.258,-27.432) AK13(13.172,-27.432) AK14(14.087,-27.432) AK15(15.001,-27.432) AK16(15.916,-27.432) AK17(16.83,-27.432) AK18(17.744,-27.432) AK19(18.659,-27.432) AK20(19.573,-27.432) AK21(20.488,-27.432) AK22(21.402,-27.432) AK23(22.316,-27.432) AK24(23.231,-27.432) AK25(24.145,-27.432) AK26(25.06,-27.432) AK27(25.974,-27.432) AK28(26.888,-27.432) AK29(27.803,-27.432) AK30(28.717,-27.432) AK31(29.632,-27.432) AK32(30.546,-27.432) AK33(31.46,-27.432) AK34(32.375,-27.432) AK35(33.289,-27.432) AK36(34.204,-27.432) AK37(35.118,-27.432) AK38(36.032,-27.432) AL3(1.829,-27.432) AL4(2.743,-27.432) AL5(3.658,-27.432) AL6(4.572,-27.432) AL7(5.486,-27.432) AL8(6.401,-27.432) AL9(7.315,-27.432) AL10(8.23,-27.432) AL11(11.344,-28.346) AL12(12.258,-28.346) AL13(13.172,-28.346) AL14(14.087,-28.346) AL15(15.001,-28.346) AL16(15.916,-28.346) AL17(16.83,-28.346) AL18(17.744,-28.346) AL19(18.659,-28.346) AL20(19.573,-28.346) AL21(20.488,-28.346) AL22(21.402,-28.346) AL23(22.316,-28.346) AL24(23.231,-28.346) AL25(24.145,-28.346) AL26(25.06,-28.346) AL27(25.974,-28.346) AL28(26.888,-28.346) AL29(27.803,-28.346) AL30(28.717,-28.346) AL31(29.632,-28.346) AL32(30.546,-28.346) AL33(31.46,-28.346) AL34(32.375,-28.346) AL35(33.289,-28.346) AL36(34.204,-28.346) AL37(35.118,-28.346) AL38(36.032,-28.346) AM3(1.829,-28.346) AM4(2.743,-28.346) AM5(3.658,-28.346) AM6(4.572,-28.346) AM7(5.486,-28.346) AM8(6.401,-28.346) AM9(7.315,-28.346) AM10(8.23,-28.346) AM11(11.344,-29.261) AM12(12.258,-29.261) AM13(13.172,-29.261) AM14(14.087,-29.261) AM15(15.001,-29.261) AM16(15.916,-29.261) AM17(16.83,-29.261) AM18(17.744,-29.261) AM19(18.659,-29.261) AM20(19.573,-29.261) AM21(20.488,-29.261) AM22(21.402,-29.261) AM23(22.316,-29.261) AM24(23.231,-29.261) AM25(24.145,-29.261) AM26(25.06,-29.261) AM27(25.974,-29.261) AM28(26.888,-29.261) AM29(27.803,-29.261) AM30(28.717,-29.261) AM31(29.632,-29.261) AM32(30.546,-29.261) AM33(31.46,-29.261) AM34(32.375,-29.261) AM35(33.289,-29.261) AM36(34.204,-29.261) AM37(35.118,-29.261) AM38(36.032,-29.261) AN3(1.829,-29.261) AN4(2.743,-29.261) AN5(3.658,-29.261) AN6(4.572,-29.261) AN7(5.486,-29.261) AN8(6.401,-29.261) AN9(7.315,-29.261) AN10(8.23,-29.261) AN11(11.344,-30.175) AN12(12.258,-30.175) AN13(13.172,-30.175) AN14(14.087,-30.175) AN15(15.001,-30.175) AN16(15.916,-30.175) AN17(16.83,-30.175) AN18(17.744,-30.175) AN19(18.659,-30.175) AN20(19.573,-30.175) AN21(20.488,-30.175) AN22(21.402,-30.175) AN23(22.316,-30.175) AN24(23.231,-30.175) AN25(24.145,-30.175) AN26(25.06,-30.175) AN27(25.974,-30.175) AN28(26.888,-30.175) AN29(27.803,-30.175) AN30(28.717,-30.175) AN31(29.632,-30.175) AN32(30.546,-30.175) AN33(31.46,-30.175) AN34(32.375,-30.175) AN35(33.289,-30.175) AN36(34.204,-30.175) AN37(35.118,-30.175) AN38(36.032,-30.175) AP3(1.829,-30.175) AP4(2.743,-30.175) AP5(3.658,-30.175) AP6(4.572,-30.175) AP7(5.486,-30.175) AP8(6.401,-30.175) AP9(7.315,-30.175) AP10(8.23,-30.175) AP11(11.344,-31.09) AP12(12.258,-31.09) AP13(13.172,-31.09) AP14(14.087,-31.09) AP15(15.001,-31.09) AP16(15.916,-31.09) AP17(16.83,-31.09) AP18(17.744,-31.09) AP19(18.659,-31.09) AP20(19.573,-31.09) AP21(20.488,-31.09) AP22(21.402,-31.09) AP23(22.316,-31.09) AP24(23.231,-31.09) AP25(24.145,-31.09) AP26(25.06,-31.09) AP27(25.974,-31.09) AP28(26.888,-31.09) AP29(27.803,-31.09) AP30(28.717,-31.09) AP31(29.632,-31.09) AP32(30.546,-31.09) AP33(31.46,-31.09) AP34(32.375,-31.09) AP35(33.289,-31.09) AP36(34.204,-31.09) AP37(35.118,-31.09) AP38(36.032,-31.09) AR3(1.829,-31.09) AR4(2.743,-31.09) AR5(3.658,-31.09) AR6(4.572,-31.09) AR7(5.486,-31.09) AR8(6.401,-31.09) AR9(7.315,-31.09) AR10(8.23,-31.09) AR11(11.344,-32.004) AR12(12.258,-32.004) AR13(13.172,-32.004) AR14(14.087,-32.004) AR15(15.001,-32.004) AR16(15.916,-32.004) AR17(16.83,-32.004) AR18(17.744,-32.004) AR19(18.659,-32.004) AR20(19.573,-32.004) AR21(20.488,-32.004) AR22(21.402,-32.004) AR23(22.316,-32.004) AR24(23.231,-32.004) AR25(24.145,-32.004) AR26(25.06,-32.004) AR27(25.974,-32.004) AR28(26.888,-32.004) AR29(27.803,-32.004) AR30(28.717,-32.004) AR31(29.632,-32.004) AR32(30.546,-32.004) AR33(31.46,-32.004) AR34(32.375,-32.004) AR35(33.289,-32.004) AR36(34.204,-32.004) AR37(35.118,-32.004) AR38(36.032,-32.004) AT3(1.829,-32.004) AT4(2.743,-32.004) AT5(3.658,-32.004) AT6(4.572,-32.004) AT7(5.486,-32.004) AT8(6.401,-32.004) AT9(7.315,-32.004) AT10(8.23,-32.004) AT11(11.344,-32.918) AT12(12.258,-32.918) AT13(13.172,-32.918) AT14(14.087,-32.918) AT15(15.001,-32.918) AT16(15.916,-32.918) AT17(16.83,-32.918) AT18(17.744,-32.918) AT19(18.659,-32.918) AT20(19.573,-32.918) AT21(20.488,-32.918) AT22(21.402,-32.918) AT23(22.316,-32.918) AT24(23.231,-32.918) AT25(24.145,-32.918) AT26(25.06,-32.918) AT27(25.974,-32.918) AT28(26.888,-32.918) AT29(27.803,-32.918) AT30(28.717,-32.918) AT31(29.632,-32.918) AT32(30.546,-32.918) AT33(31.46,-32.918) AT34(32.375,-32.918) AT35(33.289,-32.918) AT36(34.204,-32.918) AT37(35.118,-32.918) AT38(36.032,-32.918) AU3(1.829,-32.918) AU4(2.743,-32.918) AU5(3.658,-32.918) AU6(4.572,-32.918) AU7(5.486,-32.918) AU8(6.401,-32.918) AU9(7.315,-32.918) AU10(8.23,-32.918) AU11(11.344,-33.833) AU12(12.258,-33.833) AU13(13.172,-33.833) AU14(14.087,-33.833) AU15(15.001,-33.833) AU16(15.916,-33.833) AU17(16.83,-33.833) AU18(17.744,-33.833) AU19(18.659,-33.833) AU20(19.573,-33.833) AU21(20.488,-33.833) AU24(23.231,-33.833) AU25(24.145,-33.833) AU26(25.06,-33.833) AU27(25.974,-33.833) AU28(26.888,-33.833) AU29(27.803,-33.833) AU30(28.717,-33.833) AU31(29.632,-33.833) AU32(30.546,-33.833) AU33(31.46,-33.833) AU34(32.375,-33.833) AU35(33.289,-33.833) AU36(34.204,-33.833) AU37(35.118,-33.833) AU38(36.032,-33.833) AV3(1.829,-33.833) AV4(2.743,-33.833) AV5(3.658,-33.833) AV6(4.572,-33.833) AV7(5.486,-33.833) AV8(6.401,-33.833) AV9(7.315,-33.833) AV10(8.23,-33.833) AV11(11.344,-34.747) AV12(12.258,-34.747) AV13(13.172,-34.747) AV14(14.087,-34.747) AV24(23.231,-34.747) AV25(24.145,-34.747) AV28(26.888,-34.747) AV29(27.803,-34.747) AV37(35.118,-34.747) AW4(2.743,-34.747) AW9(7.315,-34.747) AW10(8.23,-34.747) AW11(11.344,-35.662) AW12(12.258,-35.662) AW13(13.172,-35.662) AW14(14.087,-35.662) AY10(8.23,-35.662) B5(3.658,-0.914) B6(4.572,-0.914) B7(5.486,-0.914) B25(21.946,-0.914) B26(22.86,-0.914) B27(23.774,-0.914) B28(24.689,-0.914) B29(25.603,-0.914) B30(26.518,-0.914) B31(29.632,-1.829) B32(30.546,-1.829) B33(31.46,-1.829) B34(32.375,-1.829) B35(33.289,-1.829) B36(34.204,-1.829) C4(2.743,-1.829) C5(3.658,-1.829) C6(4.572,-1.829) C7(5.486,-1.829) C8(6.401,-1.829) C9(7.315,-1.829) C12(10.058,-1.829) C13(10.973,-1.829) C14(11.887,-1.829) C15(12.802,-1.829) C16(13.716,-1.829) C17(14.63,-1.829) C25(21.946,-1.829) C26(22.86,-1.829) C27(23.774,-1.829) C28(24.689,-1.829) C29(25.603,-1.829) C30(26.518,-1.829) C31(29.632,-2.743) C32(30.546,-2.743) C33(31.46,-2.743) C34(32.375,-2.743) C35(33.289,-2.743) C36(34.204,-2.743) C37(35.118,-2.743) C38(36.032,-2.743) D3(1.829,-2.743) D4(2.743,-2.743) D5(3.658,-2.743) D6(4.572,-2.743) D7(5.486,-2.743) D8(6.401,-2.743) D9(7.315,-2.743) D10(8.23,-2.743) D11(9.144,-2.743) D12(10.058,-2.743) D13(10.973,-2.743) D14(11.887,-2.743) D15(12.802,-2.743) D16(13.716,-2.743) D17(14.63,-2.743) D24(21.031,-2.743) D25(21.946,-2.743) D26(22.86,-2.743) D27(23.774,-2.743) D28(24.689,-2.743) D29(25.603,-2.743) D30(26.518,-2.743) D31(29.632,-3.658) D32(30.546,-3.658) D33(31.46,-3.658) D34(32.375,-3.658) D35(33.289,-3.658) D36(34.204,-3.658) D37(35.118,-3.658) D38(36.032,-3.658) D39(36.947,-3.658) E3(1.829,-3.658) E4(2.743,-3.658) E5(3.658,-3.658) E6(4.572,-3.658) E7(5.486,-3.658) E8(6.401,-3.658) E9(7.315,-3.658) E10(8.23,-3.658) E11(9.144,-3.658) E12(10.058,-3.658) E13(10.973,-3.658) E14(11.887,-3.658) E15(12.802,-3.658) E16(13.716,-3.658) E17(14.63,-3.658) E18(15.545,-3.658) E19(16.459,-3.658) E21(18.288,-3.658) E23(20.117,-3.658) E24(21.031,-3.658) E25(21.946,-3.658) E26(22.86,-3.658) E27(23.774,-3.658) E28(24.689,-3.658) E29(25.603,-3.658) E30(26.518,-3.658) E31(29.632,-4.572) E32(30.546,-4.572) E33(31.46,-4.572) E34(32.375,-4.572) E35(33.289,-4.572) E36(34.204,-4.572) E37(35.118,-4.572) E38(36.032,-4.572) E39(36.947,-4.572) F4(2.743,-4.572) F5(3.658,-4.572) F6(4.572,-4.572) F7(5.486,-4.572) F8(6.401,-4.572) F9(7.315,-4.572) F10(8.23,-4.572) F11(9.144,-4.572) F12(10.058,-4.572) F13(10.973,-4.572) F14(11.887,-4.572) F15(12.802,-4.572) F16(13.716,-4.572) F17(14.63,-4.572) F18(15.545,-4.572) F19(16.459,-4.572) F20(17.374,-4.572) F21(18.288,-4.572) F22(19.202,-4.572) F23(20.117,-4.572) F24(21.031,-4.572) F25(21.946,-4.572) F26(22.86,-4.572) F27(23.774,-4.572) F28(24.689,-4.572) F29(25.603,-4.572) F30(26.518,-4.572) F31(29.632,-5.486) F32(30.546,-5.486) F33(31.46,-5.486) F34(32.375,-5.486) F35(33.289,-5.486) F36(34.204,-5.486) F37(35.118,-5.486) F38(36.032,-5.486) F39(36.947,-5.486) F40(37.861,-5.486) G3(1.829,-5.486) G4(2.743,-5.486) G5(3.658,-5.486) G6(4.572,-5.486) G7(5.486,-5.486) G8(6.401,-5.486) G9(7.315,-5.486) G10(8.23,-5.486) G11(9.144,-5.486) G12(10.058,-5.486) G13(10.973,-5.486) G14(11.887,-5.486) G15(12.802,-5.486) G16(13.716,-5.486) G17(14.63,-5.486) G18(15.545,-5.486) G19(16.459,-5.486) G20(17.374,-5.486) G21(18.288,-5.486) G22(19.202,-5.486) G23(20.117,-5.486) G24(21.031,-5.486) G25(21.946,-5.486) G26(22.86,-5.486) G27(23.774,-5.486) G28(24.689,-5.486) G29(25.603,-5.486) G30(26.518,-5.486) G31(29.632,-6.401) G32(30.546,-6.401) G33(31.46,-6.401) G34(32.375,-6.401) G35(33.289,-6.401) G36(34.204,-6.401) G37(35.118,-6.401) G38(36.032,-6.401) G39(36.947,-6.401) G40(37.861,-6.401) H4(2.743,-6.401) H5(3.658,-6.401) H6(4.572,-6.401) H7(5.486,-6.401) H8(6.401,-6.401) H9(7.315,-6.401) H10(8.23,-6.401) H11(9.144,-6.401) H12(10.058,-6.401) H13(10.973,-6.401) H14(11.887,-6.401) H15(12.802,-6.401) H16(13.716,-6.401) H17(14.63,-6.401) H18(15.545,-6.401) H19(16.459,-6.401) H20(17.374,-6.401) H21(18.288,-6.401) H22(19.202,-6.401) H23(20.117,-6.401) H24(21.031,-6.401) H25(21.946,-6.401) H26(22.86,-6.401) H27(23.774,-6.401) H28(24.689,-6.401) H29(25.603,-6.401) H30(26.518,-6.401) H31(29.632,-7.315) H32(30.546,-7.315) H33(31.46,-7.315) H34(32.375,-7.315) H35(33.289,-7.315) H36(34.204,-7.315) H37(35.118,-7.315) H38(36.032,-7.315) H39(36.947,-7.315) H40(37.861,-7.315) J3(1.829,-7.315) J4(2.743,-7.315) J5(3.658,-7.315) J6(4.572,-7.315) J7(5.486,-7.315) J8(6.401,-7.315) J9(7.315,-7.315) J10(8.23,-7.315) J11(9.144,-7.315) J12(10.058,-7.315) J13(10.973,-7.315) J14(11.887,-7.315) J15(12.802,-7.315) J16(13.716,-7.315) J17(14.63,-7.315) J18(15.545,-7.315) J19(16.459,-7.315) J20(17.374,-7.315) J21(18.288,-7.315) J22(19.202,-7.315) J23(20.117,-7.315) J24(21.031,-7.315) J25(21.946,-7.315) J26(22.86,-7.315) J27(23.774,-7.315) J28(24.689,-7.315) J29(25.603,-7.315) J30(26.518,-7.315) J31(29.632,-8.23) J32(30.546,-8.23) J33(31.46,-8.23) J34(32.375,-8.23) J35(33.289,-8.23) J36(34.204,-8.23) J37(35.118,-8.23) J38(36.032,-8.23) J39(36.947,-8.23) J40(37.861,-8.23) K4(2.743,-8.23) K5(3.658,-8.23) K6(4.572,-8.23) K7(5.486,-8.23) K8(6.401,-8.23) K9(7.315,-8.23) K10(8.23,-8.23) K11(9.144,-8.23) K12(10.058,-8.23) K13(10.973,-8.23) K14(11.887,-8.23) K15(12.802,-8.23) K16(13.716,-8.23) K17(14.63,-8.23) K18(15.545,-8.23) K19(16.459,-8.23) K20(17.374,-8.23) K21(18.288,-8.23) K22(19.202,-8.23) K23(20.117,-8.23) K24(21.031,-8.23) K25(21.946,-8.23) K26(22.86,-8.23) K27(23.774,-8.23) K28(24.689,-8.23) K29(25.603,-8.23) K30(26.518,-8.23) K31(29.632,-9.144) K32(30.546,-9.144) K33(31.46,-9.144) K34(32.375,-9.144) K35(33.289,-9.144) K36(34.204,-9.144) K37(35.118,-9.144) K38(36.032,-9.144) K39(36.947,-9.144) K40(37.861,-9.144) L3(1.829,-9.144) L4(2.743,-9.144) L5(3.658,-9.144) L6(4.572,-9.144) L7(5.486,-9.144) L8(6.401,-9.144) L9(7.315,-9.144) L10(8.23,-9.144) L11(9.144,-9.144) L12(10.058,-9.144) L13(10.973,-9.144) L14(11.887,-9.144) L15(12.802,-9.144) L16(13.716,-9.144) L17(14.63,-9.144) L18(15.545,-9.144) L19(16.459,-9.144) L20(17.374,-9.144) L21(18.288,-9.144) L22(19.202,-9.144) L23(20.117,-9.144) L24(21.031,-9.144) L25(21.946,-9.144) L26(22.86,-9.144) L27(23.774,-9.144) L28(24.689,-9.144) L29(25.603,-9.144) L30(26.518,-9.144) L31(29.632,-10.058) L32(30.546,-10.058) L33(31.46,-10.058) L34(32.375,-10.058) L35(33.289,-10.058) L36(34.204,-10.058) L37(35.118,-10.058) L38(36.032,-10.058) L39(36.947,-10.058) L40(37.861,-10.058) M4(2.743,-10.058) M5(3.658,-10.058) M6(4.572,-10.058) M7(5.486,-10.058) M8(6.401,-10.058) M9(7.315,-10.058) M10(8.23,-10.058) M11(9.144,-10.058) M12(10.058,-10.058) M13(10.973,-10.058) M14(11.887,-10.058) M15(12.802,-10.058) M16(13.716,-10.058) M17(14.63,-10.058) M18(15.545,-10.058) M19(16.459,-10.058) M20(17.374,-10.058) M21(18.288,-10.058) M22(19.202,-10.058) M23(20.117,-10.058) M24(21.031,-10.058) M25(21.946,-10.058) M26(22.86,-10.058) M27(23.774,-10.058) M28(24.689,-10.058) M29(25.603,-10.058) M30(26.518,-10.058) M32(30.546,-10.973) M33(31.46,-10.973) M34(32.375,-10.973) M35(33.289,-10.973) M36(34.204,-10.973) M37(35.118,-10.973) M38(36.032,-10.973) M39(36.947,-10.973) M40(37.861,-10.973) N3(1.829,-10.973) N4(2.743,-10.973) N5(3.658,-10.973) N6(4.572,-10.973) N7(5.486,-10.973) N8(6.401,-10.973) N33(31.46,-11.887) N34(32.375,-11.887) N35(33.289,-11.887) N36(34.204,-11.887) N37(35.118,-11.887) N38(36.032,-11.887) N39(36.947,-11.887) N40(37.861,-11.887) P4(2.743,-11.887) P5(3.658,-11.887) P6(4.572,-11.887) P7(5.486,-11.887) P8(6.401,-11.887) P33(31.46,-12.802) P34(32.375,-12.802) P35(33.289,-12.802) P36(34.204,-12.802) P37(35.118,-12.802) P38(36.032,-12.802) P39(36.947,-12.802) P40(37.861,-12.802) R3(1.829,-12.802) R4(2.743,-12.802) R5(3.658,-12.802) R6(4.572,-12.802) R7(5.486,-12.802) R8(6.401,-12.802) R33(31.46,-13.716) R34(32.375,-13.716) R35(33.289,-13.716) R36(34.204,-13.716) R37(35.118,-13.716) R38(36.032,-13.716) R39(36.947,-13.716) R40(37.861,-13.716) T4(2.743,-13.716) T5(3.658,-13.716) T6(4.572,-13.716) T7(5.486,-13.716) T8(6.401,-13.716) T33(31.46,-14.63) T34(32.375,-14.63) T35(33.289,-14.63) T36(34.204,-14.63) T37(35.118,-14.63) T38(36.032,-14.63) T39(36.947,-14.63) T40(37.861,-14.63) U4(2.743,-14.63) U5(3.658,-14.63) U6(4.572,-14.63) U7(5.486,-14.63) U8(6.401,-14.63) U33(31.46,-15.545) U34(32.375,-15.545) U35(33.289,-15.545) U36(34.204,-15.545) U37(35.118,-15.545) U38(36.032,-15.545) U39(36.947,-15.545) U40(37.861,-15.545) V4(2.743,-15.545) V5(3.658,-15.545) V6(4.572,-15.545) V7(5.486,-15.545) V8(6.401,-15.545) V33(31.46,-16.459) V34(32.375,-16.459) V35(33.289,-16.459) V36(34.204,-16.459) V37(35.118,-16.459) V38(36.032,-16.459) V39(36.947,-16.459) V40(37.861,-16.459) W4(2.743,-16.459) W5(3.658,-16.459) W6(4.572,-16.459) W7(5.486,-16.459) W8(6.401,-16.459) W33(31.46,-17.374) W34(32.375,-17.374) W35(33.289,-17.374) W36(34.204,-17.374) W37(35.118,-17.374) W38(36.032,-17.374) Y5(3.658,-17.374) Y6(4.572,-17.374) Y7(5.486,-17.374) Y8(6.401,-17.374) Y33(31.46,-18.288) Y34(32.375,-18.288) Y35(33.289,-18.288) Y36(34.204,-18.288) Y37(35.118,-18.288) Y38(36.032,-18.288)
  oval 0.356x0.457 smd: A11(9.144,0) A12(10.058,0) A13(10.973,0) A14(11.887,0) A15(12.802,0) A16(13.716,0) A17(14.63,0) A18(15.545,0) A23(20.117,0) A24(21.031,0) AU22(21.402,-33.833) AU23(22.316,-33.833) AV15(15.001,-34.747) AV16(15.916,-34.747) AV17(16.83,-34.747) AV18(17.744,-34.747) AV19(18.659,-34.747) AV20(19.573,-34.747) AV21(20.488,-34.747) AV22(21.402,-34.747) AV23(22.316,-34.747) AV26(25.06,-34.747) AV27(25.974,-34.747) AV30(28.717,-34.747) AV31(29.632,-34.747) AV32(30.546,-34.747) AV33(31.46,-34.747) AV34(32.375,-34.747) AV35(33.289,-34.747) AV36(34.204,-34.747) AW5(3.658,-34.747) AW6(4.572,-34.747) AW7(5.486,-34.747) AW8(6.401,-34.747) AW15(15.001,-35.662) AW16(15.916,-35.662) AW17(16.83,-35.662) AW18(17.744,-35.662) AW23(22.316,-35.662) AW24(23.231,-35.662) AW25(24.145,-35.662) AW26(25.06,-35.662) AW27(25.974,-35.662) AW28(26.888,-35.662) AW29(27.803,-35.662) AW30(28.717,-35.662) AW31(29.632,-35.662) AW32(30.546,-35.662) AW33(31.46,-35.662) AW34(32.375,-35.662) AW35(33.289,-35.662) AW36(34.204,-35.662) AY5(3.658,-35.662) AY6(4.572,-35.662) AY7(5.486,-35.662) AY8(6.401,-35.662) AY9(7.315,-35.662) AY11(11.344,-36.576) AY12(12.258,-36.576) AY13(13.172,-36.576) AY14(14.087,-36.576) AY15(15.001,-36.576) AY16(15.916,-36.576) AY17(16.83,-36.576) AY18(17.744,-36.576) AY23(22.316,-36.576) AY24(23.231,-36.576) AY25(24.145,-36.576) AY26(25.06,-36.576) AY27(25.974,-36.576) AY28(26.888,-36.576) AY29(27.803,-36.576) AY30(28.717,-36.576) AY31(29.632,-36.576) B8(6.401,-0.914) B9(7.315,-0.914) B10(8.23,-0.914) B11(9.144,-0.914) B12(10.058,-0.914) B13(10.973,-0.914) B14(11.887,-0.914) B15(12.802,-0.914) B16(13.716,-0.914) B17(14.63,-0.914) B18(15.545,-0.914) B23(20.117,-0.914) B24(21.031,-0.914) C10(8.23,-1.829) C11(9.144,-1.829) C18(15.545,-1.829) C19(16.459,-1.829) C20(17.374,-1.829) C21(18.288,-1.829) C22(19.202,-1.829) C23(20.117,-1.829) C24(21.031,-1.829) D18(15.545,-2.743) D19(16.459,-2.743) D20(17.374,-2.743) D21(18.288,-2.743) D22(19.202,-2.743) D23(20.117,-2.743) E20(17.374,-3.658) E22(19.202,-3.658)
  oval 0.457x0.356 smd: AA3(1.829,-18.288) AA4(2.743,-18.288) AB3(1.829,-19.202) AB4(2.743,-19.202) AB38(36.032,-20.117) AB39(36.947,-20.117) AB40(37.861,-20.117) AC1(0,-20.117) AC2(0.914,-20.117) AC3(1.829,-20.117) AC4(2.743,-20.117) AC38(36.032,-21.031) AC39(36.947,-21.031) AC40(37.861,-21.031) AD1(0,-21.031) AD2(0.914,-21.031) AD38(36.032,-21.946) AD39(36.947,-21.946) AD40(37.861,-21.946) AE1(0,-21.946) AE2(0.914,-21.946) AE39(36.947,-22.86) AE40(37.861,-22.86) AF1(0,-22.86) AF2(0.914,-22.86) AF3(1.829,-22.86) AF39(36.947,-23.774) AF40(37.861,-23.774) AG1(0,-23.774) AG2(0.914,-23.774) AG3(1.829,-23.774) AG39(36.947,-24.689) AG40(37.861,-24.689) AH1(0,-24.689) AH2(0.914,-24.689) AH39(36.947,-25.603) AH40(37.861,-25.603) AJ1(0,-25.603) AJ2(0.914,-25.603) AJ39(36.947,-26.518) AJ40(37.861,-26.518) AK1(0,-26.518) AK2(0.914,-26.518) AK39(36.947,-27.432) AK40(37.861,-27.432) AL1(0,-27.432) AL2(0.914,-27.432) AL39(36.947,-28.346) AL40(37.861,-28.346) AM1(0,-28.346) AM2(0.914,-28.346) AM39(36.947,-29.261) AM40(37.861,-29.261) AN1(0,-29.261) AN2(0.914,-29.261) AN39(36.947,-30.175) AN40(37.861,-30.175) AP1(0,-30.175) AP2(0.914,-30.175) AP39(36.947,-31.09) AP40(37.861,-31.09) AR1(0,-31.09) AR2(0.914,-31.09) AR39(36.947,-32.004) AR40(37.861,-32.004) AT1(0,-32.004) AT2(0.914,-32.004) AT39(36.947,-32.918) AU2(0.914,-32.918) E1(0,-3.658) E2(0.914,-3.658) F1(0,-4.572) F2(0.914,-4.572) F3(1.829,-4.572) G1(0,-5.486) G2(0.914,-5.486) H1(0,-6.401) H2(0.914,-6.401) H3(1.829,-6.401) J1(0,-7.315) J2(0.914,-7.315) K1(0,-8.23) K2(0.914,-8.23) K3(1.829,-8.23) L1(0,-9.144) L2(0.914,-9.144) M1(0,-10.058) M2(0.914,-10.058) M3(1.829,-10.058) N1(0,-10.973) N2(0.914,-10.973) P1(0,-11.887) P2(0.914,-11.887) P3(1.829,-11.887) R1(0,-12.802) R2(0.914,-12.802) T1(0,-13.716) T2(0.914,-13.716) T3(1.829,-13.716) U1(0,-14.63) U2(0.914,-14.63) U3(1.829,-14.63) V1(0,-15.545) V2(0.914,-15.545) V3(1.829,-15.545) W1(0,-16.459) W2(0.914,-16.459) W3(1.829,-16.459) Y3(1.829,-17.374) Y4(2.743,-17.374)

# Allegro board Alienware Area-51M LA-G881P.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
ESPI_IO2: length 62.5
  TOP w0.089: v2(273.94,59.69) 274.12,59.51 UH1.AV37
  TOP w0.112: v2(282.83,23.98) 282.83,23.92 283.48,23.27 283.61,23.27 284.54,22.34 284.54,22.34 TC25.1 285.35,21.53 286.75,21.53 287.32,22.1 290.07,22.1 290.7,21.48 UE5.7
  BOTTOM w0.112: v2(273.94,59.69) 273.77,59.86 272.83,59.86 271.8,58.82 271.8,58.72 271.15,58.07 271.15,57.67 268.71,55.22 268.71,53.04 268.24,52.58 268.24,52.5 267.75,52 267.75,51.62 266.56,50.44 266.56,49.26 266.28,48.98 266.28,48.38 264.45,46.55 264.45,45.79 265.03,45.22 265.03,44.81 267.09,42.74 267.09,37.18 268.29,35.98 268.29,34.14 269.65,32.78 272.06,32.78 275.57,29.26 278.6,29.26 282.86,25.01 282.86,24.01 v2(282.83,23.98)
ESPI_IO3: length 62
  TOP w0.089: v2(275.59,61.33) 275.21,61.33 274.76,60.89 UH1.BA38
  TOP w0.112: TC26.1 289.43,22.92 v2(289.94,22.92) 289.99,22.92 290.63,22.28 UE5.5
  BOTTOM w0.112: v2(289.94,22.92) 289.98,22.96 289.98,23.85 288.84,25 288.26,25 284.04,29.21 284.04,30.27 282.99,31.31 276.75,31.31 272.5,35.57 272.5,38.39 269.34,41.55 269.34,44.08 269.44,44.18 269.44,46.35 268.88,46.91 267.72,46.91 267.49,47.14 267.49,47.52 267.78,47.81 268.22,47.81 268.63,48.22 268.63,48.66 268.76,48.79 269.14,48.79 269.47,49.12 269.47,49.82 270.14,50.48 270.14,53.69 272.44,55.99 274.1,55.99 274.47,56.36 274.81,56.36 275.32,56.87 275.32,57.07 275.32,57.73 276.01,58.43 276.01,59.11 275.89,59.23 275.89,60.75 275.59,61.05 v2(275.59,61.33)
ESPI_KB_RST#: length 73.5
  TOP w0.089: UH1.BE39 273.65,63 273.65,63.49 273.46,63.68 273.46,65.62 v2(274.03,66.19) 273.58,66.63 RH518.1
  TOP w0.112: RE646.1 288.09,25.87 284.23,25.87 v1(283.83,25.47) 283.49,25.47 v2(282.44,24.42)
  BOTTOM w0.112: v2(274.03,66.19) 273.67,66.19 272.2,64.72 272.2,64.32 273.63,62.89 273.63,61.32 274.05,60.9 274.05,60.35 273.8,60.1 272.73,60.1 272.28,59.64 271.55,59.64 270.92,59 270.92,57.77 268.47,55.32 268.47,53.27 268.01,52.8 268.01,52.62 267.42,52.03 267.42,51.63 266.33,50.53 266.33,49.63 265.3,48.6 265.3,47.74 264.21,46.65 264.21,45.7 264.79,45.12 264.79,44.71 266.85,42.64 266.85,37.08 268.05,35.88 268.05,34.04 269.55,32.54 271.96,32.54 275.48,29.03 278.5,29.03 282.44,25.08 v2(282.44,24.42)
ESPI_RST#: length 74.9
  TOP w0.089: UH1.BF38 274.27,63.6 273.84,64.03 273.84,64.63 v2(274.23,65.02)
  TOP w0.112: UE5.14 292.62,18.68 v2(292.95,19.01)
  BOTTOM w0.112: v2(292.95,19.01) 291.69,19.01 291.1,19.6 291.1,21.53 v1(291.08,21.55) 291.08,21.98 290.55,22.5 289.72,22.5 289.51,22.71 289.51,23.17 289.74,23.4 289.74,23.75 288.74,24.76 288.16,24.76 283.8,29.11 283.8,30.17 282.89,31.08 275.11,31.08 272.45,33.74 270.23,33.74 269.25,34.72 269.25,35.98 269.3,36.03 269.3,38.83 268.41,39.72 268.41,42.43 269.1,43.12 269.1,44.18 269.2,44.28 269.2,46.25 268.78,46.67 267.62,46.67 267.24,47.05 267.24,47.6 267.68,48.04 268.12,48.04 268.32,48.24 268.32,49.69 268.79,50.16 269.14,50.16 269.66,50.68 269.66,54.78 272.11,57.23 274.26,57.23 274.84,57.8 274.84,58.99 275.41,59.56 275.41,60.55 275.16,60.81 274.35,61.61 274.35,63.42 274.62,63.69 274.62,64.64 v2(274.23,65.02)
ESPI_SERIRQ: length 82.6
  TOP w0.089: v2(275,60.33) 275.52,60.33 UH1.AW35 275.88,59.97 276.75,59.97 276.86,59.87 277.27,59.87 277.36,59.96 277.36,60.35 277.02,60.69 277.02,60.98 277.21,61.17 277.21,61.49 277.01,61.69 277.01,62.22 276.9,62.33 276.9,63.65 277.09,63.84 277.09,64.44 276.88,64.65 276.88,65.75 277.71,66.59 277.71,68.6 276.47,69.84 276.47,71.17 276.51,71.21 276.51,71.44
  TOP w0.112: TC21.1 287.75,25.11 v2(288.7,24.15) 289.62,24.15 290.7,23.08 UE5.3 ; 276.51,71.44 276.51,73.1 276.31,73.3 274.09,73.3 RH111.1
  BOTTOM w0.112: v2(275,60.33) 275,59.49 274.57,59.06 274.57,58.43 274.19,58.05 273.9,58.05 273.47,57.62 272.16,57.62 269.42,54.88 269.42,51.41 269.22,51.2 268.35,51.2 267.28,50.14 267.28,48.96 267,48.68 267,46.95 267.52,46.43 268.68,46.43 268.96,46.15 268.96,44.38 268.86,44.28 268.86,43.22 268.17,42.53 268.17,39.62 269.06,38.73 269.06,36.13 269.01,36.08 269.01,34.62 270.13,33.5 272.35,33.5 275.02,30.84 282.79,30.84 283.56,30.07 283.56,29.01 288.42,24.15 v2(288.7,24.15)
FB_1.2V: length 14.3
  TOP w0.112: v2(212.67,115.14) v1(212.67,114.15)
  TOP w0.254: PR213.1 PR215.1 216.11,111.97 216.28,112.14 v2(216.43,112.14) ; PR207.1 214.11,114.54 216.83,114.54 217.61,115.33 PU201.6 ; PR207.1 PR205.1 ; PR207.1 v2(212.67,115.14)
  IN4 w0.254: v2(212.67,115.14) 212.67,114.27 214.8,112.14 v2(216.43,112.14)
FB_3V: length 2.6
  TOP w0.203: PU301.4 331.48,38.73 PR301.2 PR303.2
FB_5V: length 3.8
  TOP w0.112: PR302.1 332.12,36.04 v1(332.64,35.52)
  TOP w0.203: PU301.2 331.11,37.93 331.75,37.29 332.06,37.29 PR304.1 PR302.1
FB_+1VALWP: length 5.5
  TOP w0.112: v1(260.25,4.85) 260.58,5.18 PR108.1
  TOP w0.254: PU101.4 261.69,8.84 261.35,8.5 261.35,7.98 260.9,7.53 PR107.1 261.08,7.06 261.08,6.42 PR108.1
FB_VCCIO: length 4.8
  BOTTOM w0.254: PUF01.14 157.96,112.03 PRF07.2 159.07,112.33 PRF10.1 159.88,112.33 v1(160.3,111.91) 160.8,111.41 PCF11.2
FB_VCCSA: length 3.5
  BOTTOM w0.112: v1(129.57,121.05) 129.15,120.64 PRA07.1
  BOTTOM w0.254: PRA07.1 128.53,120.63 PRA08.2 128.92,119.48 PUA01.8
FCCM_GT: length 125.8
  TOP w0.112: 67.19,27.72 67.39,27.52 68.15,27.52 68.53,27.9 69.17,27.9 70.07,27 70.07,21.55 73.15,18.46 84.23,18.46 84.33,18.36 84.33,18.37 v2(84.34,18.37)
  TOP w0.203: PUZ01.11 66.76,28.16 66.83,28.09 66.83,28.09 67.19,27.73 67.19,27.72
  TOP w0.254: v2(151.49,12.53) 151.49,12.41 150.99,11.9 149.57,11.9 147.73,10.06 141.7,10.06 139.41,12.34 v1(134.71,12.34) 132.55,12.34 131.08,10.87 129.42,10.87 129.17,11.13 PRG05.1
  IN3 w0.104: v2(84.34,18.37) 84.73,18.77 85.09,18.77 85.23,18.63 100.42,18.63 101.04,18.01 107.75,18.01 108.59,17.17 108.59,16.64 109.37,15.86 109.86,15.86 110.38,15.34 110.66,15.34 112.44,13.56 118.65,13.56 119.04,13.56 119.65,12.95 123.91,12.95 124.18,12.68 130.97,12.68 131.14,12.51 142.05,12.51 142.49,12.06 145.48,12.06 146.78,13.36 150.67,13.36 v2(151.49,12.53)
  BOTTOM w0.254: v2(151.49,12.53) 151.49,12.47 150.73,11.71 149.62,11.71 149.37,11.96 PRG17.1
FCCM_VCORE: length 113.1
  TOP w0.203: PUZ01.24 68.3,33.82 68.85,34.36 69.29,34.36 69.5,34.57 69.5,35.45 69.31,35.64 69.31,36.15 v2(68.86,36.6)
  IN1 w0.254: v2(68.86,36.6) 69.24,36.6 70.49,37.85 75.13,37.85 75.14,37.86 79.91,37.86 80.9,38.86 81.28,38.86 85.56,43.14 85.56,44.09 86.51,45.04 89.88,45.04 99.85,55.01 v2(99.85,56.41) 100.04,56.6 101.97,56.6 102.95,57.58 103.94,57.58 104.27,57.91 v2(104.47,57.91) ; v2(102.36,50.15) 102.34,50.12 v2(99.85,50.12)
  BOTTOM w0.254: PRI56.1 104.95,57.91 v2(104.47,57.91) ; PRI111.1 v2(102.36,50.15) ; 99.85,31.9 99.85,41.62 100.29,42.06 ; 99.85,31.9 100.23,31.52 101.47,31.52 PRI15.1 ; 99.85,31.9 99.19,31.24 99.19,22.55 100.01,21.73 PRI31.1 ; PRI71.1 103.92,70.34 101.93,68.35 101.93,66.76 99.85,64.67 v2(99.85,56.41) v2(99.85,50.12) v1(99.85,49.43) 99.85,48.75 98.96,47.86 98.96,45.17 100.29,43.84 100.29,42.06 ; 100.29,42.06 100.29,42.02 100.88,41.44 PRI96.1
FFS_INT1: length 122.6
  TOP w0.089: UH1.BE18 283.77,62.94 283.51,63.19 283.51,63.5 283.36,63.65 283.36,63.87 v2(283.4,63.91)
  TOP w0.112: v2(223.5,20.6) v1(223.5,19.91)
  TOP w0.127: v2(284.04,73.2) 284.04,71.93 RP10.2
  IN2 w0.104: v2(284.04,73.2) 284.59,72.66 284.59,68.04 284.7,67.93 284.7,66.8 284.18,66.28 283.29,66.28 282.92,65.91 282.92,64.22 283.22,63.91 v2(283.4,63.91)
  IN4 w0.084: v2(284.04,73.2) 283.69,73.2 281.9,71.41 281.9,71.18 280.82,70.11 279.01,70.11 278.68,69.77 270.25,69.77 269.03,71 266.06,71 264.62,72.44 261.16,72.44 260.07,71.35 254.79,71.35 254.3,70.86 254.3,70 251.95,67.64 246.75,67.64 246.23,67.12 246.23,37.84 244.78,36.4 233.6,36.4 232.79,35.58 232.79,27.64 226.26,21.11 224.01,21.11 v2(223.5,20.6)
  BOTTOM w0.112: v2(223.5,20.6) 223.5,20.45 223.42,20.37 US1.11
FFS_INT2: length 158.4
  TOP w0.089: v2(283.41,64.5) 283.78,64.12 283.78,63.64 283.93,63.49 UH1.BF18
  TOP w0.112: v2(284.63,73.23) 284.6,73.2 RP9.2 ; QS3.3 253.28,16.63 v1(251.87,16.63) 229.09,16.63 v2(228.68,17.04)
  IN2 w0.104: v2(284.63,73.23) 284.82,73.03 284.82,68.13 284.93,68.03 284.93,66.7 284.28,66.05 283.39,66.05 283.15,65.81 283.15,64.76 v2(283.41,64.5)
  IN4 w0.084: v2(284.63,73.23) 284.25,73.61 283.79,73.61 281.69,71.5 281.69,71.27 280.73,70.32 278.93,70.32 278.59,69.98 270.39,69.98 269.16,71.21 266.15,71.21 264.71,72.65 263.16,72.65 261.07,72.65 259.98,71.56 254.7,71.56 254.09,70.95 254.09,70.09 251.86,67.85 246.66,67.85 246.02,67.21 246.02,37.93 244.69,36.61 233.52,36.61 232.58,35.67 232.58,27.72 226.17,21.32 223.04,21.32 222.37,20.65 v2(222.37,20.42)
  BOTTOM w0.112: US1.9 222.42,20.37 v2(222.37,20.42) 222.37,20.42 222.37,20.92 222.58,21.13 226.06,21.13 228.78,18.42 228.78,17.14 v2(228.68,17.04)
FFS_INT2_CONN: length 11.9
  TOP w0.112: v2(256.44,6.69) 256.28,6.86 RS1.2 ; v1(251.63,12.33) DS1.2 253.53,12.33 v2(254.25,13.05)
  BOTTOM w0.112: JHDD.12 256.55,6.58 v2(256.44,6.69) 256.44,7.32 254.85,8.91 254.85,12.45 v2(254.25,13.05)
FSEL_VCCSA: length 4.2
  BOTTOM w0.254: PUA01.11 131.04,117.71 131.29,117.96 131.29,118.57 130.97,118.9 v1(130.97,119.53) 131.72,119.53 PRA16.1 PRA14.2
FSET_CHG: length 2.1
  TOP w0.203: PR755.2 207.24,143.47 v1(207.24,143.11) PU703.12
FWPG_ISL95338_1: length 336.1
  TOP w0.112: v2(128.8,147.95) 129.4,147.95 v1(129.57,147.79) ; UE5.36 294.34,8.67 v2(294.47,8.53)
  TOP w0.254: PRS54.2 127.3,147.55 127.66,147.9 128.75,147.9 v2(128.8,147.95)
  IN1 w0.254: v2(128.8,147.95) 128.8,148.19 130.04,149.43 134.5,149.43 140.1,155.03 142.38,155.03 143.16,155.81 143.16,157.66 149.09,163.59 v2(149.09,163.82)
  IN2 w0.104: v2(149.09,163.82) 149.09,165.81 150.14,166.86 150.14,168.91 153.37,172.14 158.56,172.14 158.99,171.71 158.99,166.87 158.35,166.23 158.35,159.92 160.7,157.58 160.7,147.8 168.49,140.01 168.49,126.02 180.24,114.27 180.24,112.89 184.26,108.88 184.53,108.6 184.53,104.67 188.86,100.34 194.98,100.34 195.48,99.84 197.75,99.84 198.47,100.57 210.87,100.57 211.85,99.59 236.37,99.59 236.87,99.09 253.22,99.09 253.8,98.51 258.12,98.51 261.35,95.28 261.35,90.6 261.52,90.42 261.52,89.79 261.05,89.32 261.05,85.67 v2(262.28,84.44)
  BOTTOM w0.112: v2(262.28,84.44) 262.11,84.62 261.5,84.62 260.43,83.55 260.43,74.02 260.28,73.87 260.28,71.55 259.79,71.06 259.79,68.19 258.91,67.31 258.91,64.53 258.01,63.64 258.01,57.42 257.47,56.88 257.47,54 259.41,52.06 259.41,49.57 258.79,48.94 258.79,38.38 261.38,35.79 261.38,33.61 267.32,27.67 269.16,27.67 276.25,20.59 276.25,15.64 277.02,13.78 279.76,11.03 279.76,8.27 281.36,6.67 281.36,5.78 283.79,3.35 292.07,3.35 294.05,5.33 294.05,6.68 294.89,7.51 294.89,8.29 294.65,8.53 v2(294.47,8.53)
  BOTTOM w0.203: v2(128.8,147.95) 127.8,147.95 127.59,147.75 PUS1.24
  BOTTOM w0.254: PQ6.5 150.79,161.95 150.51,162.23 150.51,163.22 150.16,163.57 149.33,163.57 v2(149.09,163.82) ; PRS53.1 128.8,148.44 v2(128.8,147.95)
FWPG_ISL95338_2: length 371.1
  TOP w0.112: v2(306.82,10.89) 306.15,10.89 305.48,11.57 305.48,12.13 298.08,19.52 298.08,21.55 298.78,22.25 302.24,22.25 303.33,21.16 304.35,21.16 305.53,22.34 305.85,22.34 306.31,21.88 UE5.91 ; v2(150.6,145.41) 151.7,145.41 v3(152.37,144.74)
  TOP w0.254: PRS56.2 149.79,144.66 150.54,145.41 v2(150.6,145.41)
  IN2 w0.104: v2(261.87,90.7) 261.87,95.09 258.22,98.74 253.9,98.74 253.31,99.32 236.97,99.32 236.47,99.82 211.94,99.82 210.96,100.8 198.38,100.8 197.65,100.08 195.58,100.08 195.08,100.57 188.95,100.57 184.76,104.76 184.76,108.7 184.49,108.97 180.47,112.99 180.47,114.36 168.72,126.11 168.72,140.1 160.93,147.9 160.93,157.67 158.58,160.02 158.58,166.14 159.22,166.78 159.22,171.8 158.66,172.37 153.27,172.37 149.91,169 149.91,166.96 146.83,163.88 v2(146.83,163.75)
  IN4 w0.254: v2(150.6,145.41) 150.6,147.15 152.43,148.98 152.43,153.57 146.83,159.17 v2(146.83,163.75)
  BOTTOM w0.112: v2(306.82,10.89) 306.82,8.02 305.77,6.97 303.61,6.97 302.49,5.85 296.61,5.85 292.48,1.73 283.39,1.73 279.55,5.57 279.55,6.46 277.02,8.99 277.02,9.08 275.61,10.48 275.61,12.8 274.58,15.31 274.58,18.84 272.05,21.36 267.33,21.36 264.81,23.88 264.81,27.81 259.59,33.04 259.59,35.18 257.12,37.65 257.12,49.67 257.73,50.27 257.73,51.39 255.73,53.38 255.73,81.69 259.15,85.11 259.15,89.24 260.61,90.7 v2(261.87,90.7)
  BOTTOM w0.203: PUS2.24 149.97,145.2 150.14,145.37 150.56,145.37 v2(150.6,145.41) 150.66,145.47 PRS55.1
  BOTTOM w0.254: v2(146.83,163.75) 147.55,164.48 PQ10.5
GC6_EVENT#: length 176.5
  TOP w0.089: UH1.BB26 279.78,61.81 v2(279.47,61.81)
  TOP w0.112: v2(183.35,145.44) v1(183.35,146.1)
  IN2 w0.104: v2(279.47,61.81) 279.7,61.81 279.82,61.92 279.82,67.51 279.71,67.62 279.71,69.09 281.7,71.07 281.7,71.6 281.2,72.11 281.2,75.33 281.46,75.6 281.46,77.24 280.86,77.83 280.86,79.01 278.62,81.25 278.62,85.01 275.81,87.82 275.81,97.3 268.51,104.6 251.06,104.6 250.46,105.2 238.66,105.2 238.16,105.71 222.03,105.71 221.74,106 214.1,106 213.9,106.2 196.7,106.2 193,109.9 193,116.04 188.77,120.26 188.77,125.54 184.7,129.61 184.7,133.67 183.56,134.8 183.56,142.98 182.93,143.61 182.93,145.02 v2(183.35,145.44)
  BOTTOM w0.112: v2(183.35,145.44) 182.59,145.44 181.11,143.95 180.19,143.95 178.45,145.69 177.63,145.69 177.27,145.33 JDGFF2.D2
GC6_FB_EN: length 177.4
  TOP w0.089: UH1.BF29 278.67,63.88 278.62,63.92 278.62,66.65 278.42,66.84 278.42,69.6 v1(278.33,69.7) 278.14,69.89 278.14,70.68 278.05,70.77 278.05,71.19 278.3,71.44 ; v2(278.52,71.66) 278.35,71.5
  TOP w0.112: 278.35,71.5 278.3,71.44
  IN2 w0.104: v2(180.36,144.52) 181.36,144.52 183.1,142.79 183.1,134.61 184.24,133.48 184.24,129.42 188.31,125.35 188.31,120.07 192.54,115.85 192.54,109.71 197.34,104.91 205.99,104.91 206.81,105.74 213.52,105.74 213.71,105.74 213.91,105.54 214.29,105.54 214.29,105.54 221.55,105.54 221.84,105.24 237.97,105.24 238.47,104.74 250.27,104.74 250.87,104.14 268.32,104.14 275.13,97.33 275.13,86.74 276.21,85.65 276.21,83.01 279.36,79.86 279.36,74.07 279.17,73.88 279.17,72.32 v2(278.52,71.66)
  IN3 w0.104: v2(180.36,144.52) 180.36,143.91 178.01,141.55 172.59,141.55 171.91,142.23 171.91,142.47 v2(172.47,143.03)
  BOTTOM w0.112: JDGFF2.C10 v2(172.47,143.03)
GPD_7: length 7.4
  TOP w0.089: UH1.BE41 272.75,63 272.99,63.24 272.99,63.6 273.27,63.87 273.27,65.69 273,65.95 v1(273,66.16) 273.27,66.43 273.27,68.24 272.77,68.73 RH11.1 RH594.2
GPIO8: length 4.9
  TOP w0.112: RT124.2 v1(41.47,48.58) 41.87,48.98 42.08,48.98 42.55,49.45 RT125.1
  TOP w0.127: v2(44.05,48.59) 43.14,49.49 RT125.1
  BOTTOM w0.076: v2(44.05,48.59) 44.05,48.32 UT4.H6
GPP_H12: length 5.3
  TOP w0.089: UH1.AB47 269.61,51.8 269.22,51.8 268.92,52.09 268.33,52.09 266.66,50.43 266.63,50.43 RH100.2 v1(266.47,49.3)
GPP_H15: length 4.8
  TOP w0.089: RH99.1 v1(266.45,52.06) 268.03,52.06 268.25,52.28 269,52.28 269.3,51.99 269.57,51.99 269.64,52.06 UH1.AC47
GPP_J9: length 2.5
  TOP w0.089: UH1.AU9 v2(288.45,59.72)
  BOTTOM w0.112: v2(288.45,59.72) 288.05,59.32 RH218.1 287,58.51 v1(286.99,58.51)
GPPJ_RCOMP_1P8: length 8.5
  TOP w0.112: RH216.1 296.52,67.74 v1(297.02,68.23)
  TOP w0.254: UH1.BD1 UH1.BE1 ; UH1.BE1 292.17,63.21 UH1.BE2 ; UH1.BE1 292.39,63.21 292.95,63.77 292.95,64.57 294.25,65.88 294.25,66.21 295.08,67.03 295.3,67.03 RH216.1
GPU_FAN_FB: length 120.4
  TOP w0.112: v2(376.48,45.59) v1(377.07,45.59) ; v2(294.39,12.57) 294.17,12.35 292.77,12.35 292.45,12.68 UE5.29
  IN3 w0.104: v2(376.48,45.59) 375.79,44.91 375.79,39.14 378.18,36.75 378.18,18.29 376.3,16.41 367.24,16.41 367.01,16.63 365.51,16.63 365.25,16.38 358.14,16.38 353.3,11.54 344.93,11.54 344.21,10.82 317.88,10.82 317.16,11.54 306.77,11.54 305.49,12.82 301.68,12.82 301.5,13 294.82,13 v2(294.39,12.57)
GPU_FAN_PWM: length 129.3
  TOP w0.112: v2(375.13,49.73) v3(375.75,49.73) ; UE5.27 292.5,13.48 v2(293.21,12.77)
  IN3 w0.104: v2(375.13,49.73) 375.56,49.3 375.56,39.04 377.95,36.66 377.95,18.38 376.21,16.64 367.33,16.64 367.11,16.87 365.41,16.87 365.16,16.61 358.04,16.61 353.2,11.77 344.83,11.77 344.11,11.05 317.97,11.05 317.25,11.77 308.67,11.77 307.39,13.05 301.78,13.05 301.59,13.23 293.68,13.23 v2(293.21,12.77)
  BOTTOM w0.112: RF5.1 374.95,49.55 v2(375.13,49.73) 375.34,49.93 376.15,49.93 377.7,51.49 JFAN2.3
GPU_OVERT#: length 298.5
  TOP w0.112: UE5.85 306.05,19.48 v2(305.9,19.33)
  IN2 w0.104: v2(179.98,126.2) 179.98,120.4 188.77,111.62 188.77,108.97 v2(191.8,105.94)
  BOTTOM w0.112: JDGFF1.F1 179.56,133.16 179.75,132.97 179.75,126.43 v2(179.98,126.2) ; v2(305.9,19.33) 306.7,19.33 309.85,16.19 309.85,14.55 311.05,13.34 312.73,13.34 313.77,12.3 313.77,7.83 312.42,6.48 311.54,6.48 308.58,3.52 308.58,3.18 308.26,2.87 307.51,2.87 306.29,4.09 v1(303.5,4.09) 298.03,4.09 296.13,2.18 293.78,2.18 293.09,1.49 283.24,1.49 279.29,5.44 279.29,6.38 276.78,8.89 276.78,8.98 275.04,10.72 275.04,12.99 274.55,14.15 274.2,14.5 269.65,14.5 267.62,12.47 267.62,7.33 262.22,1.93 242.92,1.93 241.3,3.55 206.19,3.55 187.74,21.99 187.74,102.19 184.81,105.12 184.81,106.2 185.32,106.7 191.04,106.7 v2(191.8,105.94)
GPU_STRAP5_EC: length 260.3
  TOP w0.112: v2(248.79,12.02) 248.79,13.26 RE689.2 ; v2(294.03,14.5) 294.57,13.97 299.77,13.97 301.14,12.6 UE5.53
  IN2 w0.104: v2(171.54,133.32) 171.54,133.11 170.11,131.67 170.11,126.69 181.86,114.94 181.86,113.72 186.29,109.28 186.29,106.73 187.04,105.98 v2(187.04,104.61)
  IN3 w0.104: v2(294.03,14.5) 293.56,14.98 292.48,14.98 292.07,14.57 287.69,14.57 281.99,20.26 268.91,20.26 263.28,14.63 263.28,13.73 260.78,11.22 257.87,11.22 256.94,12.15 253.63,12.15 252.87,11.39 249.83,11.39 249.2,12.02 v2(248.79,12.02)
  BOTTOM w0.112: v2(171.54,133.32) 171.78,133.56 172.3,133.56 172.47,133.4 JDGFF1.F10 ; v2(248.79,12.02) 248.62,11.85 247.87,11.85 246.55,10.53 246.55,9.97 246.85,9.68 246.85,8.85 246.09,8.09 246.09,5.64 244.23,3.78 206.29,3.78 187.98,22.09 187.98,102.97 v1(187.29,103.66) 187.04,103.91 v2(187.04,104.61)
GSYNC_ID: length 3.8
  TOP w0.089: RH30.1 275.12,67.13 274.98,67.27 274.98,67.99 RH29.1 276.29,68.37 276.89,67.78 v1(277.21,67.78)
GT_V1N: length 32.5
  TOP w0.254: v2(162.01,19.66) 161.49,19.14 160.18,19.14 158.93,20.38 147.71,20.38 146.82,21.28 143.48,21.28 142.98,21.78 140.16,21.78 v2(140.04,21.89)
  BOTTOM w0.254: v2(162.01,19.66) 161.82,19.47 v1(161.82,19.2) 161.82,18.76 161.44,18.38 PRG23.1 ; PLG01.3 135.81,20.69 136.07,20.43 139.13,20.43 PRG11.2 140.04,21.35 v2(140.04,21.89)
GT_V1P: length 10.1
  BOTTOM w0.254: PRG09.1 140.61,15.97 PRG08.2 139.03,17.56 139.03,19.58 138.56,20.05 136.07,20.05 135.81,19.8 PLG01.2
GT_V2N: length 43.3
  IN4 w0.254: v2(162.78,17.3) 162.78,12.22 162.09,11.53 149.88,11.53 149,12.41 146.4,12.41 145.57,13.23 142.33,13.23 141.95,13.61 141.95,15.25 v2(141.93,15.26)
  BOTTOM w0.254: PRG12.1 v2(141.93,15.26) ; v2(162.78,17.3) v1(162.78,18.06) 162.78,20.03 161.13,21.68 PRG22.2 157.69,20.44 154.95,20.44 154.7,20.69 PLG02.3
GT_V2P: length 7.9
  BOTTOM w0.254: PRG21.1 159.19,18.38 PRG20.2 157.51,20.06 154.95,20.06 154.7,19.8 PLG02.2
GYRO_ADD: length 2.8
  TOP w0.112: US2.1 111.27,172.5 111.09,172.68 111.09,173.06 111.38,173.35 RS10.1 111.38,174.17 v1(110.9,174.65)
GYRO_INT2: length 1
  TOP w0.112: RH1015.1 114.35,171.52 114.33,171.5 US2.9
H_CATERR#: length 22.9
  BOTTOM w0.102: UC1.D13 133.32,71.66 133.76,72.1 134.26,72.1 134.58,72.41 134.58,73.62 134.17,74.03 131.12,74.03 130.01,75.15 130.01,75.17 129.99,75.19
  BOTTOM w0.112: 129.99,75.19 129.03,76.15 129.03,80.59 125.46,84.16 125.46,85.19 125.35,85.3 RC693.2
H_CPU_SVIDALRT#: length 28.5
  TOP w0.112: RC19.2 136.69,26.83 135.53,25.68 v1(133.19,25.68) v2(131.66,25.68)
  IN1 w0.084: 133.63,35.05 132.71,34.14 v2(132.71,32.08)
  IN1 w0.133: 133.63,35.05 135.1,36.52 135.1,43.2 134.16,44.13 134.16,44.46 134.6,44.9 v2(134.6,45.25)
  BOTTOM w0.102: UC1.E39 v2(134.6,45.25)
  BOTTOM w0.112: v2(132.71,32.08) 132.16,32.08 131.34,31.27 131.34,29.17 131.66,28.85 v2(131.66,25.68)
H_CPUPWRGD: length 238.3
  TOP w0.089: UH1.AE3 291.37,53.45 291.44,53.52 291.78,53.52 291.88,53.42 294.18,53.42 294.36,53.24 296.02,53.24 v2(296.19,53.06)
  TOP w0.102: v2(134.51,75.7) 134.02,75.22 133.21,75.22 132.98,75.44 129.82,75.44
  TOP w0.112: 129.82,75.44 128.89,75.44 v3(127.02,77.32) 125.69,78.64 125.69,82.05 125.58,82.16 121.16,82.16 CC4.1
  IN4 w0.084: v2(296.19,53.06) 295.66,53.6 295.66,55.91 295.43,56.13 295.43,58.84 294.57,59.7 294.57,64.03 294.09,64.5 294.09,67.62 293.09,68.62 293.09,69.19 291.82,70.46 291.82,73.65 291.23,74.25 290.09,74.25 282.78,81.55 281.59,81.55 280.25,82.89 278.89,82.89 272.76,89.01 272.76,92.69 268.4,97.05 260.63,97.05 258.72,98.96 247.3,98.96 246.83,99.43 229.84,99.43 229.25,98.84 210.63,98.84 209.96,99.51 204.3,99.51 203.64,98.86 186.24,98.86 185.59,99.51 181.47,99.51 179.92,97.97 165.16,97.97 163.15,95.96 157.76,95.96 152.23,90.44 135.65,90.44 133.82,88.61 133.82,84.99
  IN4 w0.102: v2(134.51,75.7) 134.59,75.7 134.97,76.07 134.97,81.93 133.82,83.08 133.82,84.99
  BOTTOM w0.102: v2(134.51,75.7) UC1.F8
H_DRAMRST#: length 24.6
  TOP w0.089: UH1.BB46 269.42,61.88 269.33,61.8 269.06,61.8 268.98,61.71 268.18,61.71 268.11,61.78 v2(267.9,61.78)
  TOP w0.112: v2(255.03,53.74) 254.66,53.36 RD52.2 254.09,52.92 254.18,52.83 CD125.1 253.38,52.53 RD62.2 253.29,52.61 RD51.2
  IN3 w0.104: v2(255.03,53.74) 259.24,57.94 259.24,59.84 259.55,60.16 260.63,60.16 260.87,60.4 260.87,62.23 261.12,62.47 261.16,62.47 261.17,62.48 261.58,62.48 261.59,62.47 262.28,61.77 267.89,61.77 v2(267.9,61.78)
H_PECI: length 228
  TOP w0.089: v2(297.77,55.21) 297.78,55.21 v1(297.78,54.19) 297.22,53.62 294.52,53.62 294.34,53.8 292.06,53.8 291.91,53.95 UH1.AF2
  IN4 w0.084: v2(297.77,55.21) 297.78,55.21 297.78,55.46 298.29,55.97 298.29,67.78 294.01,72.05 294.01,74.56 282.48,86.09 278.78,86.09 275.94,88.93 275.94,92.63 269.33,99.24 266.29,99.24 265.45,100.09 260.69,100.09 259.63,101.14 248.39,101.14 247.91,101.62 228.94,101.62 228.34,101.03 211.54,101.03 210.84,101.73 199.04,101.73 198.57,101.25 196.2,101.25 195.73,101.73 183.9,101.73 179.37,106.26 175.32,106.26 170.09,101.03 168.28,101.03 167.42,100.17 164.24,100.17 162.26,98.19 156.89,98.19 151.34,92.64 133.66,92.64 126.51,85.49 126.32,85.49 v2(126.27,85.45)
  BOTTOM w0.112: RC11.2 121.79,87.88 122.14,88.23 124.63,88.23 126.27,86.59 v2(126.27,85.45)
H_PM_DOWN: length 237.6
  TOP w0.089: 297.89,52.6 295.9,52.6 295.45,53.05 294.28,53.05 294.1,53.23 291.79,53.23 291.73,53.29 UH1.AE2
  TOP w0.112: 297.89,52.6 298.06,52.6 v1(298.43,52.97) 298.74,53.28 v2(298.98,53.28) 299.34,53.28 RH14.1 ; RC5.2 119.3,84.88 v2(119.15,84.73)
  IN4 w0.084: v2(298.98,53.28) 298.98,52.73 299.96,51.75 301.36,51.75 301.6,51.99 301.6,53.2 299.07,55.74 299.07,68.1 294.79,72.38 294.79,74.88 269.65,100.02 266.62,100.02 264.71,101.92 248.76,101.92 248.19,102.49 228.7,102.49 228.02,101.81 211.86,101.81 211.17,102.5 184.23,102.5 179.69,107.04 175,107.04 169.77,101.81 164.78,101.81 161.94,98.97 156.57,98.97 151.02,93.42 132.74,93.42 126.19,86.87 123.65,86.87 122.19,85.4 121.1,85.4 120.72,85.02 119.44,85.02 v2(119.15,84.73)
H_PM_SYNC: length 9
  TOP w0.089: UH1.AF3 291.46,53.71 291.87,53.71 291.97,53.61 294.26,53.61 294.44,53.43 296.63,53.43 v1(296.89,53.17) 297.89,53.17
  TOP w0.112: RH15.1 298.59,53.72 298.04,53.17 297.89,53.17
H_PM_SYNC_R: length 238
  TOP w0.102: v2(134.58,76.6) 134.02,76.05 132.72,76.05 132.53,75.86 v1(130.39,75.86) 129.82,75.86
  TOP w0.112: CC3.1 121.65,82.57 125.83,82.57 126.11,82.3 126.11,78.82 129.06,75.86 129.82,75.86 ; RH15.2 300.61,54.15 300.46,54.3 299.39,54.3 v2(299.35,54.34)
  IN4 w0.084: 133.25,84.99 133.25,88.68 135.39,90.83 152.07,90.83 157.6,96.35 162.99,96.35 165,98.36 179.75,98.36 181.3,99.9 192.62,99.9 193.28,99.24 203.48,99.24 204.14,99.9 210.12,99.9 210.8,99.23 229.09,99.23 229.67,99.82 247.02,99.82 247.49,99.35 258.88,99.35 260.79,97.44 268.56,97.44 273.58,92.42 273.58,88.74 278.57,83.76 279.98,83.76 281.12,82.62 281.8,81.94 282.94,81.94 287.76,77.12 288.9,77.12 292.21,73.81 292.21,70.62 293.48,69.35 293.48,68.79 294.48,67.78 294.48,64.98 295.22,64.24 295.22,63.19 295.53,62.88 295.53,60.58 295.36,60.41 295.36,59.46 295.82,59 295.82,56.3 296.04,56.07 296.04,54.15 296.64,53.55 298.56,53.55 v2(299.35,54.34)
  IN4 w0.102: 133.25,84.99 133.25,82.89 134.12,82.01 134.12,77.06 v2(134.58,76.6)
  BOTTOM w0.102: v2(134.58,76.6) 134.49,76.6 UC1.E8
H_PROCHOT#: length 627
  TOP w0.112: v2(305.79,31.74) 305.79,31.54 305.68,31.43 QE2.1 ; PRZ02.1 57.98,29.04 PCZ02.1 57.81,28.87 57.81,28.54 v2(57.65,28.38) 57.49,28.54 56.12,28.54 54.68,27.09 54.68,21.09 55.51,20.25 56.7,20.25 57.98,18.97 59.72,18.97 60.28,18.41 67.05,18.41 69.16,16.3 v1(74.83,16.3) 76.9,16.3 77.52,15.69 PQ7.1 ; v2(135.41,29.26) RC3.2 RC4.1 ; PR777.1 v2(213.97,139.28)
  IN1 w0.084: v2(55.84,47.58) 56.07,47.35 56.19,47.35 59.44,50.6 82.74,50.6 96.15,64.01 97.58,64.01 102.3,68.74 102.3,77.69 102.35,77.75 102.35,77.75 108.15,83.55 108.15,90.44 108.38,90.66 110.57,92.85 118.8,92.85 119.24,92.41 123.16,92.41 123.6,92.85 131.08,92.85 142.27,104.04 142.27,107.03 144.42,109.18 146.48,109.18 148.29,110.99 148.29,119.74 150.66,122.11 154.72,122.11 159.87,127.26 159.87,133.96 162.44,136.53 162.44,141.92 159.18,145.18 157.63,145.18 152.49,150.33 152.49,163.04 151.94,163.59 v2(151.94,163.59)
  IN3 w0.104: v2(135.41,29.26) 134.14,29.26 130.48,25.61 126.55,25.61 126.12,25.18 112.63,25.18 110.2,22.76 102.11,22.76 101.47,22.12 94.79,22.12 93.56,23.35 89.04,23.35 87.81,22.12 86.22,22.12 85.79,22.55 80.36,22.55 76.32,18.52 69.74,18.52 67.6,20.66 63.29,20.66 61.76,22.18 60.72,22.18 57.45,25.45 57.45,28.18 v2(57.65,28.38) 57.81,28.54 57.81,32.35 56.07,34.09 56.07,47.35 v2(55.84,47.58)
  IN4 w0.084: v2(305.79,31.74) 305.71,31.82 305.71,32.64 308.06,34.99 308.06,36.79 312.67,41.39 312.67,43.24 309.9,46 309.21,46 307.13,48.07 307.13,58.37 304.39,61.11 304.39,69.9 303.38,70.91 303.38,71.15 299.57,74.96 299.57,76.87 268.5,107.95 256.63,107.95 254.54,110.04 238,110.04 237.08,109.12 228.63,109.12 226.52,111.23 215.34,111.23 215.08,111.5 212.57,111.5 210.31,113.76 210.31,124.71 209.36,125.65 209.36,133.44 210.69,134.77 210.69,136.59 211.79,137.69 212.38,137.69 v2(213.97,139.28) 213.97,141.85 212.09,143.73 212.09,146.66 211.46,147.29 210.03,147.29 207.42,149.9 207.42,159.6 205.2,161.82 191.74,161.82 191.07,161.16 189.83,161.16 188.72,160.05 v2(188.72,159.42)
  BOTTOM w0.112: v2(188.72,159.42) 188.72,157.92 187.61,156.81 181.3,156.81 180.75,157.36 180.75,157.96 180.06,158.65 177.65,158.65 174.86,161.44 173.64,161.44 171.72,163.37 167.85,163.37 165.63,165.59 162.53,165.59 161.41,164.47 158.17,164.47 155.82,162.13 152.47,162.13 PR27.1 v2(151.94,163.59) 151.28,164.25 150.29,164.25 150.18,164.36 PR42.1
H_PROCHOT#_R: length 16.3
  TOP w0.112: v2(134.78,31.47) 134.78,31.46 134.72,31.4 RC4.2
  BOTTOM w0.102: UC1.C39 132.71,45.19 132.71,43.74 135.31,41.14 135.31,38.5
  BOTTOM w0.112: 135.31,38.5 135.31,33.97 134.78,33.43 v2(134.78,31.47)
H_THERMTRIP#: length 224
  TOP w0.112: RH79.2 301,52.14 v2(301.21,52.35)
  IN4 w0.084: v2(124.93,84.79) 124.93,85.59 125.82,86.48 126.37,86.48 132.92,93.03 151.18,93.03 156.73,98.58 162.1,98.58 164.94,101.42 169.93,101.42 175.16,106.65 179.53,106.65 184.07,102.12 211.01,102.12 211.7,101.42 228.18,101.42 228.78,102.01 248.07,102.01 248.55,101.53 259.79,101.53 260.85,100.48 265.61,100.48 266.45,99.63 269.49,99.63 294.4,74.72 294.4,72.21 298.68,67.94 298.68,55.58 300.8,53.46 300.8,52.76 v2(301.21,52.35)
  BOTTOM w0.112: RC2.2 R395.1 121.53,83.64 122,84.1 124.25,84.1 v2(124.93,84.79)
H_THERMTRIP#_R: length 9.9
  TOP w0.089: 297.89,52.17 297.71,52.35 295.88,52.35 295.37,52.86 294.2,52.86 294.02,53.04 291.72,53.04 291.43,52.75 UH1.AD3
  TOP w0.112: v1(299.69,51.09) RH79.1 299.66,52.17 297.89,52.17
H_VCCST_PWRGD: length 253.3
  TOP w0.112: v2(296,23.75) 295.14,24.62 UE5.123 ; v2(141.88,99.16) v1(141.88,98.68)
  IN3 w0.104: v2(300.07,24.15) 299.42,24.15 299.18,24.38 296.63,24.38 v2(296,23.75)
  IN4 w0.084: v2(300.07,24.15) 300.31,24.39 300.31,26.63 300.31,28.86 298.86,30.31 298.86,31.96 299.37,32.48 299.37,40.13 304.81,45.57 304.81,56.99 302.26,59.54 302.26,68.91 297.44,73.72 297.44,75.98 267.67,105.75 249.58,105.75 248.96,106.38 227.57,106.38 225.49,108.46 219.76,108.46 218.32,107.02 215.29,107.02 214.69,107.62 202.74,107.62 202.15,107.02 195.35,107.02 194.78,107.59 185.23,107.59 181.3,111.52 173.51,111.52 169.73,107.74 167.9,107.74 164.63,104.47 163.68,104.47 160.84,101.62 151.47,101.62 150.92,102.18 145.68,102.18 142.66,99.16 v2(141.88,99.16)
  BOTTOM w0.112: v2(296,23.75) 296,23.61 294.93,22.54 Q7.3 ; RC12.2 RC13.1 140.54,104.98 141.12,105.56 141.46,105.56 142.2,104.82 142.2,102.53 141.88,102.21 v2(141.88,99.16)
HDA_BIT_CLK: length 7
  TOP w0.089: RT707.2 290.45,67.27 288.61,65.43 287.88,65.43 287.38,64.93 287.38,63.25 287.55,63.07 287.55,62.69 287.22,62.35 UH1.BD11
HDA_BIT_CLK_R: length 327.9
  TOP w0.089: RT707.1 290.96,66.72 290.39,66.72 288.62,64.95 v2(288.54,64.95)
  TOP w0.112: CH243.1 291.51,67.77 RT707.1
  IN3 w0.104: v2(33.03,17.61) 33.73,18.31 35.43,18.31 37.52,20.39 40.89,20.39 41.54,21.04 41.54,21.66 42.29,22.41 49.18,22.41 51.07,20.52 53.92,20.52 54.86,19.58 57.1,19.58 58.78,17.9 65.81,17.9 69.42,14.3 79.54,14.3 84.36,19.13 85.24,19.13 85.38,18.99 100.7,18.99 101.32,18.37 107.89,18.37 108.94,17.32 108.94,16.79 109.52,16.22 110.01,16.22 110.53,15.7 110.81,15.7 112.58,13.92 118.51,13.92 118.51,13.92 119.19,13.92 119.19,13.92 119.8,13.31 124.06,13.31 124.33,13.04 131.59,13.04 132.06,13.51 133.1,13.51 133.39,13.21 145.24,13.21 146.46,14.43 151.81,14.43 155.25,17.86 178.21,17.86 181.49,14.59 184.32,14.59 186.92,17.19 219.53,17.19 219.85,16.86 226.25,16.86 227.48,18.1 235.56,18.1 237.77,20.3 257.26,20.3 266.06,29.1 284.13,29.1 284.49,29.46 287.59,29.46 288.46,28.59 v2(288.7,28.59)
  IN4 w0.084: v2(288.7,28.59) 288.7,28.65 288.37,28.99 288.37,42.07 287.36,43.08 287.36,47.46 286.32,48.5 286.32,52.16 286.33,52.17 286.33,52.36 286.82,52.85 286.82,53.87 285.39,55.29 285.39,56.73 285.71,57.05 286.41,57.05 286.73,57.36 286.73,58.19 287.11,58.57 287.11,61.05 287.47,61.41 287.47,64.83 287.7,65.06 288.43,65.06 v2(288.54,64.95)
  BOTTOM w0.112: v2(33.03,17.61) 30.95,17.61 29.06,15.71 JAUDIO.28
HDA_RST#: length 5.9
  TOP w0.089: RP7.2 288.13,68.27 v2(287.73,67.87) ; UH1.BE10 287.99,62.99 v2(287.99,64.67)
  IN1 w0.084: v2(287.73,67.87) 287.91,67.69 287.91,64.74 v2(287.99,64.67)
HDA_SDIN: length 328.1
  TOP w0.089: UH1.BE11 287.17,63 287.17,64.99 287.77,65.59 288.16,65.98 v2(288.42,65.98)
  IN3 w0.104: v2(288.9,29.14) 288.41,29.14 287.38,30.17 281.28,30.17 280.59,29.49 265.94,29.49 257.4,20.95 231.01,20.95 228.66,18.6 226.78,18.6 225.51,17.33 219.94,17.33 219.58,17.7 186.92,17.7 184.17,14.95 181.63,14.95 178.36,18.22 155.1,18.22 151.67,14.79 146.31,14.79 145.09,13.57 133.93,13.57 133.38,14.12 127.09,14.12 126.49,13.52 124.36,13.52 124.21,13.66 119.95,13.66 119.34,14.28 119.33,14.28 112.73,14.28 110.86,16.15 110.83,16.15 109.94,17.04 109.94,17.36 109.68,17.62 109.15,17.62 108.04,18.73 101.78,18.73 101.16,19.35 85.58,19.35 85.44,19.49 84.51,19.49 84.01,19.49 79.18,14.66 69.74,14.66 68.68,15.72 68.66,15.72 66.09,18.29 58.93,18.29 57.25,19.96 55.02,19.96 54,20.98 51.15,20.98 49.36,22.77 42.14,22.77 41.18,21.8 41.18,21.21 40.74,20.78 36.91,20.78 v2(36.09,19.96)
  IN4 w0.084: v2(288.42,65.98) 289.11,65.98 289.28,65.81 289.28,65.12 288.45,64.28 288.45,63.14 287.86,62.55 287.86,62.22 288.31,61.77 288.31,61.22 288,60.9 288,59.61 288.28,59.32 289.28,59.32 289.88,58.72 289.88,57.72 289.85,57.7 289.85,56.52 290.04,56.34 290.04,55.8 290.27,55.57 290.27,54.6 291.01,53.87 291.01,49.63 292,48.64 292,41.51 290.39,39.9 290.39,30.04 289.5,29.14 v2(288.9,29.14)
  BOTTOM w0.112: JAUDIO.24 31.06,15.85 31.21,16.01 31.21,16.91 31.47,17.17 33.35,17.17 33.62,17.44 33.62,18.12 33.81,18.31 34.44,18.31 v2(36.09,19.96)
HDA_SDOUT: length 7.1
  TOP w0.112: RP2.2 289.86,68.21 RH16.2 289.86,67.42 288.82,66.37 287.67,66.37 v1(287.11,65.81) 287.11,65.49 286.86,65.24 286.86,63.72 286.8,63.67 UH1.BF12
HDA_SDOUT_R: length 335
  TOP w0.112: v2(288,72.12) 288.27,72.12 289.52,70.87 RP2.1
  IN3 w0.104: v2(290.67,27.27) 288.82,27.27 287.22,28.87 284.73,28.87 284.37,28.51 266.87,28.51 258.07,19.71 238.16,19.71 235.96,17.51 227.73,17.51 225.88,15.66 188.34,15.66 186.51,13.83 181.09,13.83 180.23,14.69 157.61,14.69 154.22,11.3 142.27,11.3 141.82,11.75 130.91,11.75 130.68,11.98 123.9,11.98 123.63,12.25 119.36,12.25 118.75,12.87 112.15,12.87 110.48,14.54 109.14,14.54 107.03,14.54 106.24,15.34 99.45,15.34 96.85,17.94 89.44,17.94 87.64,16.13 82.53,16.13 80.09,13.69 68.3,13.69 65.61,16.38 55.4,16.38 54.99,15.97 50.49,15.97 49.22,17.24 49.22,18.74 47.06,20.9 42.79,20.9 40.93,19.05 38.79,19.05 38.35,18.62 37.39,18.62 33.12,14.35 31.39,14.35 v2(30.88,13.84)
  IN4 w0.084: v2(288,72.12) 288.04,72.12 288.46,71.71 288.46,68.49 289.91,67.04 289.91,64.86 289.23,64.17 289.23,61.48 289.41,61.3 289.41,61.07 289.96,60.51 289.96,59.83 290.73,59.06 290.73,56.9 291.34,56.29 291.34,54.72 291.73,54.34 291.85,54.21 291.85,50.21 292.83,49.23 293.18,49.23 293.3,49.11 293.54,48.87 293.54,45.59 292.84,44.89 292.84,44.14 294.02,42.97 294.02,41.41 291.74,39.14 291.74,28.35 v2(290.67,27.27)
  BOTTOM w0.112: JAUDIO.25 30.56,14.17 v2(30.88,13.84)
HDA_SPKR: length 314.6
  TOP w0.089: v2(278.54,60.61) 278.59,60.56 278.59,60.43 UH1.AW29
  IN2 w0.104: v2(278.54,60.61) 278.54,60.66 278.74,60.86 278.74,68.95 280.66,70.87 v2(280.66,71.12)
  IN3 w0.104: v2(55.52,18.59) 54.81,18.59 53.26,20.14 50.9,20.14 49.66,21.38 42.58,21.38 40.73,19.53 38.51,19.53 38.12,19.15 37.08,19.15 34.28,16.34 v2(33.02,16.34)
  IN4 w0.084: v2(278.54,60.61) 278.54,60.54 277.99,59.99 275.84,59.99 275.68,59.84 274.41,59.84 274.04,60.22 274.04,60.85 273.38,61.51 272.48,61.51 271.7,60.73 271.7,59.48 271.82,59.36 271.82,58.07 269.8,56.05 269.8,53.52 267.06,50.79 264.64,50.79 259.99,46.14 259.99,24.17 257.45,21.63 254.39,21.63 251.54,18.78 247.67,18.78 240.31,11.43 232.18,11.43 231.76,11.01 227.27,11.01 226.88,11.4 204.43,11.4 200.51,15.32 188.54,15.32 182.12,8.89 173.19,8.89 172.41,8.11 169.64,8.11 168.54,9.22 143.06,9.22 142.53,9.75 137.36,9.75 136.81,9.2 132.71,9.2 131.81,10.1 124.46,10.1 122.44,12.12 117.96,12.12 117.1,12.98 112.38,12.98 110.79,14.56 107.65,14.56 106.91,15.31 95.95,15.31 93.87,17.39 91.49,17.39 90.6,18.28 88.44,18.28 86.34,16.18 83.18,16.18 82.98,16.38 82.75,16.6 69.22,16.6 67.98,17.83 58.3,17.83 58.06,18.07 56.15,18.07 55.63,18.59 v2(55.52,18.59)
  BOTTOM w0.112: v2(33.02,16.34) 32.98,16.34 32.06,15.42 JAUDIO.22
  BOTTOM w0.127: RH600.1 281.11,72.5 281.11,71.86 280.66,71.4 280.66,71.12 v2(280.66,71.12)
HDA_SYNC: length 5.5
  TOP w0.089: RP6.2 288.94,68.55 288,67.61 288,67.57 v1(288,67.02) 287.77,66.79 287.65,66.79 286.78,65.93 286.78,65.48 286.61,65.3 UH1.BG13
HDA_SYNC_R: length 333.1
  TOP w0.112: RP6.1 288.94,70.66 v2(288.06,71.54)
  IN3 w0.104: v2(32.37,16.32) 32.75,15.93 34.2,15.93 37.16,18.9 38.23,18.9 38.62,19.29 40.83,19.29 42.7,21.15 47.63,21.15 49.48,19.3 49.48,17.35 50.6,16.23 54.89,16.23 55.3,16.63 65.71,16.63 68.4,13.94 79.98,13.94 82.41,16.37 85.05,16.37 85.82,17.13 88.31,17.13 89.34,18.17 100.23,18.17 100.85,17.55 107.55,17.55 108.12,16.98 108.12,16.45 108.99,15.58 109.18,15.4 109.67,15.4 110.23,14.84 110.51,14.84 112.24,13.1 118.85,13.1 119.46,12.49 123.72,12.49 123.99,12.22 130.77,12.22 130.95,12.04 141.85,12.04 142.3,11.6 145.67,11.6 146.19,12.11 151.87,12.11 156.19,16.43 178.82,16.43 181.19,14.06 186.41,14.06 188.24,15.89 225.78,15.89 227.63,17.74 235.86,17.74 238.06,19.95 257.98,19.95 266.78,28.75 284.28,28.75 284.63,29.1 287.44,29.1 288.85,27.69 v2(290.26,27.69)
  IN4 w0.084: v2(288.06,71.54) 288.25,71.35 288.25,68.4 289.7,66.95 289.7,64.94 288.87,64.11 288.87,61.54 289.2,61.21 289.2,60.98 289.75,60.43 289.75,59.74 290.52,58.98 290.52,56.81 291.13,56.2 291.13,54.64 291.64,54.13 291.64,50.12 292.74,49.02 293.09,49.02 293.33,48.78 293.33,45.68 292.63,44.98 292.63,44.05 293.81,42.88 293.81,41.5 291.53,39.23 291.53,28.96 v2(290.26,27.69)
  BOTTOM w0.112: JAUDIO.23 31.56,15.5 v2(32.37,16.32)
HDMI_HPD_PCH: length 159.6
  TOP w0.089: v2(281.97,65) 281.97,64.98 281.56,64.57 281.56,64.25 282.17,63.64 282.17,62.83 282.36,62.65 UH1.BD21
  IN1 w0.084: v2(181.75,133.17) 181.38,133.17 180.77,132.56 180.77,129.74 181.1,129.41 181.1,125.31 181.3,125.11 181.3,123.8 182.26,122.84 190.63,122.84 191.38,122.08 198.55,114.92 198.55,114.08 201.22,111.41 202.06,111.41 206.52,106.95 215.19,106.95 215.84,106.3 234.79,106.3 235.24,105.84 250.62,105.84 251.67,104.78 262.34,104.78 267.05,100.07 268.62,100.07 275.13,93.57 275.13,89.65 282.73,82.05 282.73,74.02 281.25,72.54 281.25,72.06 281.26,72.06 281.26,71.97 280.81,71.52 280.49,71.52 280.03,71.05 280.03,69.51 279.69,69.17 279.69,66.77 281.48,64.97 281.94,64.97 v2(281.97,65)
  BOTTOM w0.112: JDGFF1.F2 177.27,133.59 177.38,133.7 180.99,133.7 181.52,133.17 v2(181.75,133.17)
HEAD_LED_B_DRV#: length 97.9
  TOP w0.112: UE3.5 v2(151.85,177.01) ; v2(110.6,128.17) v1(111.28,128.17)
  IN4 w0.084: v2(110.6,128.17) 110.6,129.39 110.27,129.72 110.27,134.01 111.59,135.34 111.59,138.83 106.32,144.1 106.32,156.14 106.67,157.76 106.75,158.12 106.93,159.01 107.09,159.73 107.43,161.34 111.15,165.06 144.23,165.06 149.19,170.01 149.19,174.92 151.28,177.01 v2(151.85,177.01)
  BOTTOM w0.112: v2(110.6,128.17) 110.6,126.5 110.84,126.26 112.17,126.26 113.7,124.73 JFC.4
HEAD_LED_G_DRV#: length 100
  TOP w0.112: v1(149.83,178.2) 150.43,177.6 v2(151.85,177.6) 152.26,177.6 152.35,177.51 UE3.4
  IN4 w0.084: v2(109.95,128.15) 110.33,128.53 110.33,129.35 109.95,129.73 109.95,133.99 111.38,135.43 111.38,138.75 106.11,144.02 106.11,156.16 106.48,157.87 106.53,158.14 106.73,159.05 107.31,161.81 110.98,165.47 144.06,165.47 148.77,170.18 148.77,174.8 151.57,177.6 v2(151.85,177.6)
  BOTTOM w0.112: JFC.3 112.7,124.91 111.79,125.82 110.65,125.82 109.95,126.52 v2(109.95,128.15)
HEAD_LED_R_DRV#: length 98.7
  TOP w0.112: v1(151.1,178.59) 151.5,178.18 v2(151.85,178.18) 152.26,178.18 152.43,178.01 UE3.3
  IN4 w0.084: v2(109.92,128.75) 109.67,129 109.67,134.01 111.17,135.52 111.17,138.66 105.9,143.93 105.9,156.18 106.28,157.97 106.28,157.97 106.32,158.16 107.07,161.68 107.2,162.28 110.81,165.89 143.89,165.89 148.36,170.36 148.36,174.69 v2(151.85,178.18)
  BOTTOM w0.112: JFC.2 111.7,124.95 111.19,125.46 110.34,125.46 109.53,126.27 109.53,128.36 v2(109.92,128.75)
HT_EN: length 32.8
  TOP w0.112: v2(297.19,8.58) 296.74,9.04 UE5.42
  IN1 w0.084: JDBG.5 324.45,7.26 302.04,7.26 301.83,7.47 301.83,8.55 300.89,9.48 298.1,9.48 v2(297.19,8.58)
  BOTTOM w0.112: v2(297.19,8.58) 297.22,8.58 297.78,8.02 v1(297.78,7.77)
I2C0_SCL_EC: length 297.3
  TOP w0.112: RE668.2 312.47,18.92 v1(313.02,18.37) 312.79,18.15 v2(311.81,18.15)
  IN3 w0.104: v2(36.65,13.75) 36.55,13.85 36.55,14.21 37.41,15.06 44.57,15.06 46.61,13.03 47.34,13.03 48.44,11.92 62.64,11.92 64.09,10.47 80.69,10.47 81.7,9.45 88.11,9.45 89.1,8.46 93.17,8.46 96.41,11.71 104.99,11.71 105.78,10.92 109.28,10.92 112.24,7.95 124.7,7.95 124.98,7.67 137.89,7.67 138.13,7.92 139.88,7.92 140.38,7.41 166.87,7.41 167.56,6.73 185.58,6.73 190.19,11.34 196.03,11.34 197.17,10.2 223.71,10.2 224.51,9.4 232.6,9.4 233.92,10.72 240.02,10.72 243.34,14.04 246.1,14.04 246.46,13.68 249.14,13.68 249.27,13.81 250.13,13.81 250.43,13.51 251.48,13.51 252.26,14.29 260.95,14.29 268.33,21.67 282.58,21.67 287.94,16.31 291.44,16.31 292.12,16.99 295.53,16.99 295.68,16.84 296.52,16.84 297.06,17.38 306.69,17.38 307.45,18.15 v2(311.81,18.15)
  BOTTOM w0.112: JAUDIO.13 36.56,13.85 v2(36.65,13.75)
I2C0_SDA_EC: length 298.1
  TOP w0.112: v2(310.48,19.64) 310.35,19.52 RE669.2
  IN3 w0.104: v2(37.89,16.27) 38.38,15.78 44.87,15.78 46.9,13.75 47.63,13.75 48.35,13.03 50.11,13.03 50.5,12.64 62.94,12.64 64.39,11.18 80.98,11.18 82,10.17 89.14,10.17 90.13,9.18 92.87,9.18 96.11,12.42 105.28,12.42 105.91,11.8 109.22,11.8 109.41,11.8 111.8,9.4 115.38,9.4 116.15,10.18 117.63,10.18 118.25,9.56 122.51,9.56 122.78,9.29 124.7,9.29 125.38,8.62 133.44,8.62 133.88,9.06 140.71,9.06 141.16,8.61 156.03,8.61 156.75,9.33 180.79,9.33 181.16,9.7 186.51,9.7 189.53,12.71 196.32,12.71 197.66,11.38 223.33,11.38 223.8,11.84 228.19,11.84 228.75,12.4 235.63,12.4 239.4,16.16 260.13,16.16 267.97,24 270.21,24 271.57,25.36 283.37,25.36 285.09,23.65 288.03,23.65 288.31,23.36 288.43,23.36 289.07,22.73 289.07,22.61 289.66,22.02 290.94,22.02 292.24,20.71 294.56,20.71 295.18,20.09 297.46,20.09 297.79,20.42 299.54,20.42 299.99,19.96 301.27,19.96 301.52,20.22 307.12,20.22 307.22,20.11 307.22,19.24 307.33,19.14 307.54,19.14 307.64,19.24 307.64,20.11 307.74,20.22 307.95,20.22 308.06,20.11 308.06,19.37 308.16,19.26 308.37,19.26 308.47,19.37 308.47,20.11 308.58,20.22 308.83,20.22 308.93,20.11 308.93,19.48 309.04,19.38 309.24,19.38 309.35,19.48 309.35,20.11 309.45,20.22 310.36,20.22 310.48,20.1 v2(310.48,19.64)
  BOTTOM w0.112: JAUDIO.12 37.06,15.43 v2(37.89,16.27)
I2C2_SCL: length 73.2
  TOP w0.089: v2(284.57,65.11) 284.85,64.83 284.85,64.04 284.6,63.8 UH1.BF17 ; RPC7.4 265.24,48.52 265.33,48.43 v2(265.71,48.43)
  TOP w0.112: RH31.1 v2(274.8,82.4) 274.53,82.4 v1(274.29,82.64)
  IN2 w0.104: 277.19,56.2 276.34,56.2 276.03,55.88 276.03,54.71 275.73,54.42 273.89,54.42 273.08,53.6 273.08,52.32 272.04,51.28 270.97,51.28 270.43,50.73 270.43,50.43 269.92,49.92 269.92,48.99 270.15,48.77 270.15,48.51 269.5,47.87 269.5,47.36 269.04,46.9 267.84,46.9 266.31,48.43 v2(265.71,48.43) ; 277.19,56.2 281.05,56.2 281.49,56.64 283.61,56.64 283.74,56.77 283.74,57.55 283.93,57.74 284.56,57.74 284.89,58.07 284.89,59.65 284.15,60.39 282.28,60.39 281.88,60.79 281.88,61.38 284.89,64.38 284.89,64.79 v2(284.57,65.11) ; 277.19,56.2 277.19,57 276,58.19 276,59.77 276.23,60 276.74,60 276.98,60.24 276.98,62.27 275.1,64.14 275.1,66.74 275.54,67.17 275.54,70.75 276.48,71.69 276.48,72.51 276.83,72.86 276.83,77.11 274.03,79.91 274.03,81.62 v2(274.8,82.4)
I2C2_SDA: length 67.3
  TOP w0.089: v2(268.89,49.46) 268.86,49.5 267.48,49.5 266.48,48.5 266.48,48.25 v1(266.26,48.02) RPC7.3 ; v2(284.19,67.52) 284.51,67.52 284.83,67.21 284.83,65.52 285.04,65.31 285.04,63.47 UH1.BE17
  TOP w0.112: v2(276,76.03) 275.55,76.48 RH32.1
  BOTTOM w0.112: v2(284.19,67.52) 283.74,67.97 282.5,67.97 282.03,67.49 282.03,66.94 281.28,66.19 280.69,66.19 279.2,67.68 279.2,71.58 276.98,73.8 276.98,75.43 276.38,76.03 v2(276,76.03) 276,76.68 274.13,78.54 273.75,78.54 272.36,77.15 272.36,68.83 274.87,66.32 274.87,63.6 274.59,63.32 274.59,61.71 275.65,60.65 275.65,59.14 275.77,59.01 275.77,58.53 275.08,57.83 275.08,56.97 274.71,56.6 274.37,56.6 274,56.23 271.44,56.23 269.9,54.68 269.9,50.58 268.89,49.57 v2(268.89,49.46)
I2C3_SCL: length 3.9
  TOP w0.112: US2.13 112.66,173.42 v1(112.38,173.7) 112.14,173.7 112.03,173.81 112.03,174.31 112.44,174.72 112.6,174.72 RH617.2
I2C3_SDA: length 3.9
  TOP w0.112: RH618.2 113.06,174.78 112.81,175.03 v1(112.3,175.03) 111.79,174.52 111.79,173.57 112.16,173.2 US2.14
I2C_0_SCL: length 282.8
  TOP w0.089: UH1.BC22 282.14,62.39 282.07,62.46 282.07,62.65 281.98,62.73 281.98,63.56 281.37,64.17 281.37,65.29 281.67,65.59 v2(281.95,65.59) ; v2(267.77,49.1) 267.53,48.86 267.11,48.86 266.67,48.42 266.67,47.71 266.35,47.38 265.4,47.38 265.26,47.52 RPC7.2
  IN1 w0.084: v2(109.5,14.99) 110.24,14.99 112.56,12.67 122.94,12.67 123.98,11.63 128.14,11.63 128.4,11.89 142.26,11.89 143.36,10.79 158.68,10.79 173.76,25.87 181.06,25.87 183.43,28.24 227.01,28.24 228.38,26.86 234.96,26.86 235.22,27.12 237.65,27.12 239.91,29.38 243.52,29.38 248.06,33.91 258.12,33.91 260.03,32.01 262.72,32.01 263.06,31.67 271.48,31.67 271.91,31.24 274,31.24 275.43,29.82 281.44,29.82 284.5,32.87 284.5,33.98 282.59,35.88 282.59,38.18 281.84,38.93 281.84,42.33 281.17,43 281.17,44.81 279.62,46.36 278.88,46.36 277.27,47.97 276.57,47.97 275.74,48.8 272.63,48.8 272.45,48.62 270.21,48.62 269.76,49.07 267.81,49.07 267.78,49.1 v2(267.77,49.1)
  IN2 w0.104: v2(267.77,49.1) 267.71,49.04 267.62,49.04 267.49,49.17 267.49,51.33 268.72,52.57 268.72,54.82 269.25,55.34 269.25,58.58 269.4,58.73 269.4,62.49 269.5,62.59 269.5,66.07 270.45,67.03 270.92,67.03 v2(271.04,66.9)
  IN3 w0.127: v2(271.04,66.9) 271.16,67.02 273.79,67.02 274.52,66.29 278.8,66.29 279.47,65.62 281.91,65.62 v2(281.95,65.59)
  BOTTOM w0.112: RE71.1 100,18.7 99.42,19.28 98.72,19.28 97.88,18.43 v1(97.88,16.41) 97.88,14.35 100.53,11.7 100.53,10.76 101.05,10.24 102.57,10.24 102.86,10.53 102.92,10.59 102.92,11.67 103.62,12.37 107.12,12.37 109.44,14.69 109.44,14.93 v2(109.5,14.99)
I2C_0_SCL_R: length 12.6
  TOP w0.112: v2(106.58,16.82) 106.56,16.8 106.56,15.47 RE659.2
  IN3 w0.104: v2(106.58,16.82) 106.58,16.66 105.77,15.85 100.53,15.85 99.85,16.53 v2(99.85,17.07)
  BOTTOM w0.112: RE71.2 99.85,17.63 v2(99.85,17.07) 99.87,17.05 99.87,16.36 99.45,15.94 99.45,15.85 99.45,15.85 JTP.2
I2C_0_SDA: length 282.8
  TOP w0.089: UH1.BF23 281.73,63.56 281.19,64.09 281.19,65.36 281.97,66.14 v2(281.97,66.17) ; v2(267.77,48.51) 267.77,48.53 267.61,48.69 267.6,48.68 267.19,48.68 266.85,48.35 266.85,47.63 266.42,47.2 265.45,47.2 265.27,47.02 RPC7.1
  IN1 w0.084: v2(108.91,14.99) 108.91,15.19 109.18,15.45 110.43,15.45 112.75,13.14 123.13,13.14 124.17,12.1 127.95,12.1 128.2,12.35 142.45,12.35 143.55,11.26 158.49,11.26 173.57,26.33 180.87,26.33 183.24,28.7 227.2,28.7 228.57,27.33 234.77,27.33 235.03,27.58 237.46,27.58 239.72,29.84 243.33,29.84 247.87,34.38 258.32,34.38 260.22,32.48 262.91,32.48 263.25,32.14 271.67,32.14 272.1,31.7 274.2,31.7 275.62,30.28 281.25,30.28 284.03,33.06 284.03,33.79 282.13,35.69 282.13,37.99 281.38,38.74 281.38,42.14 280.71,42.8 280.71,44.61 279.43,45.9 278.68,45.9 277.08,47.5 276.38,47.5 275.55,48.33 272.82,48.33 272.64,48.16 270.01,48.16 269.57,48.6 267.86,48.6 v2(267.77,48.51)
  IN2 w0.104: v2(267.77,48.51) 267.72,48.55 267.42,48.55 267,48.97 267,51.53 268.24,52.77 268.24,55.02 268.76,55.54 268.76,58.78 268.91,58.93 268.91,62.7 269.01,62.79 269.01,66.7 268.14,67.58 268.14,67.79 268.76,68.41 269.08,68.41 269.46,68.03 269.46,67.46 269.65,67.27 270.01,67.27 270.25,67.51 270.89,67.51 v2(271.04,67.66)
  IN3 w0.127: v2(271.04,67.66) 271.18,67.52 274.01,67.52 274.73,66.8 279.01,66.8 279.68,66.13 281.93,66.13 v2(281.97,66.17)
  BOTTOM w0.112: v2(108.91,14.99) 108.94,14.96 108.94,14.89 106.92,12.87 103.42,12.87 102.43,11.88 102.43,10.8 102.36,10.73 101.25,10.73 101.02,10.96 101.02,11.91 98.37,14.56 98.37,18.23 98.83,18.69 RE653.1
I2C_0_SDA_R: length 12.6
  TOP w0.112: v2(106,16.82) 106.06,16.75 106.06,15.47 RE660.2
  IN3 w0.104: v2(106,16.82) 105.51,16.34 100.73,16.34 100.34,16.73 100.34,17.27 100.05,17.55 99.65,17.55 99.27,17.17 v2(99.27,17.04)
  BOTTOM w0.112: RE653.2 99.36,17.63 99.36,17.13 v2(99.27,17.04) 99.38,16.93 99.38,16.56 98.95,16.14 98.95,15.85 98.95,15.85 JTP.1
I2C_CLK: length 388.8
  TOP w0.112: RE2.2 v2(364.13,33.81) 363.83,34.11 UE1.42 ; UE3.25 157.15,184.4 v1(158.2,185.45) v2(160.29,187.54) 160.86,188.11 RM1.2
  IN4 w0.084: v2(160.29,187.54) 160.15,187.68 160.15,187.91 160.34,188.1 164.31,188.1 169.66,182.76 169.66,176.7 166.96,174 166.96,172.34 166.53,171.91 166.53,171.02 163.22,167.72 163.22,156.17 168.27,151.12 179.11,151.12 180.76,149.47 180.76,144.2 182.32,142.64 182.32,135.17 180.77,133.62 180.77,129.16 180.89,129.04 180.89,112.59 185.09,108.4 219.04,108.4 219.56,108.92 225.69,108.92 227.76,106.84 249.15,106.84 249.78,106.22 267.87,106.22 297.91,76.17 297.91,73.92 302.73,69.1 302.73,59.73 305.28,57.18 305.28,45.38 299.84,39.94 299.84,32.28 299.32,31.77 299.32,30.51 300.78,29.05 300.78,27.96 301.15,27.59 301.15,22.83 301.65,22.32 301.65,20.1 302.96,18.79 309.52,18.79 311.14,17.17 314.98,17.17 315.36,17.55 321.98,17.55 324.46,20.02 326.22,20.02 327.38,21.18 329.01,22.81 336.75,22.81 337.17,22.4 344.6,22.4 345.46,23.26 351.98,23.26 353.53,21.71 355.11,21.71 356.57,20.24 363.28,20.24 364.55,21.51 364.55,29.55 363.86,30.25 363.86,33.72 363.94,33.81 v2(364.13,33.81)
I2C_DAT: length 388.6
  TOP w0.112: RM2.2 160.27,188.22 v2(159.62,187.57) v1(156.65,184.6) 156.65,180.8 156.65,180.79 UE3.26 ; RE1.2 v2(364.13,34.59) 364.08,34.59 364.06,34.61 UE1.43
  IN4 w0.084: v2(364.13,34.59) 364.07,34.59 363.39,33.91 363.39,30.06 364.09,29.36 364.09,21.71 363.09,20.71 356.77,20.71 355.3,22.17 353.72,22.17 352.17,23.72 344.97,23.72 344.11,22.86 337.36,22.86 336.94,23.27 328.82,23.27 326.91,21.37 326.03,20.49 324.27,20.49 321.79,18.01 314.23,18.01 313.43,18.81 310.16,18.81 308.32,20.65 303.57,20.65 302.28,21.93 302.28,30.33 300.97,31.65 300.97,40.22 305.74,44.99 305.74,57.53 303.19,60.08 303.19,69.29 298.37,74.11 298.37,76.37 268.06,106.68 249.97,106.68 249.34,107.31 227.96,107.31 225.81,109.45 217.63,109.45 217.06,108.88 185.26,108.88 181.35,112.79 181.35,127.86 182.81,129.32 182.81,142.81 181.23,144.39 181.23,146.38 181.31,146.46 181.62,146.46 181.7,146.55 181.7,146.71 181.62,146.8 181.31,146.8 181.23,146.88 181.23,147.05 181.31,147.13 181.49,147.13 181.58,147.22 181.58,147.38 181.49,147.47 181.31,147.47 181.23,147.55 181.23,149.66 179.31,151.58 168.47,151.58 163.68,156.36 163.68,166.9 165.32,168.54 165.68,168.54 165.91,168.77 165.91,169.7 167.1,170.89 167.1,171.82 167.42,172.15 167.42,173.81 170.12,176.51 170.12,182.95 164.51,188.57 160.15,188.57 159.68,188.1 159.68,187.63 v2(159.62,187.57)
I2C_INT: length 88.8
  TOP w0.112: UE5.98 305.14,23.75 304.69,23.31 v2(304.69,23.28) ; v3(230.36,14.48) 230.57,14.48 v2(230.92,14.83)
  IN3 w0.104: v2(304.69,23.28) 304.32,23.28 303.96,23.64 302.57,23.64 302.2,23.28 297.29,23.28 296.87,22.85 292.11,22.85 289.54,25.42 287.32,25.42 286.69,26.06 285.23,26.06 284.62,26.67 270.7,26.67 269.69,25.65 266.81,25.65 258.85,17.7 238.76,17.7 236.72,15.66 232.14,15.66 231.3,14.83 v2(230.92,14.83)
  BOTTOM w0.112: JPK.15 228.95,11.75 229.73,12.54 DK3.2 229.73,14.49 RE656.2 230.35,15.01 230.53,14.83 v2(230.92,14.83)
ILIM_VCCIO: length 3.6
  BOTTOM w0.112: PRF11.2 v1(160.11,113.45)
  BOTTOM w0.254: PRF11.2 159.13,113.45 PRF09.1 157.68,112.82 157.68,112.78 157.45,112.55 157.41,112.55 157.34,112.48 PUF01.13
IMVP_VR_ON: length 457.5
  TOP w0.112: v2(296.36,21.76) 297.2,22.6 297.2,24.15 297.03,24.33 296.17,24.33 295.94,24.56 UE5.121 295.94,26.49 295.36,27.07 295.36,27.54 CE38.2
  TOP w0.254: v2(115.41,104.48) 115.41,101.43 118.52,98.32 118.52,93.3 119.34,92.48 119.34,89.33 119.64,89.03 119.94,89.03 v2(120.17,88.8) ; v2(128.29,121.63) v1(129.44,120.48) 130.83,119.09 PRA23.2 ; v2(58.55,27.4) 58.59,27.4 58.7,27.51 PRZ24.1
  IN1 w0.254: v2(63.52,38.32) 63.52,38.35 64.56,39.38 65.09,39.38 71.5,45.79 79.37,45.79 80.13,46.55 82.83,46.55 85.27,48.99 87.2,48.99 94.85,56.65 94.85,58.6 97.36,61.1 98.76,61.1 105.24,67.58 105.24,76.62 115.41,86.79 115.41,88.1 116.23,88.92 119.31,88.92 119.41,89.03 119.94,89.03 v2(120.17,88.8) ; v2(128.29,121.63) 119.85,121.63 115.41,117.18 v2(115.41,104.48)
  IN2 w0.254: v2(58.55,27.4) 58.82,27.4 60.1,28.68 60.1,33.15 63.64,36.68 63.64,38.21 v2(63.52,38.32)
  IN3 w0.104: v2(288.19,5.48) 288.57,5.1 289.32,5.1 292.37,8.15 292.37,10.77 292.07,11.07 291.43,11.07 290.33,9.97 283.78,9.97 283.07,9.27 280.26,9.27 278.55,7.55 276.92,7.55 274.74,9.72 270.2,9.72 264.38,3.91 248.23,3.91 244.76,7.38 197.08,7.38 195.16,9.29 195.03,9.32 191.14,9.32 191,9.29 186.42,4.71 182.91,4.71 182.31,4.11 179.08,4.11 178.25,4.94 166.82,4.94 166.13,5.62 138.37,5.62 138.32,5.57 126.84,5.57 126.55,5.87 124.55,5.87 124.26,5.57 120.44,5.57 119.51,6.51 111.69,6.51 108.69,9.51 96.28,9.51 93.28,6.51 65.52,6.51 v2(64.16,7.87)
  BOTTOM w0.112: v2(58.55,27.4) 58.65,27.3 59.33,27.3 59.4,27.23 59.4,26.88 58.2,25.68 58.2,24.74 59.37,23.57 61.07,23.57 63.4,21.24 63.4,20.15 62.13,18.88 62.13,15.07 62.7,14.5 62.7,13.42 64.16,11.96 v2(64.16,7.87) ; Q7.6 293.63,20.77 294.62,21.76 v2(296.36,21.76) 297.26,21.76 298.15,20.87 298.15,17.96 293.99,13.8 291.83,13.8 290.84,12.82 290.84,12.09 289.51,10.76 289.51,7.46 288.19,6.14 v2(288.19,5.48)

# Allegro board Alienware Area-51M LA-G881P.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_DQS0: length 110.3
  IN3 w0.165: v2(222.28,27.63) 222.12,27.47 222.12,27.15 221.79,26.82 219.75,26.82 216.53,27.17 209.95,27.17 209.12,28 208,28 207.85,27.85 207.85,27.63 v2(207.95,27.53)
  IN4 w0.102: 152.18,38.5 152.16,38.52 152.16,38.55 151.37,39.35 151.37,44.09 153.42,46.14 153.42,47.9 154.18,48.66 154.18,49.03 154.08,49.13 153.93,49.13 153.78,48.98 v2(153.78,48.91)
  IN4 w0.147: 152.18,38.5 162.49,28.19 173.15,28.19 173.52,27.82 173.52,27.11 174.19,26.44 184.12,26.44 184.5,26.82 184.5,27.99 184.65,28.14 185.09,28.14 185.24,27.99 185.24,26.85 185.53,26.56 186.18,26.56 186.47,26.85 186.47,27.99 186.62,28.14 187.06,28.14 187.21,27.99 187.21,26.85 187.5,26.56 188.15,26.56 188.44,26.85 188.44,27.99 188.59,28.14 189.03,28.14 189.18,27.99 189.18,26.85 189.47,26.56 190.12,26.56 190.41,26.85 190.41,27.82 190.56,27.96 191,27.96 191.15,27.82 191.15,26.85 191.44,26.56 207.59,26.56 207.89,26.85 207.89,27.46 v2(207.95,27.53)
  BOTTOM w0.165: JDIMM4.13 205.48,29.78 205.62,29.63 206.21,29.63 207.8,28.04 207.8,27.68 v2(207.95,27.53)
  BOTTOM w0.173: JDIMM2.13 219.57,29.78 219.69,29.66 220.33,29.66 221.27,28.73 221.59,28.73 222.04,28.27 222.04,27.87 v2(222.28,27.63)
  BOTTOM w0.216: UC1.AF35 153.8,48.91 v2(153.78,48.91)
DDR_B_DQS1: length 97.5
  IN4 w0.102: 160.12,38.68 160.11,38.7 160.07,38.7 159.51,39.26 159.51,39.49 157.54,41.46 157.54,42.59 157.2,42.92 157.2,44.87 158.93,46.59 158.93,50.31 157.84,51.4 157.84,51.59 157.94,51.69 158.29,51.69 v2(158.35,51.63)
  IN4 w0.147: v2(224.33,35.71) 224.25,35.71 223.99,35.97 223.99,36.35 223.68,36.66 219.48,36.66 219.19,36.36 219.19,35.67 218.98,35.46 218.66,35.46 218.45,35.67 218.45,36.36 218.16,36.66 211.91,36.66 210.03,34.78 210.03,34.51 v2(209.83,34.31) 210.01,34.14 210.01,33.8 209.86,33.65 205.48,33.65 205.05,33.22 199.66,33.22 199.51,33.36 199.51,33.67 199.22,33.97 198.57,33.97 198.28,33.67 198.28,33.36 198.13,33.22 197.69,33.22 197.54,33.36 197.54,33.67 197.25,33.97 185.35,33.97 183.75,35.56 176.17,35.56 174.63,34.02 164.78,34.02 160.12,38.68
  BOTTOM w0.173: JDIMM2.34 225.83,35.03 225.71,34.91 224.32,34.91 224.15,35.08 224.15,35.53 v2(224.33,35.71) ; v2(209.83,34.31) 210.01,34.49 210.01,34.92 210.34,35.25 211.33,35.25 211.67,34.91 211.93,34.91 212.04,35.03 JDIMM4.34
  BOTTOM w0.216: UC1.AL33 v2(158.35,51.63)
DDR_B_DQS2: length 82.6
  IN3 w0.165: v2(222.19,40.49) 221.95,40.25 221.95,40.1 221.62,39.77 207.79,39.77 207.57,39.56 207.57,39.19 207.74,39.02 v2(207.79,39.02)
  IN4 w0.102: 174.27,40.28 174.26,40.28 174.23,40.26 174.18,40.26 174.15,40.24 173.7,40.24 169.59,44.35 168.05,44.35 167.82,44.13 167.82,43.57 167.72,43.47 167.42,43.47 167.32,43.57 167.32,44.13 167.1,44.35 164.7,44.35 162.94,46.12 162.94,49.72 161.31,51.35 161.31,51.36 v2(161.06,51.61)
  IN4 w0.147: 174.27,40.28 202.47,40.28 202.76,39.99 202.76,39.85 202.91,39.7 203.35,39.7 203.5,39.85 203.5,39.99 203.79,40.28 204.61,40.28 204.9,39.99 204.9,39.62 205.05,39.47 205.49,39.47 205.64,39.62 205.64,39.99 205.93,40.28 207.3,40.28 207.59,39.99 207.59,39.22 v2(207.79,39.02)
  BOTTOM w0.102: UC1.AP33 161.5,51.17 v2(161.06,51.61)
  BOTTOM w0.173: v2(222.19,40.49) 222.02,40.66 222.02,40.97 221.75,41.24 220.64,41.24 220.1,40.7 220.1,40.4 219.91,40.21 219.66,40.21 219.59,40.28 JDIMM2.55 ; JDIMM4.55 205.77,40.28 205.89,40.16 207.01,40.16 207.56,39.61 207.56,39.25 v2(207.79,39.02)
DDR_B_DQS3: length 82
  IN3 w0.165: v2(223.86,46.76) 223.7,46.92 223.7,47.29 223.42,47.57 215.82,47.57 215.01,46.76 212.61,46.76 211.68,45.83 209.18,45.83 208.55,45.2 208.55,44.47 v2(208.32,44.23)
  IN4 w0.102: 174.27,45.94 174.26,45.94 174.23,45.96 174.18,45.96 174.15,45.98 174.07,45.98 171.62,48.44 168.77,48.44 167.38,49.83 167.38,50.72 166.85,51.25 166.1,51.25 163.58,53.77 161.62,53.77 160.47,54.91 160.47,55.18 160.37,55.29 v2(160.18,55.29)
  IN4 w0.147: v2(208.32,44.23) 208.53,44.45 208.53,44.78 207.86,45.45 191.66,45.45 191.17,45.94 174.27,45.94
  BOTTOM w0.173: v2(223.86,46.76) 223.72,46.62 223.72,46.35 224.61,45.46 225.76,45.46 225.83,45.53 JDIMM2.76 ; v2(208.32,44.23) 208.48,44.4 208.48,44.88 209.02,45.41 211.71,45.41 211.83,45.53 JDIMM4.76
  BOTTOM w0.216: UC1.AN28 v2(160.18,55.29)
DDR_B_DQS4: length 80.8
  IN3 w0.165: v2(206.27,74.31) 206.48,74.1 206.48,73.7 206.85,73.33 212.09,73.33 212.31,73.1 221.58,73.1 221.74,72.94 221.74,72.69 v2(221.63,72.57)
  IN4 w0.102: 174.27,76.03 174.24,76.03 174.22,76.05 173.39,76.05 172.91,75.58 171.75,75.58 170.76,74.6 167.43,74.6 166.01,73.17 165.38,73.17 164.41,72.2 161.52,72.2 161.34,72.02 161.34,71.63 161.18,71.47 160.79,71.47 160.54,71.22 160.54,71.1 160.62,71.02 160.62,70.59 160.85,70.36 160.85,70.2 160.71,70.06 160.57,70.06 160.32,70.32 160.07,70.32 159.99,70.39 159.99,70.64 v2(160.18,70.83)
  IN4 w0.147: 174.27,76.03 178.32,76.03 178.78,76.48 179.19,76.48 179.65,76.03 180.31,76.03 180.61,76.32 180.61,76.41 180.76,76.55 181.2,76.55 181.34,76.41 181.34,76.32 181.64,76.03 182.29,76.03 182.58,76.32 182.58,76.41 182.73,76.55 183.17,76.55 183.32,76.41 183.32,76.32 183.61,76.03 184.46,76.03 184.75,76.32 184.75,76.41 184.9,76.55 185.34,76.55 185.49,76.41 185.49,76.32 185.78,76.03 186.43,76.03 186.73,76.32 186.73,76.41 186.87,76.55 187.31,76.55 187.46,76.41 187.46,76.32 187.75,76.03 188.4,76.03 188.69,76.32 188.69,76.41 188.84,76.55 189.28,76.55 189.43,76.41 189.43,76.32 189.72,76.03 190.37,76.03 190.66,76.32 190.66,76.41 190.81,76.55 191.25,76.55 191.4,76.41 191.4,76.32 191.69,76.03 192.34,76.03 192.63,76.32 192.63,76.41 192.78,76.55 193.22,76.55 193.37,76.41 193.37,76.32 193.66,76.03 194.31,76.03 194.6,76.32 194.6,76.41 194.75,76.55 195.45,76.55 197.18,74.83 206.31,74.83 206.46,74.68 206.46,74.5 v2(206.27,74.31)
  BOTTOM w0.173: JDIMM4.179 205.49,73.28 205.6,73.16 206.13,73.16 206.46,73.49 206.46,74.12 v2(206.27,74.31) ; JDIMM2.179 219.66,73.27 219.66,73.28 219.77,73.16 220.05,73.16 220.45,72.77 220.45,72.42 220.74,72.13 221.6,72.13 221.77,72.29 221.77,72.43 v2(221.63,72.57)
  BOTTOM w0.216: UC1.AN12 v2(160.18,70.83)
DDR_B_DQS5: length 79.2
  IN3 w0.165: v2(210.75,78.54) 210.61,78.67 210.61,79.11 210.71,79.21 211.68,79.21 211.91,78.98 216.87,78.98 217.11,78.74 221.27,78.74 221.95,78.05 223.86,78.05 224.19,78.38 224.19,78.57 v2(224.45,78.83)
  IN4 w0.102: v2(161.09,76.69) 161.09,76.55 161.29,76.35 161.57,76.35 162.88,77.65 162.88,78.29 163.55,78.97 165.17,78.97 166.31,80.11 167.61,80.11 172.11,84.6 174.22,84.6 174.24,84.63 174.27,84.63
  IN4 w0.147: v2(210.75,78.54) 210.58,78.71 210.58,79.59 209.81,80.36 203.67,80.36 203.18,80.85 199.04,80.85 198.2,81.68 181.24,81.68 178.3,84.63 174.27,84.63
  BOTTOM w0.102: UC1.AP8 v2(161.09,76.69)
  BOTTOM w0.173: JDIMM2.200 226.1,78.53 225.99,78.41 225.48,78.41 225.22,78.15 224.43,78.15 224.25,78.33 224.25,78.64 224.44,78.83 v2(224.45,78.83) ; JDIMM4.200 211.98,78.53 211.45,78 210.8,78 210.62,78.17 210.62,78.42 v2(210.75,78.54)
DDR_B_DQS6: length 88.2
  IN3 w0.165: v2(207.86,86.15) 208.28,85.73 208.28,85.34 208.21,85.27 208.21,84.81 208.54,84.48 209.26,84.48 209.87,85.09 212.62,85.09 212.91,84.8 218.85,84.8 218.93,84.72 221.04,84.72 221.37,84.4 221.37,84.25 v2(221.23,84.11)
  IN4 w0.102: 167.04,87.63 166.78,87.37 166.78,87.34 163.36,83.92 161.1,83.92 160.86,83.67 160.86,83.04 158.77,80.96 158.77,76.49 158.53,76.25 158.11,76.25 158.01,76.35 158.01,76.6 158.16,76.75 v2(158.29,76.75)
  IN4 w0.147: 167.04,87.63 168.76,89.35 180.25,89.35 182.01,87.59 182.49,87.59 182.63,87.74 182.63,88.88 182.93,89.18 183.57,89.18 183.87,88.88 183.87,87.74 184.01,87.59 195.27,87.59 195.89,86.97 203.31,86.97 203.95,86.33 204.65,86.33 205.25,85.73 207.97,85.73 208.06,85.82 208.06,85.95 v2(207.86,86.15)
  BOTTOM w0.102: UC1.AL8 157.89,76.36 v2(158.29,76.75)
  BOTTOM w0.173: v2(207.86,86.15) 207.88,86.15 208.06,85.98 208.06,85.19 206.52,83.66 205.89,83.66 205.77,83.78 JDIMM4.221 ; JDIMM2.221 220.25,83.78 220.44,83.59 220.97,83.59 221.23,83.85 v2(221.23,84.11)
DDR_B_DQS7: length 100.8
  IN3 w0.165: v2(223.2,89.55) 223.18,89.55 223.1,89.62 223.03,89.62 222.78,89.88 222.78,90.34 222.35,90.76 219.56,90.76 219.33,91 209.78,91 209.59,91.18 209.59,91.37 v2(209.75,91.53)
  IN4 w0.102: v2(153.8,77.73) 154,77.92 154,78.66 153.8,78.86 153.8,81.19 155.06,82.46 155.06,83.28 155.71,83.92 156.34,83.92 156.67,84.25 156.67,86.59 158.81,88.74 158.81,88.77 158.83,88.79
  IN4 w0.147: 158.83,88.79 160.21,90.17 160.21,90.38 159.86,90.74 159.86,91.15 160.32,91.61 160.73,91.61 161.09,91.26 161.3,91.26 162.07,92.03 164.75,92.03 166.8,94.08 201.76,94.08 202.05,93.78 202.05,92.95 202.2,92.8 202.64,92.8 202.79,92.95 202.79,94.25 203.08,94.54 205.2,94.54 205.5,94.25 205.5,93.64 205.2,93.34 204.46,93.34 204.32,93.2 204.32,92.7 204.46,92.55 209.45,92.55 209.75,92.26 v2(209.75,91.53)
  BOTTOM w0.173: v2(223.2,89.55) 223.01,89.35 223.01,89.11 223.2,88.91 225.71,88.91 225.83,89.02 JDIMM2.242 ; JDIMM4.242 212.09,89.03 211.98,88.92 211.76,88.92 210.26,90.42 209.85,90.42 209.44,90.84 209.44,91.26 209.71,91.53 v2(209.75,91.53)
  BOTTOM w0.216: v2(153.8,77.73) 154.24,77.29 UC1.AG7
DDR_B_DQS#0: length 109.8
  IN3 w0.165: v2(207.37,27.53) 207.56,27.71 207.56,27.95 207.88,28.28 209.24,28.28 210.07,27.45 216.54,27.45 219.77,27.1 221.68,27.1 221.84,27.26 221.84,27.43 v2(221.65,27.63)
  IN4 w0.102: v2(153.78,49.8) 153.59,49.8 153.49,49.7 153.49,49.45 153.61,49.33 154.16,49.33 154.38,49.11 154.38,48.58 153.62,47.82 153.62,46.05 151.57,44.01 151.57,39.43 152.31,38.7 152.34,38.7 152.36,38.68
  IN4 w0.147: 152.36,38.68 162.59,28.44 173.25,28.44 173.77,27.93 173.77,27.22 174.29,26.69 184.01,26.69 184.25,26.93 184.25,28.09 184.54,28.39 185.19,28.39 185.48,28.09 185.48,26.95 185.63,26.81 186.07,26.81 186.22,26.95 186.22,28.09 186.51,28.39 187.16,28.39 187.46,28.09 187.46,26.95 187.6,26.81 188.04,26.81 188.19,26.95 188.19,28.09 188.49,28.39 189.13,28.39 189.43,28.09 189.43,26.95 189.57,26.81 190.02,26.81 190.16,26.95 190.16,27.92 190.46,28.21 191.1,28.21 191.4,27.92 191.4,26.95 191.54,26.81 207.49,26.81 207.64,26.96 207.64,27.23 207.52,27.35 207.52,27.37 v2(207.37,27.53)
  BOTTOM w0.165: 204.85,29.28 205.55,29.28 205.64,29.36 206.1,29.36 207.53,27.93 207.53,27.69 v2(207.37,27.53)
  BOTTOM w0.173: JDIMM4.11 204.85,29.28 ; v2(221.65,27.63) 221.77,27.75 221.77,28.16 221.48,28.45 221.15,28.45 220.21,29.39 219.69,29.39 219.57,29.28 JDIMM2.11
  BOTTOM w0.216: UC1.AF34 v2(153.78,49.8)
DDR_B_DQS#1: length 97
  IN4 w0.102: 159.95,38.5 159.93,38.52 159.93,38.55 159.31,39.17 159.31,39.4 157.33,41.38 157.33,42.51 157,42.84 157,44.95 158.72,46.67 158.72,50.22 157.63,51.31 157.63,51.53 157.53,51.63 v2(157.44,51.63)
  IN4 w0.147: v2(223.57,35.71) 223.74,35.88 223.74,36.25 223.58,36.41 219.58,36.41 219.44,36.26 219.44,35.56 219.08,35.21 218.56,35.21 218.2,35.56 218.2,36.26 218.06,36.41 212.01,36.41 210.28,34.68 210.28,34.5 v2(210.46,34.31) 210.26,34.11 210.26,33.69 209.96,33.4 205.59,33.4 205.16,32.97 199.56,32.97 199.26,33.26 199.26,33.57 199.11,33.72 198.67,33.72 198.53,33.57 198.53,33.26 198.23,32.97 197.58,32.97 197.29,33.26 197.29,33.57 197.14,33.72 185.24,33.72 183.65,35.31 176.27,35.31 174.73,33.77 164.68,33.77 159.95,38.5
  BOTTOM w0.173: v2(210.46,34.31) 210.28,34.5 210.28,34.81 210.45,34.98 211.17,34.98 211.51,34.64 211.89,34.64 212,34.53 JDIMM4.32 ; JDIMM2.32 225.83,34.53 225.71,34.64 224.2,34.64 223.88,34.96 223.88,35.4 v2(223.57,35.71)
  BOTTOM w0.216: UC1.AK33 v2(157.44,51.63)
DDR_B_DQS#2: length 82
  IN3 w0.165: v2(207.08,39.02) 207.29,39.23 207.29,39.67 207.67,40.05 221.49,40.05 221.64,40.2 221.64,40.41 v2(221.56,40.49)
  IN4 w0.102: 174.27,40.04 173.62,40.04 169.5,44.15 168.13,44.15 168.03,44.05 168.03,43.49 167.81,43.27 167.33,43.27 167.11,43.49 167.11,44.05 167.01,44.15 164.62,44.15 162.74,46.03 162.74,49.64 161.17,51.2 160.88,51.2 160.78,51.1 160.78,50.8 160.88,50.7 v2(161.06,50.7)
  IN4 w0.147: v2(207.08,39.02) 207.34,39.29 207.34,39.89 207.2,40.04 206.03,40.04 205.89,39.89 205.89,39.52 205.59,39.22 204.95,39.22 204.65,39.52 204.65,39.89 204.51,40.04 203.9,40.04 203.75,39.89 203.75,39.74 203.46,39.45 202.81,39.45 202.51,39.74 202.51,39.89 202.37,40.04 174.27,40.04
  BOTTOM w0.102: UC1.AN33 160.64,51.12 v2(161.06,50.7)
  BOTTOM w0.173: JDIMM2.53 219.43,39.78 219.54,39.89 219.59,39.93 220.02,39.93 220.37,40.29 220.37,40.58 220.76,40.97 221.63,40.97 221.75,40.85 221.75,40.68 v2(221.56,40.49) ; v2(207.08,39.02) 207.29,39.23 207.29,39.49 206.9,39.89 205.89,39.89 205.77,39.78 JDIMM4.53
DDR_B_DQS#3: length 81.5
  IN3 w0.165: v2(208.95,44.23) 208.83,44.35 208.83,45.09 209.29,45.55 211.79,45.55 212.72,46.48 215.13,46.48 215.94,47.29 223.3,47.29 223.42,47.17 223.42,46.95 v2(223.23,46.76)
  IN4 w0.102: v2(161.09,55.25) 161.09,55.32 160.99,55.42 160.78,55.42 160.68,55.32 160.68,55 161.7,53.97 163.67,53.97 166.19,51.46 166.93,51.46 167.58,50.81 167.58,49.91 168.85,48.64 171.7,48.64 174.16,46.19 174.27,46.19
  IN4 w0.147: 174.27,46.19 191.27,46.19 191.76,45.7 207.96,45.7 208.78,44.88 208.78,44.4 v2(208.95,44.23)
  BOTTOM w0.173: v2(208.95,44.23) 208.76,44.43 208.76,44.77 209.13,45.14 211.71,45.14 211.83,45.03 212.9,45.03 JDIMM4.74 ; v2(223.23,46.76) 223.45,46.54 223.45,46.24 224.5,45.19 225.66,45.19 225.83,45.03 JDIMM2.74
  BOTTOM w0.216: v2(161.09,55.25) 161.06,55.25 UC1.AN29
DDR_B_DQS#4: length 81.3
  IN3 w0.165: v2(206.89,74.31) 206.76,74.18 206.76,73.81 206.96,73.61 212.2,73.61 212.43,73.38 221.69,73.38 222.02,73.05 222.02,72.77 v2(222.22,72.57)
  IN4 w0.102: 174.27,76.28 174.24,76.28 174.22,76.26 173.3,76.26 172.83,75.79 171.66,75.79 170.68,74.8 167.35,74.8 165.92,73.37 165.29,73.37 164.33,72.41 161.44,72.41 160.3,71.27 160.04,71.27 159.79,71.02 159.79,70.3 v2(160.18,69.92)
  IN4 w0.147: 174.27,76.28 178.22,76.28 178.67,76.73 179.3,76.73 179.75,76.28 180.21,76.28 180.36,76.43 180.36,76.51 180.65,76.8 181.3,76.8 181.59,76.51 181.59,76.43 181.74,76.28 182.18,76.28 182.33,76.43 182.33,76.51 182.62,76.8 183.27,76.8 183.56,76.51 183.56,76.43 183.71,76.28 184.36,76.28 184.51,76.43 184.51,76.51 184.8,76.8 185.45,76.8 185.74,76.51 185.74,76.43 185.89,76.28 186.33,76.28 186.48,76.43 186.48,76.51 186.77,76.8 187.41,76.8 187.71,76.51 187.71,76.43 187.85,76.28 188.3,76.28 188.44,76.43 188.44,76.51 188.74,76.8 189.38,76.8 189.68,76.51 189.68,76.43 189.82,76.28 190.27,76.28 190.41,76.43 190.41,76.51 190.71,76.8 191.36,76.8 191.65,76.51 191.65,76.43 191.8,76.28 192.24,76.28 192.38,76.43 192.38,76.51 192.68,76.8 193.33,76.8 193.62,76.51 193.62,76.43 193.77,76.28 194.21,76.28 194.36,76.43 194.36,76.51 194.65,76.8 195.56,76.8 197.28,75.08 206.41,75.08 206.7,74.78 206.7,74.49 v2(206.89,74.31)
  BOTTOM w0.173: v2(222.22,72.57) 222.04,72.4 222.04,72.18 221.72,71.85 220.62,71.85 220.17,72.31 220.17,72.66 219.94,72.89 219.68,72.89 219.56,72.78 JDIMM2.177 ; JDIMM4.177 205.54,72.78 205.66,72.89 206.25,72.89 206.73,73.37 206.73,74.15 v2(206.89,74.31)
  BOTTOM w0.216: UC1.AN13 v2(160.18,69.92)
DDR_B_DQS#5: length 79.6
  IN3 w0.165: v2(223.81,78.83) 223.91,78.73 223.91,78.5 223.75,78.33 222.07,78.33 221.38,79.02 217.23,79.02 216.98,79.26 212.02,79.26 211.8,79.48 210.59,79.48 210.33,79.22 210.33,78.72 v2(210.15,78.54)
  IN4 w0.102: 174.27,84.38 174.24,84.38 174.22,84.4 172.19,84.4 167.7,79.91 166.39,79.91 165.25,78.76 163.63,78.76 163.08,78.21 163.08,77.57 161.66,76.15 161.27,76.15 161.09,75.97 v2(161.09,75.77)
  IN4 w0.147: 174.27,84.38 178.19,84.38 181.14,81.43 198.1,81.43 198.93,80.6 203.08,80.6 203.57,80.11 209.71,80.11 210.33,79.48 210.33,78.72 v2(210.15,78.54)
  BOTTOM w0.102: UC1.AR8 v2(161.09,75.77)
  BOTTOM w0.173: JDIMM2.198 226.06,78.02 225.95,78.14 225.59,78.14 225.34,77.88 224.31,77.88 223.98,78.21 223.98,78.66 v2(223.81,78.83) ; v2(210.15,78.54) 210.35,78.35 210.35,78.06 210.68,77.73 211.57,77.73 211.87,78.03 JDIMM4.198
DDR_B_DQS#6: length 88.8
  IN3 w0.165: v2(221.86,84.12) 221.67,84.31 221.67,84.5 221.16,85 219.05,85 218.97,85.08 213.03,85.08 212.74,85.37 209.75,85.37 209.14,84.76 208.65,84.76 208.49,84.92 208.49,85.16 208.56,85.23 208.56,86.11 v2(208.51,86.15)
  IN4 w0.102: 167.04,87.31 163.44,83.72 161.19,83.72 161.06,83.59 161.06,82.95 158.98,80.87 158.98,76.41 158.62,76.05 158.51,76.05 158.41,75.94 v2(158.41,75.71)
  IN4 w0.147: 167.04,87.31 167.07,87.31 168.86,89.1 180.15,89.1 181.91,87.34 182.59,87.34 182.88,87.63 182.88,88.78 183.03,88.93 183.47,88.93 183.62,88.78 183.62,87.63 183.91,87.34 195.16,87.34 195.79,86.72 203.2,86.72 203.84,86.08 204.55,86.08 205.15,85.48 208.07,85.48 208.31,85.72 208.31,85.95 v2(208.51,86.15)
  BOTTOM w0.102: UC1.AM8 158.81,76.11 v2(158.41,75.71)
  BOTTOM w0.173: JDIMM2.219 219.47,83.27 219.66,83.46 220.18,83.46 220.33,83.32 221.09,83.32 221.84,84.06 221.84,84.09 v2(221.86,84.12) ; JDIMM4.219 205.77,83.28 205.89,83.39 206.64,83.39 208.33,85.08 208.33,85.97 v2(208.51,86.15)
DDR_B_DQS#7: length 101.1
  IN3 w0.165: v2(209.06,91.53) 209.3,91.3 209.3,91.08 209.66,90.72 219.22,90.72 219.45,90.49 222.24,90.49 222.5,90.23 222.5,89.56 v2(222.49,89.55)
  IN4 w0.102: v2(154.64,77.65) 154.56,77.57 154.3,77.57 154.2,77.67 154.2,78.75 154,78.95 154,81.1 155.27,82.37 155.27,83.19 155.79,83.72 156.43,83.72 156.87,84.16 156.87,86.51 158.95,88.59 158.98,88.59 159,88.61
  IN4 w0.147: 159,88.61 160.46,90.07 160.46,90.48 160.11,90.84 160.11,91.05 160.42,91.36 160.63,91.36 160.98,91.01 161.4,91.01 162.17,91.78 164.85,91.78 166.9,93.83 201.66,93.83 201.8,93.68 201.8,92.85 202.1,92.55 202.74,92.55 203.04,92.85 203.04,94.14 203.18,94.29 205.1,94.29 205.25,94.14 205.25,93.74 205.1,93.59 204.36,93.59 204.07,93.3 204.07,92.59 204.36,92.3 209.35,92.3 209.5,92.15 209.5,91.96 209.49,91.95 v2(209.06,91.53)
  BOTTOM w0.173: v2(222.49,89.55) 222.73,89.3 222.73,88.99 223.09,88.64 225.71,88.64 225.83,88.53 JDIMM2.240 ; JDIMM4.240 212.13,88.53 212.01,88.64 211.65,88.64 210.15,90.15 209.74,90.15 209.16,90.73 209.16,91.37 209.17,91.38 209.17,91.42 v2(209.06,91.53)
  BOTTOM w0.216: UC1.AG6 v2(154.64,77.65)
DDR_B_DRAMRST#: length 51.1
  TOP w0.112: RD62.1 253.31,51.37 252.71,50.77 v2(252.5,50.77) ; CD133.1 211.53,52.27 v2(211.43,52.37)
  IN3 w0.104: v2(252.5,50.77) 245.08,50.77 244.43,50.12 237.65,50.12 236.63,51.14 225.18,51.14 v2(223.95,52.37)
  IN4 w0.084: v2(211.43,52.37) 212.17,53.12 223.21,53.12 v2(223.95,52.37)
  BOTTOM w0.112: JDIMM4.108 212.3,53.53 212.12,53.34 211.91,53.34 211.43,52.85 v2(211.43,52.37) ; JDIMM2.108 226.07,53.53 225.77,53.22 224.8,53.22 v2(223.95,52.37)
DDR_B_MA0: length 80.3
  IN3 w0.216: v2(224.08,61.41) 224.08,61.53 224.5,61.95 225.5,61.95 225.78,62.23 225.78,63.11 225.5,63.4 216.28,63.4 214.65,65.02 v2(214.65,65.22)
  IN4 w0.102: 175.62,64.35 175.35,64.35 174.75,64.95 170.08,64.95 169.05,63.92 160.9,63.92 160.68,63.7 160.68,63.4 160.34,63.05 159.73,63.05 v2(159.27,63.51)
  IN4 w0.173: v2(214.65,65.22) 213.51,64.07 183.59,64.07 183.32,64.35 175.62,64.35
  BOTTOM w0.203: UC1.AL19 v2(159.27,63.51)
  BOTTOM w0.224: JDIMM4.144 213.5,62.53 214.65,63.68 v2(214.65,65.22) ; v2(224.08,61.41) 224.08,61.54 225.06,62.53 JDIMM2.144
DDR_B_MA1: length 80.9
  IN3 w0.216: v2(219.99,61.41) 218.14,61.41 217.6,61.95 209.6,61.95 208.64,60.98 208.64,60.81 206.51,58.69 v2(206.51,58.56)
  IN4 w0.102: 175.62,59.67 174.35,59.67 173.95,59.27 169.12,59.27 168.93,59.45 163.48,59.45 163.22,59.71 160.68,59.71 159.77,60.63 159.77,60.88 159.34,61.31 158.14,61.31 158.01,61.18 158.01,60.92 158.16,60.77 v2(158.35,60.77)
  IN4 w0.173: 175.62,59.67 179.88,59.67 181.84,57.71 185.46,57.71 185.64,57.88 185.64,58.53 185.81,58.7 186.16,58.7 186.33,58.53 186.33,57.88 186.5,57.71 186.85,57.71 187.02,57.88 187.02,58.53 187.19,58.7 187.54,58.7 187.71,58.53 187.71,57.88 187.88,57.71 188.23,57.71 188.4,57.88 188.4,58.53 188.57,58.7 188.92,58.7 189.09,58.53 189.09,57.88 189.26,57.71 189.61,57.71 189.78,57.88 189.78,58.53 189.96,58.7 190.3,58.7 190.47,58.53 190.47,57.88 190.65,57.71 190.99,57.71 191.16,57.88 191.16,58.53 191.34,58.7 191.68,58.7 191.86,58.53 191.86,58.11 192.03,57.94 192.37,57.94 192.55,58.11 192.55,58.53 192.72,58.7 206.38,58.7 v2(206.51,58.56)
  BOTTOM w0.203: UC1.AL22 v2(158.35,60.77)
  BOTTOM w0.224: JDIMM2.133 218.7,59.78 219.72,59.78 219.99,60.04 v2(219.99,61.41) ; v2(206.51,58.56) 206.5,58.58 206.5,59.36 206.08,59.78 JDIMM4.133
DDR_B_MA2: length 77.5
  IN3 w0.216: v2(211.28,58.57) 212.88,58.57 213.34,59.03 219.49,59.03 219.98,58.55 224.46,58.55 225.34,59.43 v2(225.34,59.88)
  IN4 w0.102: v2(160.18,60.77) 160.73,60.22 163.99,60.22 164.55,59.65 173.45,59.65 173.9,60.11 175.62,60.11
  IN4 w0.173: 175.62,60.11 180.03,60.11 182.1,58.04 182.38,58.04 182.55,58.21 182.55,58.85 182.72,59.03 183.07,59.03 183.24,58.85 183.24,58.21 183.41,58.04 183.76,58.04 183.93,58.21 183.93,58.85 184.1,59.03 184.45,59.03 184.62,58.85 184.62,58.21 184.79,58.04 185.14,58.04 185.31,58.21 185.31,58.85 185.49,59.03 207.79,59.03 208.47,59.7 210.86,59.7 211.23,59.33 211.23,58.62 v2(211.28,58.57)
  BOTTOM w0.102: UC1.AM22 v2(160.18,60.77)
  BOTTOM w0.224: v2(225.34,59.88) 225.7,59.53 JDIMM2.132 ; JDIMM4.132 211.93,59.53 211.28,58.87 v2(211.28,58.57)
DDR_B_MA3: length 79.5
  IN3 w0.216: v2(220.67,59.88) 220.67,60.01 220.45,60.22 212.81,60.22 212.59,60.44 212.59,61.28 212.38,61.49 211.95,61.49 211.73,61.28 211.73,60.44 211.51,60.22 208.79,60.22 207.68,59.12 v2(207.68,58.57)
  IN4 w0.102: 175.62,59.22 174.67,59.22 174.28,58.84 169.05,58.84 168.81,58.6 163.95,58.6 163.09,59.46 160.58,59.46 v2(159.27,60.77)
  IN4 w0.173: v2(207.68,58.57) 207.68,58.52 207.28,58.12 205.71,58.12 205.46,58.37 195.88,58.37 195.71,58.2 195.71,57.56 195.53,57.39 195.12,57.39 194.94,57.56 194.94,58.2 194.77,58.37 194.43,58.37 194.25,58.2 194.25,57.56 194.08,57.39 193.74,57.39 193.56,57.56 193.56,58.2 193.39,58.37 193.04,58.37 192.87,58.2 192.87,57.56 192.7,57.39 183.09,57.39 182.91,57.21 182.91,56.61 182.74,56.44 182.39,56.44 182.22,56.61 182.22,57.21 182.05,57.39 181.57,57.39 179.74,59.22 175.62,59.22
  BOTTOM w0.102: UC1.AM23 v2(159.27,60.77)
  BOTTOM w0.224: v2(207.68,58.57) 207.68,58.25 207.38,57.95 206.44,57.95 206.02,58.37 206.02,58.95 205.7,59.28 JDIMM4.131 ; v2(220.67,59.88) 220.06,59.28 JDIMM2.131
DDR_B_MA4: length 79.4
  IN3 w0.216: v2(224.17,59.88) 224.17,59.63 223.59,59.05 220.09,59.05 219.74,59.4 213.09,59.4 212.73,59.03 210.32,59.03 210.04,58.75 v2(210.04,58.57)
  IN4 w0.102: v2(162.97,58.94) 162.97,58.16 163.51,57.62 173.95,57.62 175.11,58.78 175.62,58.78
  IN4 w0.173: v2(210.04,58.57) 210.04,58.8 209.81,59.03 208.68,59.03 208.3,58.66 208.3,58.17 207.82,57.69 196.3,57.69 195.67,57.06 186.21,57.06 186.04,56.89 186.04,56.41 185.86,56.23 185.52,56.23 185.35,56.41 185.35,56.89 185.17,57.06 184.79,57.06 184.62,56.89 184.62,56.28 184.45,56.11 184.1,56.11 183.93,56.28 183.93,56.89 183.76,57.06 183.41,57.06 183.24,56.89 183.24,56.28 183.06,56.11 182.26,56.11 179.59,58.78 175.62,58.78
  BOTTOM w0.102: UC1.AP23 162.03,59.84 162.71,59.84 162.97,59.59 v2(162.97,58.94)
  BOTTOM w0.224: v2(210.04,58.57) 210.04,58.38 210.34,58.09 211.48,58.09 211.92,58.53 JDIMM4.128 ; JDIMM2.128 224.58,58.53 224.08,59.03 224.08,59.79 v2(224.17,59.88)
DDR_B_MA5: length 83
  IN3 w0.216: v2(223,59.88) 223,59.63 222.79,59.42 220.34,59.42 219.98,59.77 212.85,59.77 212.55,59.47 209.3,59.47 208.87,59.04 v2(208.87,58.57)
  IN4 w0.102: 175.62,58.33 175.17,58.33 174.04,57.2 160.27,57.2 159.68,57.78 159.68,59.44 v2(159.27,59.86)
  IN4 w0.173: v2(208.87,58.57) 208.87,58.15 208,57.28 196.36,57.28 195.82,56.74 189.27,56.74 189.09,56.56 189.09,56.28 188.92,56.11 188.58,56.11 188.4,56.28 188.4,56.56 188.23,56.74 187.88,56.74 187.71,56.56 187.71,55.96 187.54,55.79 187.19,55.79 187.02,55.96 187.02,56.56 186.85,56.74 186.53,56.74 186.36,56.56 186.36,55.96 186.19,55.79 182,55.79 179.45,58.33 175.62,58.33
  BOTTOM w0.203: UC1.AL23 v2(159.27,59.86)
  BOTTOM w0.224: v2(223,59.88) 223,59.11 224.09,58.03 JDIMM2.126 ; v2(208.87,58.57) 208.87,58.49 209.65,57.71 211.64,57.71 211.95,58.03 212.9,58.03 JDIMM4.126
DDR_B_MA6: length 72.2
  IN3 w0.216: v2(221.33,57.22) 220.61,57.95 208.2,57.95 207.8,57.54 207.8,56.49 v2(207.96,56.33)
  IN4 w0.102: 175.62,57.92 175.5,57.92 175.47,57.88 175.23,57.88 174.27,56.92 172.57,56.92 v2(171.82,56.17)
  IN4 w0.173: v2(207.96,56.33) 207.97,56.33 208.05,56.41 208.05,56.69 207.88,56.86 204.98,56.86 204.41,56.29 203.8,56.29 203.22,56.86 196.4,56.86 195.95,56.41 192.35,56.41 192.18,56.24 192.18,55.63 192.01,55.46 191.66,55.46 191.49,55.63 191.49,56.24 191.32,56.41 190.97,56.41 190.8,56.24 190.8,55.63 190.63,55.46 190.28,55.46 190.11,55.63 190.11,56.24 189.93,56.41 189.59,56.41 189.42,56.24 189.42,55.63 189.24,55.46 181.73,55.46 179.28,57.92 175.62,57.92
  BOTTOM w0.102: UC1.AW26 166.7,58.15 168.19,58.15 169.42,56.92 171.08,56.92 v2(171.82,56.17)
  BOTTOM w0.224: JDIMM4.127 205.55,58.28 206.3,57.53 207.01,57.53 207.95,56.59 207.95,56.34 v2(207.96,56.33) ; v2(221.33,57.22) 220.28,58.28 JDIMM2.127
DDR_B_MA7: length 69.6
  IN3 w0.216: v2(225.56,57.22) 225.56,57.54 225.17,57.94 222.91,57.94 221.73,56.76 210.99,56.76 v2(210.72,57.03)
  IN4 w0.102: 175.62,55.65 173.63,55.65 173.13,55.14 172.29,55.14 v2(171.91,54.76)
  IN4 w0.173: 175.62,55.65 179.9,55.65 181.07,54.49 196.06,54.49 196.62,55.05 204.93,55.05 205.24,55.36 211.96,55.36 212.13,55.54 212.13,56.12 211.91,56.33 211.04,56.33 210.72,56.65 v2(210.72,57.03)
  BOTTOM w0.102: v2(171.91,54.76) 171.02,55.65 169.98,55.65 168.06,57.57 UC1.AY26
  BOTTOM w0.224: v2(210.72,57.03) 212.9,57.03 JDIMM4.122 ; v2(225.56,57.22) 225.76,57.03 JDIMM2.122
DDR_B_MA8: length 73
  IN3 w0.216: v2(219.99,57.22) 219.63,57.58 216.17,57.58 215.96,57.36 215.96,57.34 215.74,57.13 215.31,57.13 215.09,57.34 215.09,57.36 214.88,57.58 214.45,57.58 214.23,57.36 214.23,57.34 214.01,57.13 213.58,57.13 213.37,57.34 213.37,57.36 213.15,57.58 212.72,57.58 212.5,57.36 212.5,57.34 212.29,57.13 211.85,57.13 211.64,57.34 211.64,57.36 211.42,57.58 209.09,57.58 208.42,56.91 208.42,56.14 207.81,55.53 206.95,55.53 206.69,55.79 v2(206.69,56.33)
  IN4 w0.102: v2(170.45,56.24) 170.99,55.7 172.74,55.7 173.71,56.67 174.65,56.67 175.42,57.44 175.47,57.44 175.5,57.47 175.62,57.47
  IN4 w0.173: 175.62,57.47 179.13,57.47 181.47,55.14 192.64,55.14 192.82,55.31 192.82,55.91 192.99,56.09 193.33,56.09 193.51,55.91 193.51,55.31 193.68,55.14 194.03,55.14 194.2,55.31 194.2,55.91 194.37,56.09 194.72,56.09 194.89,55.91 194.89,55.31 195.06,55.14 195.56,55.14 195.73,55.31 195.73,55.88 195.9,56.06 196.81,56.06 196.98,56.23 196.98,56.36 197.16,56.54 197.5,56.54 197.67,56.36 197.67,56.05 197.85,55.87 198.19,55.87 198.36,56.05 198.36,56.36 198.54,56.54 198.88,56.54 199.06,56.36 199.06,56.05 199.23,55.87 199.57,55.87 199.75,56.05 199.75,56.36 199.92,56.54 200.26,56.54 200.44,56.36 200.44,56.05 200.61,55.87 204.58,55.87 205.04,56.33 v2(206.69,56.33)
  BOTTOM w0.102: v2(170.45,56.24) 170.02,56.67 169.28,56.67 168.04,57.91 166.81,57.91 166.59,57.69 166.59,57.43 166.39,57.23 165.02,57.23 164.68,57.57 UC1.AU26
  BOTTOM w0.224: JDIMM2.125 218.7,57.78 219.59,57.78 219.99,57.38 v2(219.99,57.22) ; v2(206.69,56.33) 206.69,56.56 205.48,57.78 204.7,57.78 JDIMM4.125
DDR_B_MA9: length 71.7
  IN3 w0.216: v2(208.32,54.27) 208.32,54.29 209.16,55.13 212.86,55.13 213.34,55.61 214.64,55.61 214.86,55.4 214.86,55.24 215.07,55.02 215.51,55.02 215.72,55.24 215.72,55.4 215.94,55.61 218.09,55.61 218.3,55.4 218.3,55.24 218.52,55.02 218.95,55.02 219.17,55.24 219.17,55.4 219.38,55.61 219.84,55.61 220.12,55.33 221.4,55.33 221.72,55.65 v2(221.72,55.8)
  IN4 w0.102: v2(169.32,54.89) 169.34,54.89 169.87,54.35 172.74,54.35 173.66,55.27 175.62,55.27
  IN4 w0.173: v2(208.32,54.27) 208.32,54.74 208.11,54.95 205.42,54.95 205.1,54.63 196.66,54.63 196.19,54.16 179.83,54.16 179.65,54.33 179.65,55.1 179.48,55.27 179.13,55.27 178.96,55.1 178.96,54.45 178.79,54.28 178.44,54.28 178.27,54.45 178.27,55.1 178.1,55.27 175.62,55.27
  BOTTOM w0.102: UC1.AW27 166.51,56.66 166.85,56.99 167.43,56.99 167.52,57.08 167.84,57.08 169.32,55.6 v2(169.32,54.89)
  BOTTOM w0.224: JDIMM4.121 204.7,56.78 205.53,56.78 207.24,55.07 207.67,55.07 208.32,54.41 v2(208.32,54.27) ; v2(221.72,55.8) 221.72,56 221.07,56.65 219.81,56.65 219.69,56.78 218.7,56.78 JDIMM2.121
DDR_B_MA10: length 78.4
  IN3 w0.216: v2(215.82,65.22) 217.2,63.84 225.82,63.84 226.24,64.26 226.24,65.5 225.98,65.76 225.04,65.76 224.66,65.38 v2(224.66,65.22)
  IN4 w0.102: 175.62,66.75 174.29,66.75 173.8,66.27 169.45,66.27 168.86,65.68 167.52,65.68 166.77,64.93 162.31,64.93 v2(162.01,65.23)
  IN4 w0.173: 175.62,66.75 176.14,66.75 177,67.61 184.04,67.61 185.17,66.49 208.48,66.49 209.48,67.49 212.39,67.49 213.87,66.01 215.07,66.01 215.82,65.26 v2(215.82,65.22)
  BOTTOM w0.102: v2(162.01,65.23) 161.65,64.89 UC1.AP18
  BOTTOM w0.224: v2(215.82,65.22) 215.82,65.5 215.34,65.99 214.77,65.99 214.1,65.32 214.1,65.25 213.87,65.03 JDIMM4.146 ; JDIMM2.146 226.9,65.03 225.76,65.03 225.45,64.72 224.99,64.72 224.66,65.05 v2(224.66,65.22)
DDR_B_MA11: length 75.8
  IN3 w0.216: v2(224.29,57.22) 222.96,57.22 222.13,56.39 212.89,56.39 212.37,55.87 209.68,55.87 209.45,56.1 v2(209.45,57.03)
  IN4 w0.102: v2(170.71,54.76) 171.35,55.4 173.02,55.4 174.01,56.38 174.8,56.38 175.45,57.03 175.62,57.03
  IN4 w0.173: v2(209.45,57.03) 209.45,56.38 208.85,55.78 205.07,55.78 204.75,55.46 196.57,55.46 195.92,54.81 181.2,54.81 178.99,57.03 178.34,57.03 178.17,56.85 178.17,56.35 177.97,56.15 177.65,56.15 177.48,56.33 177.48,56.85 177.31,57.03 176.96,57.03 176.79,56.85 176.79,56.35 176.59,56.15 176.27,56.15 176.1,56.33 176.1,56.85 175.93,57.03 175.62,57.03
  BOTTOM w0.102: v2(170.71,54.76) 170.71,55.27 170.59,55.4 169.88,55.4 167.95,57.33 167.39,57.33 167.3,57.23 166.73,57.23 166.49,56.99 165.02,56.99 164.68,56.66 UC1.AU27
  BOTTOM w0.224: JDIMM4.120 209.71,56.53 209.45,56.78 v2(209.45,57.03) ; v2(224.29,57.22) 224.29,57.11 224.88,56.53 JDIMM2.120
DDR_B_MA12: length 72.8
  IN3 w0.216: v2(207.05,54.27) 206.96,54.18 206.64,54.18 206.43,54.39 206.43,54.89 206.64,55.1 208.34,55.1 208.74,55.5 212.62,55.5 213.09,55.98 220.31,55.98 v2(220.49,55.8)
  IN4 w0.102: v2(168.55,55.78) 168.48,55.7 168.48,54.68 169.07,54.09 172.26,54.09
  IN4 w0.173: 172.26,54.09 173.09,54.09 173.35,54.35 175.62,54.35 176.14,53.84 176.68,53.84 176.85,54.01 176.85,54.77 177.03,54.94 177.37,54.94 177.54,54.77 177.54,54.01 177.72,53.84 187.54,53.84 187.71,53.66 187.71,53.49 187.89,53.31 188.23,53.31 188.4,53.49 188.4,53.66 188.58,53.84 188.92,53.84 189.09,53.66 189.09,53.33 189.27,53.16 189.61,53.16 189.78,53.33 189.78,53.66 189.96,53.84 190.45,53.84 190.62,53.66 190.62,53.33 190.79,53.16 191.14,53.16 191.31,53.33 191.31,53.66 191.48,53.84 191.83,53.84 192,53.66 192,53.33 192.17,53.16 192.52,53.16 192.69,53.33 192.69,53.66 192.86,53.84 193.21,53.84 193.38,53.66 193.38,53.33 193.55,53.16 193.9,53.16 194.07,53.33 194.07,53.66 194.25,53.84 194.59,53.84 194.76,53.66 194.76,53.33 194.94,53.16 195.28,53.16 195.45,53.33 195.45,53.66 195.63,53.84 196.33,53.84 196.71,54.22 205.27,54.22 205.59,54.54 206.78,54.54 v2(207.05,54.27)
  BOTTOM w0.102: v2(168.55,55.78) 168.05,55.78 167.5,56.32 165.91,56.32 165.57,56.66 UC1.AV27
  BOTTOM w0.224: v2(207.05,54.27) 207.05,54.72 205.49,56.28 JDIMM4.119 ; JDIMM2.119 220.01,56.28 v2(220.49,55.8)
DDR_B_MA13: length 72.6
  IN3 w0.216: v2(211.55,68.46) 213.16,68.46 213.66,68.96 219.4,68.96 219.86,69.42 224.28,69.42 225.07,68.62 v2(225.07,68.46)
  IN4 w0.102: 172.41,72.21 172.04,72.21 171.83,71.99 168.57,71.99 164.99,68.42 164.39,68.42 164.33,68.48 163.3,68.48 v2(162.92,68.1)
  IN4 w0.173: 172.41,72.21 173,72.21 173.17,72.04 173.17,71.19 173.34,71.01 173.69,71.01 173.86,71.19 173.86,71.73 174.03,71.9 194.5,71.9 196.34,70.06 209.3,70.06 210.44,68.92 211.17,68.92 211.55,68.54 v2(211.55,68.46)
  BOTTOM w0.102: UC1.AR15 162.47,67.64 v2(162.92,68.1)
  BOTTOM w0.224: JDIMM4.158 211.98,68.03 v2(211.55,68.46) ; v2(225.07,68.46) 225.07,68.06 225.39,67.74 225.81,67.74 226.09,68.03 226.9,68.03 JDIMM2.158
DDR_B_ODT0: length 68.4
  IN4 w0.102: 175.62,69.41 175.31,69.41 175.28,69.38 170.84,69.38 170.81,69.35 169.47,69.35 169.02,68.9 168.55,68.9 166.89,67.23 163.22,67.23 162.5,66.51 161.98,66.51 161.43,67.06 161.43,67.38 161.21,67.6 160.89,67.6 160.46,67.17 v2(159.27,67.17)
  IN4 w0.135: v2(207.46,68.46) 207.46,68.81 207.33,68.94 195.88,68.94 194.15,70.66 185.53,70.66 185.4,70.53 185.4,69.54 185.26,69.41 184.99,69.41 184.86,69.54 184.86,70.64 184.73,70.78 184.46,70.78 184.32,70.64 184.32,69.54 184.19,69.41 183.92,69.41 183.78,69.54 183.78,70.64 183.65,70.78 183.38,70.78 183.24,70.64 183.24,69.54 183.11,69.41 182.84,69.41 182.7,69.54 182.7,70.64 182.57,70.78 182.3,70.78 182.17,70.64 182.17,69.54 182.03,69.41 181.76,69.41 181.63,69.54 181.63,70.64 181.49,70.78 181.22,70.78 181.09,70.64 181.09,69.54 180.95,69.41 180.68,69.41 180.55,69.54 180.55,70.64 180.42,70.78 180.15,70.78 180.01,70.64 180.01,69.54 179.88,69.41 175.62,69.41
  BOTTOM w0.175: JDIMM4.155 205.71,67.28 205.82,67.38 206.3,67.87 206.87,67.87 v2(207.46,68.46)
  BOTTOM w0.267: UC1.AM16 v2(159.27,67.17)
DDR_B_ODT1: length 68.9
  IN4 w0.102: v2(158.35,67.17) 158.76,67.58 160.58,67.58 160.81,67.8 161.29,67.8 161.63,67.46 161.63,67.15 162.06,66.71 162.41,66.71 163.14,67.44 166.8,67.44 168.47,69.1 168.93,69.1 169.39,69.56 170.1,69.56 170.29,69.75 175.62,69.75
  IN4 w0.135: 175.62,69.75 176.28,69.75 176.42,69.88 176.42,70.98 176.55,71.12 176.82,71.12 176.96,70.98 176.96,69.88 177.09,69.75 177.36,69.75 177.5,69.88 177.5,70.98 177.63,71.12 177.9,71.12 178.03,70.98 178.03,69.88 178.17,69.75 178.44,69.75 178.57,69.88 178.57,70.98 178.71,71.12 179,71.12 179.14,70.98 179.14,69.88 179.27,69.75 179.54,69.75 179.67,69.88 179.67,70.98 179.81,71.12 194.18,71.12 196.02,69.28 207.52,69.28 207.91,68.88 208.23,68.88 208.62,69.28 208.97,69.28 209.24,69.01 209.24,68.45 209.14,68.35 208.84,68.35 v2(208.73,68.46)
  BOTTOM w0.175: JDIMM4.161 204.7,68.78 205.61,68.78 205.84,69.01 208.18,69.01 v2(208.73,68.46)
  BOTTOM w0.267: UC1.AL16 v2(158.35,67.17)
DDR_B_ODT2: length 82.9
  IN4 w0.102: 175.62,72.45 172,72.45 171.75,72.2 168.49,72.2 164.91,68.62 164.47,68.62 164.41,68.68 162.79,68.68 162.17,68.06 v2(162.04,68.06)
  IN4 w0.135: v2(221.52,68.46) 221.5,68.46 220.96,67.92 220.46,67.92 220.32,67.78 220.32,66.05 220.19,65.91 219.92,65.91 219.79,66.05 219.79,67.78 219.65,67.92 219.38,67.92 219.25,67.78 219.25,66.05 219.11,65.91 218.84,65.91 218.71,66.05 218.71,67.78 218.57,67.92 218.29,67.92 218.15,67.78 218.15,66.28 218.02,66.14 217.75,66.14 217.61,66.28 217.61,67.78 217.48,67.92 217.21,67.92 217.07,67.78 217.07,67.11 216.94,66.98 216.67,66.98 216.54,67.11 216.54,67.78 216.4,67.92 216.13,67.92 216,67.78 216,67.11 215.86,66.98 215.59,66.98 215.46,67.11 215.46,67.78 215.32,67.92 215.06,67.92 214.92,67.78 214.92,67.11 214.79,66.98 214.52,66.98 214.38,67.11 214.38,67.78 214.25,67.92 213.84,67.92 213.47,68.29 212.45,68.29 210.2,70.54 196.52,70.54 194.6,72.45 175.62,72.45
  BOTTOM w0.102: UC1.AP15 161.61,67.63 v2(162.04,68.06)
  BOTTOM w0.175: JDIMM2.155 220.54,67.27 221.52,68.25 v2(221.52,68.46)
DDR_B_ODT3: length 85.3
  IN4 w0.102: 175.62,73.12 172.1,73.12 171.58,72.6 168.32,72.6 167.18,71.46 166.27,71.46 165.19,70.38 164.49,70.38 163.35,69.24 162.04,69.24 161.38,68.58 159.77,68.58 v2(159.27,68.08)
  IN4 w0.135: v2(220.29,68.46) 220.29,69.7 220.2,69.79 220.2,70.54 220.38,70.72 221.45,70.72 221.59,70.86 221.59,71.95 221.45,72.08 220.05,72.08 219.72,72.41 217.5,72.41 217.37,72.28 217.37,70.64 217.23,70.5 216.96,70.5 216.83,70.64 216.83,72.29 216.69,72.42 216.42,72.42 216.29,72.29 216.29,70.64 216.15,70.5 215.88,70.5 215.75,70.64 215.75,72.27 215.62,72.41 215.35,72.41 215.21,72.27 215.21,70.64 215.08,70.5 214.81,70.5 214.67,70.64 214.67,72.27 214.54,72.41 214.27,72.41 214.13,72.27 214.13,70.64 214,70.5 213.72,70.5 213.58,70.64 213.58,71.08 213.45,71.21 196.86,71.21 194.93,73.14 175.63,73.14 175.62,73.12
  BOTTOM w0.102: UC1.AL15 158.82,67.63 v2(159.27,68.08)
  BOTTOM w0.175: JDIMM2.161 219.97,68.78 v2(220.29,68.46)
DDR_B_PAR: length 74.8
  IN3 w0.216: v2(207.67,65.22) 207.67,65.07 208.46,64.28 214.78,64.28 216.17,62.89 219.91,62.89 221.16,61.64 v2(221.16,61.41)
  IN4 w0.102: 175.62,64.75 175.45,64.75 175,65.2 170.05,65.2 168.96,64.12 160.51,64.12 160.36,63.97 158.8,63.97 v2(158.35,63.51)
  IN4 w0.173: v2(207.67,65.22) 206.85,64.4 183.73,64.4 183.37,64.75 175.62,64.75
  BOTTOM w0.14: UC1.AL20 v2(158.35,63.51)
  BOTTOM w0.224: JDIMM4.143 205.48,62.28 205.68,62.47 206.69,62.47 207.67,63.45 v2(207.67,65.22) ; v2(221.16,61.41) 221.16,61.72 220.6,62.28 JDIMM2.143
DDR_B_RAS#: length 78.4
  IN3 w0.216: v2(210.33,67.02) 213.19,67.02 213.4,67.23 221.74,67.23 222.74,68.23 v2(222.74,68.46)
  IN4 w0.102: 175.62,66.33 174.16,66.33 173.89,66.06 169.53,66.06 168.9,65.43 167.55,65.43 166.86,64.73 161.55,64.73 v2(161.09,65.19)
  IN4 w0.173: v2(210.33,67.02) 209.31,66 205.7,66 205.07,65.38 194.22,65.38 194.05,65.55 194.05,65.99 193.88,66.16 193.53,66.16 193.36,65.99 193.36,65.55 193.19,65.38 192.84,65.38 192.67,65.55 192.67,65.99 192.5,66.16 192.15,66.16 191.98,65.99 191.98,65.55 191.8,65.38 191.46,65.38 191.29,65.55 191.29,65.99 191.11,66.16 190.77,66.16 190.6,65.99 190.6,65.55 190.42,65.38 190.08,65.38 189.9,65.55 189.9,65.99 189.73,66.16 189.39,66.16 189.21,65.99 189.21,65.55 189.04,65.38 188.54,65.38 187.75,66.16 185.03,66.16 183.91,67.29 177.14,67.29 176.17,66.32 175.63,66.32 175.62,66.33
  BOTTOM w0.102: UC1.AN18 160.78,64.89 v2(161.09,65.19)
  BOTTOM w0.224: v2(222.74,68.46) 222.74,68.04 224.25,66.53 JDIMM2.152 ; v2(210.33,67.02) 210.48,66.88 211.81,66.88 212.16,66.53 JDIMM4.152
DDR_B_WE#: length 80.3
  IN3 w0.216: v2(206.22,67.02) 206.22,66.6 206.6,66.22 213,66.22 213.45,66.67 220.01,66.67 221.06,65.62 221.13,65.46 v2(221.13,65.2)
  IN4 w0.102: v2(159.23,65.38) 159.69,64.92 160.33,64.92 160.63,65.22 160.63,65.38 160.93,65.68 161.35,65.68 161.37,65.7 162.84,65.7 162.86,65.72 166.95,65.72 167.28,66.06 168.96,66.06 169.41,66.51 173.65,66.51 174.31,67.17 175.62,67.17
  IN4 w0.173: v2(206.22,67.02) 206.01,66.82 204.06,66.82 203.41,67.47 200.59,67.47 200.41,67.29 200.41,67.02 200.24,66.85 199.9,66.85 199.72,67.02 199.72,67.29 199.55,67.47 199.21,67.47 199.03,67.29 199.03,66.99 198.86,66.82 198.51,66.82 198.34,66.99 198.34,67.29 198.17,67.47 197.82,67.47 197.65,67.29 197.65,66.99 197.48,66.82 197.13,66.82 196.96,66.99 196.96,67.29 196.79,67.47 196.44,67.47 196.27,67.29 196.27,66.99 196.1,66.82 195.75,66.82 195.58,66.99 195.58,67.24 195.41,67.41 195.1,67.41 194.93,67.24 194.93,66.99 194.75,66.82 194.41,66.82 194.23,66.99 194.23,67.24 194.06,67.41 193.72,67.41 193.54,67.24 193.54,66.99 193.37,66.82 193.03,66.82 192.85,66.99 192.85,67.24 192.68,67.41 192.33,67.41 192.16,67.24 192.16,66.99 191.99,66.82 191.64,66.82 191.47,66.99 191.47,67.24 191.3,67.41 190.95,67.41 190.78,67.24 190.78,66.99 190.61,66.82 190.26,66.82 190.09,66.99 190.09,67.24 189.92,67.41 189.57,67.41 189.4,67.24 189.4,66.99 189.23,66.82 188.88,66.82 188.71,66.99 188.71,67.24 188.53,67.41 188.19,67.41 188.02,67.24 188.02,66.99 187.84,66.82 187.5,66.82 187.33,66.99 187.33,67.24 187.15,67.41 186.51,67.41 186.34,67.24 186.34,66.99 186.16,66.82 185.82,66.82 185.65,66.99 185.65,67.24 185.47,67.41 184.71,67.41 184.18,67.94 176.87,67.94 176.1,67.17 175.62,67.17
  BOTTOM w0.203: UC1.AL17 v2(159.23,65.38)
  BOTTOM w0.224: JDIMM4.151 205.56,66.28 205.8,66.52 205.97,66.52 206.25,66.79 206.25,66.99 v2(206.22,67.02) ; JDIMM2.151 219.56,66.27 219.64,66.36 220.33,66.36 221.09,65.6 221.13,65.5 v2(221.13,65.2)
DDR_VTT_CNTL: length 40.1
  TOP w0.112: v2(174.62,35.65) 175.03,35.24 v1(175.03,34.25) UC2.2
  BOTTOM w0.102: UC1.AC36 151.99,47.93 151.99,47.01 152.06,46.93 152.06,44.03 151.8,43.77 151.8,39.43
  BOTTOM w0.127: v2(174.62,35.65) 170.97,32 159.23,32 151.8,39.43
DEBUG_CTL1: length 2.8
  TOP w0.112: RT66.2 41.01,45.36 v1(41.51,45.85) 41.76,46.1 v2(42.3,46.1)
  BOTTOM w0.076: v2(42.3,46.1) 42.42,46.1 42.79,46.48 UT4.E4
DEBUG_CTL2: length 2.4
  TOP w0.112: v2(42.74,45.61) 42.72,45.59 41.91,45.59 41.6,45.28 RT67.2
  BOTTOM w0.076: v2(42.74,45.61) 43.2,46.07 UT4.D5
DEMB0: length 2.1
  BOTTOM w0.112: UM8.53 176.54,179.3 177.13,178.71 RM75.2 RM79.2
DEMB1: length 2.8
  BOTTOM w0.112: UM8.54 176.54,178.8 176.75,178.59 176.75,177.82 177.02,177.54 RM86.2 RM62.2
DEPOP#_EC: length 282.6
  TOP w0.112: UE5.55 301.94,9.04 302.25,8.73 v2(302.25,8.55) ; v2(284.7,5.42) v1(285.46,5.42) 285.53,5.42 285.72,5.62 RE688.2
  IN3 w0.104: v2(40.94,13.48) 41.72,12.7 42.47,12.7 46.38,8.79 58.72,8.79 61.93,5.58 93.82,5.58 96.82,8.58 108.31,8.58 111.18,5.72 111.31,5.58 118.63,5.58 120.76,3.45 125.24,3.45 125.47,3.68 165.26,3.68 167.26,1.68 186.58,1.68 187.25,2.36 188.44,2.36 189.12,1.68 194.63,1.68 196.63,3.68 218.31,3.68 219.37,2.62 222.22,2.62 223.29,3.68 241,3.68 241.27,3.41 241.54,3.14 243,1.68 243.19,1.68 275.75,1.68 279.85,5.78 284.34,5.78 v2(284.7,5.42) 285.96,4.16 289.69,4.16 292.54,7.01 295.15,7.01 296.45,8.3 296.45,8.85 296.87,9.27 301.86,9.27 302.25,8.88 v2(302.25,8.55)
  BOTTOM w0.112: v2(40.94,13.48) 40.67,13.48 40.06,14.1 JAUDIO.6
DEVSLP0: length 66.8
  TOP w0.089: 260.2,57.03 260.28,57.03 260.62,57.36 265.97,57.36 267.36,55.97 267.93,55.97 267.98,55.92 268.29,55.92 268.34,55.97 268.98,55.97 269.16,56.14 UH1.AL48
  TOP w0.127: v2(257.29,51.14) v1(257.29,51.65) 257.29,51.93 258.18,52.82 258.18,55.01 258.43,55.26 258.43,55.26 260.2,57.03
  BOTTOM w0.112: JHDD.7 259.05,6.69 258.86,6.88 257.97,6.88 255.33,9.52 255.33,12.23 255.91,12.81 255.91,13.15 255.11,13.94 255.11,23.02 256.12,24.02 256.12,25.95 257.51,27.35 257.51,36.13 256.63,37.02 256.63,50.48 v2(257.29,51.14)
DEVSLP1: length 165.2
  TOP w0.089: v2(275.4,55.33) 275.75,54.98 UH1.AH35
  IN1 w0.084: JSSD2.38 378.7,10.69 377.62,11.77 363.1,11.77 362.67,11.35 354.83,11.35 352.59,9.1 350.18,9.1 346.05,4.98 343.5,4.98 v2(341.98,3.45)
  BOTTOM w0.112: v2(275.4,55.33) 275.02,54.95 274.7,54.95 273.8,54.05 273.8,51.11 273.53,50.84 273.1,50.84 272.21,49.95 272.21,49.62 272.22,49.62 272.22,49.27 272.21,49.27 272.21,48.73 271.76,48.28 270.94,48.28 270.29,47.64 270.29,47.19 270.39,47.09 270.39,43.91 270.67,43.64 271.12,43.64 272.13,42.62 272.13,40.28 275.84,36.57 279.36,36.57 280.35,35.58 282.44,35.58 282.93,35.09 282.93,33.04 283.4,32.57 283.4,32.25 288.58,27.07 289.21,27.07 291.55,24.74 294.03,24.74 294.72,25.42 297.89,25.42 298.87,24.44 298.87,23.75 299.82,22.81 301.26,22.81 303.15,24.7 304.91,24.7 306.4,23.21 306.4,20.68 314.48,12.6 314.48,7.39 310.87,3.78 310.87,2.23 v1(311.08,2.02) 311.61,1.5 340.02,1.5 v2(341.98,3.45)
DEVSLP4: length 132.9
  TOP w0.089: v2(267.9,58.57) 268.35,58.12 269.63,58.12 UH1.AR47
  IN3 w0.104: v2(345.22,21.74) 344.14,22.82 339.14,22.82 338.04,23.92 337.36,24.6 333.44,24.6 333.17,24.33 330.77,21.93 328.68,21.93 327.59,20.84 314.79,20.84 312.45,23.18 312.45,23.39 309.68,26.16 306.86,26.16 305.07,27.94 304.32,27.94 301.4,30.86 301.4,31.39 298.89,33.9 294.94,33.9 293.81,35.03 292.4,35.03 291.57,35.87 291.57,53.19 291.77,53.39 291.77,56.52 290.58,57.7 290.58,59.85 288.9,61.53 288.9,62.65 288.28,63.28 278.61,63.28 278.33,63 278.33,61.11 277.23,60 276.42,60 276.19,59.78 274.85,59.78 274.22,59.15 273.66,59.15 273.27,58.76 272.68,58.76 272.1,59.34 269.4,59.34 268.63,58.57 v2(267.9,58.57)
  BOTTOM w0.112: v2(345.22,21.74) 345.22,20.54 346.05,19.71 v1(347.25,19.71) 352.07,19.71 355.14,16.65 JSSD1.38
DGPU_HOLD_RST#: length 157.1
  TOP w0.089: v2(283.43,61.01) 283.12,61.32 UH1.BB20
  IN1 w0.084: v2(182.27,125.88) 182.36,125.79 182.36,124.58 183.04,123.9 191.12,123.9 206.22,108.8 214.84,108.8 216.28,107.36 230.29,107.36 231.04,108.1 234.49,108.1 235.68,106.9 251.48,106.9 251.89,106.49 264.21,106.49 284.19,86.52 284.19,79.4 284.57,79.02 284.57,76.08 284.22,75.73 284.22,75.36 283.79,74.93 283.79,73.54 283.02,72.77 283.02,71.11 282.9,70.99 282.78,70.99 282.55,70.76 282.55,70.64 282.54,70.63 282.54,69.83 283.56,68.82 283.56,68.32 283.35,68.11 282.61,68.11 282.28,67.78 282.28,66.44 282.83,65.9 282.83,63.8 283.16,63.47 283.16,61.28 v2(283.43,61.01)
  BOTTOM w0.112: JDGFF1.C2 177.27,127.86 177.93,127.2 178.8,127.2 178.91,127.09 178.91,125.81 179.67,125.05 181.44,125.05 v1(181.86,125.47) v2(182.27,125.88)
DGPU_PRSNT#: length 7.8
  TOP w0.089: UH1.BD38 274.32,62.63 274.51,62.82 274.51,63.15 274.52,63.16 274.52,63.71 274.79,63.98 274.79,65.48 274.47,65.8 274.47,66.51 v1(274.35,66.63) 274.03,66.95 274.03,69.35 RH135.2
DGPU_PWR_EN: length 257
  TOP w0.089: 297.88,59.68 297.84,59.71 296.87,59.71 296.41,59.26 294.61,59.26 293.36,58.01 292.97,58.01 292.6,58.38 292.18,58.38 291.95,58.61 291.5,58.61 291.44,58.67 290.7,58.67 289.68,57.65 289.04,57.65 288.51,57.11 287.43,57.11 287.12,56.81 284.55,56.81 284.34,57.02 v2(284.34,57.32) 284.17,57.15 UH1.AN18
  TOP w0.112: UE5.97 305.54,26.88 305.78,27.12 306.52,27.12 307.2,27.79 307.2,32.45 306.54,33.11 v1(301.02,33.11) 300.59,33.11 300.32,32.83 295.96,32.83 294.4,31.27 292.95,31.27 v2(292.47,30.79) ; 297.88,59.68 298.1,59.46 RH537.1
  IN2 w0.104: v2(284.34,57.32) 284.46,57.32 285.48,58.34 285.63,58.34 285.86,58.57 285.86,58.91 285.32,59.45 285.32,60.64 285.08,60.88 285.08,62.78 286.98,64.69 286.98,67.96 288.88,69.86 288.88,72.4 287.68,73.59 287.68,74.36 286.74,75.3 286.74,75.9 285.75,76.89 285.75,78.71 277.59,86.87 277.59,95.85 268.6,104.83 251.16,104.83 250.56,105.43 238.76,105.43 238.25,105.94 222.13,105.94 221.84,106.23 214.2,106.23 214,106.43 213.81,106.43 213.81,106.43 196.79,106.43 193.23,109.99 193.23,116.13 189,120.36 189,125.63 184.93,129.71 184.93,133.76 183.79,134.9 183.79,144.41 v2(183.35,144.85)
  IN3 w0.104: v2(292.47,30.79) 292.47,30.93 288.26,35.14 286.46,35.14 284.06,37.54 284.06,40.54 283.13,41.46 283.13,45.52 283.74,46.12 283.74,49.02 285.19,50.47 285.19,50.84 285.65,51.31 285.65,52.96 284.89,53.72 284.89,54.38 284.16,55.11 284.16,57.14 v2(284.34,57.32)
  BOTTOM w0.112: v2(183.35,144.85) 182.77,144.85 181,143.09 177.47,143.09 177.27,143.29 JDGFF2.C2
DGPU_PWROK: length 7.3
  TOP w0.089: UH1.BE14 286.12,62.95 285.89,63.18 285.89,65.28 286.4,65.79 286.4,67.28 286.29,67.4 285.84,67.4 v1(285.53,67.71) 285.53,68.22 285.83,68.53 RH516.2
DH_1.2V: length 15.4
  TOP w0.254: v2(218.82,119.68) 218.82,119.68 PU201.17
  IN4 w1.016: 233.01,119.97 232.48,120.51 222.01,120.51 221.34,121.18 219.86,121.18 219.52,120.84
  vias: v1(234.28,120.1) v2(218.82,120.28) v2(233.65,119.21) v2(234.28,119.21)
DIMM1_CHA_EVENT#: length 27.9
  TOP w0.112: RD7.2 v1(255.78,82.61)
  TOP w0.127: v2(256.16,84.22) 255.78,83.84 RD7.2
  BOTTOM w0.112: JDIMM1.134 254.8,60.03 254.8,60.02 255.38,60.02 255.49,60.13 255.49,83.2 256.16,83.87 v2(256.16,84.22)
DIMM2_CHA_EVENT#: length 4
  TOP w0.112: RD18.2 v1(241.88,58.7)
  TOP w0.127: v2(241.71,60.48) 241.88,60.3 RD18.2
  BOTTOM w0.127: v2(241.71,60.48) 241.26,60.03 JDIMM3.134
DIMM3_CHB_EVENT#: length 4.7
  TOP w0.112: RD32.2 v1(228.93,63.25)
  TOP w0.127: v2(228.72,61.41) 228.93,61.63 RD32.2
  BOTTOM w0.127: v2(228.72,61.41) 228.72,60.82 227.92,60.03 JDIMM2.134
DIMM4_CHB_EVENT#: length 4.4
  TOP w0.112: v2(215.04,58.57) v1(215.04,58)
  TOP w0.127: v2(215.04,58.57) 215.06,58.6 RD44.2
  BOTTOM w0.127: JDIMM4.134 214.34,60.03 215.04,59.33 v2(215.04,58.57)
DL_1.2V: length 20.7
  IN4 w1.016: 221.94,117.83 221.94,117.23 225.28,113.9 234.55,113.9 235.93,115.28 235.93,119.47
  vias: v2(220.12,118.2) v2(220.75,118.2) v2(235.11,120.67) v2(235.11,120.04)
DMI_CRX_PTX_N0: length 209.6
  TOP w0.089: v2(277.65,40.84) 277.28,40.84 277.07,41.05 277.07,41.69 276.91,41.85 276.91,42.15 276.72,42.34 276.54,42.34 UH1.C33
  IN1 w0.084: v2(147.49,88.46) 147.6,88.35 148.84,88.35 151.66,91.17 152.01,91.17 155.4,94.56 157.39,94.56 160.47,97.64 161.18,97.64 163.69,100.16 167.23,100.16 173.46,106.38 180.43,106.38 184.56,102.26 212.18,102.26 212.48,101.97 230.91,101.97 231.27,101.6 250.8,101.6 257.59,94.81 257.59,92.03 260.86,88.76 260.86,83.98 261.5,83.34 261.5,77.44 263.9,75.04 263.9,68.89 264.45,68.33 264.45,62.26 262.23,60.04 262.23,55.04 261.17,53.98 261.17,51.85 261.86,51.16 261.86,41.33 262.56,40.62 264.84,40.62 265.24,41.03 272.06,41.03 273.03,40.06 275.14,40.06 276.23,41.15 277.17,41.15 277.48,40.84 v2(277.65,40.84)
  BOTTOM w0.102: UC1.Y4 147.65,80.07 147.54,80.07 147.29,80.32 147.29,82.78 146.86,83.21 146.86,84.12 146.75,84.23 146.75,84.95 146.74,84.96 146.74,84.99
  BOTTOM w0.112: 146.74,84.99 146.74,88.05 147.04,88.35 147.38,88.35 v2(147.49,88.46)
DMI_CRX_PTX_N1: length 205.5
  TOP w0.089: UH1.C32 277.22,42.5 277.41,42.5 277.56,42.35 277.56,42.03 277.96,41.62 277.96,41.3 278.28,40.98 278.28,40.53 277.35,39.6 276.89,39.6 v2(276.66,39.37)
  IN1 w0.084: v2(147.51,86.06) 147.72,86.27 147.9,86.27 148.08,86.44 149.55,86.44 150.79,87.68 150.79,89.17 151.99,90.37 152.34,90.37 155.73,93.76 157.72,93.76 160.8,96.84 161.51,96.84 164.02,99.36 179.68,99.36 180.9,100.58 198.07,100.58 198.95,101.46 211.83,101.46 212.13,101.17 230.57,101.17 231,100.74 245.83,100.74 253.52,93.05 255.19,93.05 259.93,88.3 259.93,77.87 260.82,76.98 260.82,69.94 263.65,67.11 263.65,63.03 261.42,60.79 261.42,55.42 260.37,54.37 260.37,51.52 261.06,50.83 261.06,41 262.23,39.82 269.23,39.82 269.79,39.26 275.47,39.26 275.89,39.67 276.36,39.67 v2(276.66,39.37)
  BOTTOM w0.102: UC1.AA5 148.55,79.17 148.41,79.17 148.19,79.39 148.19,81.04 147.78,81.45 147.78,82.87 147.56,83.08 147.56,84.95 147.55,84.96 147.55,84.99
  BOTTOM w0.112: 147.55,84.99 147.55,85.38 148.01,85.84 148.01,86.13 147.9,86.24 147.69,86.24 v2(147.51,86.06)
DMI_CRX_PTX_N2: length 200.8
  TOP w0.089: v2(278.12,39.12) 278.32,39.32 278.53,39.32 279.03,39.82 279.03,40.86 278.43,41.46 278.43,42.04 278.14,42.33 278.01,42.33 UH1.C31
  IN1 w0.084: v2(278.12,39.12) 277.95,39.29 277.48,39.29 276.82,38.63 269.53,38.63 268.96,39.19 261.97,39.19 260.43,40.73 260.43,50.57 259.74,51.26 259.74,55.55 260.12,55.93 260.12,58.16 260.78,58.82 260.78,62.48 260.06,63.2 260.06,72.47 259.12,73.42 259.12,84.21 256.76,86.57 256.76,88.35 253.33,91.78 253.33,92.31 245.53,100.11 230.74,100.11 230.31,100.53 211.77,100.53 211.47,100.83 199.42,100.83 198.51,99.92 181.14,99.92 179.94,98.72 164.29,98.72 161.77,96.21 161.07,96.21 157.98,93.13 155.99,93.13 152.6,89.73 152.25,89.73 151.42,88.9 151.42,86.16 150.31,85.05 149.18,85.05 149.12,84.99
  IN1 w0.102: 149.12,84.99 v2(148.96,84.83)
  BOTTOM w0.102: v2(148.96,84.83) 148.8,84.99 148.75,84.99 148.74,84.97 148.68,84.97 148.49,84.78 148.49,82.54 149.31,81.72 149.31,80.69 149.41,80.59 149.56,80.59 149.66,80.69 UC1.AB3

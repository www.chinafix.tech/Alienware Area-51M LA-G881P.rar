# Allegro board Alienware Area-51M LA-G881P.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+3VALW_PD: length 14.4
  TOP w0.254: v3(39.08,46.22) RT53.2 CT88.1 CT101.1 39.64,49.14 v2(39.78,49) ; RT731.2 v2(36.62,55.84)
  IN3 w0.254: v2(39.78,49) 39.78,51.58 36.62,54.75 v2(36.62,55.84)
  BOTTOM w0.203: v2(39.78,49) 39.83,49 40.76,48.07 40.96,48.07 40.97,48.07 UT4.H1
+3VALW_SSD: length 11
  IN1 w0.508: v2(359.16,24.92) 359.47,25.23 361.79,25.23 362.61,24.41 v2(368.35,24.41)
  BOTTOM w0.356: R363.2 v2(368.35,24.41)
  vias: v2(354.16,7.92) v2(354.16,7.29) v2(354.75,7.92) v2(354.75,7.29) v2(357.61,7.11) v2(357.61,6.5) v2(358.47,24.93) v3(356.58,19.45)
+3VALW_TBT: length 323.3
  TOP w0.127: v2(39.52,39.37) v3(38.89,39.37)
  TOP w0.254: v2(31.35,41.12) 31.58,40.89 31.77,40.89 31.9,40.76 RT77.2 ; v2(35.32,44.71) 35.29,44.68 34.19,44.68 33.88,44.37 RT76.2
  TOP w0.356: RT695.1 279.29,78.07 279.91,78.7 v2(280.06,78.7)
  TOP w0.381: v2(22.27,43.87) 22.27,43.98 22.63,44.34 CT48.1
  TOP w0.508: v2(16.05,53.31) 16.25,53.31 16.95,52.61 22.32,52.61 23.4,51.53 23.4,50.56 RT723.1
  IN1 w0.762: v2(116.62,87.78) 116.62,86.56 106.26,76.2 106.26,67.16 99.18,60.09 97.78,60.09 95.87,58.18 95.87,56.23 87.62,47.98 85.69,47.98 83.25,45.53 80.55,45.53 79.79,44.78 71.92,44.78 65.51,38.36 65.27,38.36 64.49,37.59 58.6,37.59 56.69,39.49 47.9,39.49 45.84,37.44 42.12,37.44 41.18,38.38 40.11,38.38
  IN3 w0.762: v2(116.62,87.78) 116.62,88.68 120.33,92.39 123.06,92.39 124.01,93.35 182.56,93.35 194.71,105.5 v2(202.4,105.5)
  BOTTOM w0.203: UT1.H9 v2(22.27,43.87)
  BOTTOM w0.254: RT21.1 16.8,44.6 16.54,44.34 v2(16.54,44.07) ; RT20.1 33.03,47.62 v2(33.08,47.67)
  BOTTOM w0.508: 279.84,79.24 280.06,79.02 v2(280.06,78.7)
  BOTTOM w0.762: v2(202.4,105.5) 204.19,107.28 212.82,107.28 215.86,110.32 234.41,110.32 235.06,110.97 252.57,110.97 253.38,110.16 253.38,106.36 253.02,106 253.02,100.41 255.42,98.01 269.62,98.01 273.58,94.05 273.58,83.78 274.16,83.21 275.24,83.21 275.84,82.61 276.38,82.61 276.39,82.6 276.48,82.6 279.84,79.24
  vias: v2(14.86,53.31) v2(15.47,53.34) v2(16.74,47.64) v2(40.21,39.34)
+3VALW_TBT_S5: length 71.8
  TOP w0.254: UT6.24 v2(46.03,29.62) ; v2(46.71,33.37) 46.81,33.27 RT218.1 ; RT217.1 44.73,32.98 v2(45.56,33.81)
  TOP w0.305: RT220.1 RT228.1 42.25,17.56 41.93,17.24 v2(41.93,16.71) ; v2(50.8,16.86) 50.8,16.94 51.4,17.54 RT240.1 ; RT237.1 48.77,18.13 48.27,18.63 RT222.1 48.26,19.12 v2(48.11,19.28)
  TOP w0.356: RT225.1 40.9,19.42 40.54,19.77 v2(40.54,19.96)
  TOP w0.381: UT7.9 49.39,11.08 v2(49.31,11) ; v2(44.83,16.69) 45.05,16.91 45.05,17.06 45.55,17.56 45.56,17.56 RT233.1 ; CT213.1 CT219.1 57.27,11.08 UT7.12
  TOP w0.406: UT7.16 55.39,13.68 54.91,14.16 54.91,17.58 v2(55.31,17.97) ; UT7.12 UT7.9
  TOP w0.508: 49.56,33.87 49.56,34.06 48.42,35.2 46.13,35.2 ; RT713.1 65.44,10.81 65.84,11.2 65.84,13.08 65.48,13.43 RT714.1 63.91,13.67 64.03,13.8 64.03,14.87 63.52,15.38 61.69,15.38 CT216.1 61.43,15.97 60.81,16.59 RT250.1 60.81,16.86 59.4,18.27 57.01,18.27 56.71,17.97 v2(55.31,17.97) ; v2(37.27,47.08) 37.55,47.36 RT53.1 ; v2(47.24,16.71) 47.36,16.6 RT242.1
  IN3 w0.508: v2(37.27,47.08) 37.46,47.27 38.19,47.27 38.57,46.89 38.57,44.6 41.88,41.29 41.88,39.02 42.58,38.31 v2(43.03,38.31) ; v2(50.8,16.86) 51.36,17.42 51.36,17.96 51.95,18.55 53.54,18.55 54.11,17.97 v2(55.31,17.97)
  BOTTOM w0.254: RT107.1 44.16,39.46 43.66,38.96 v2(43.66,38.31)
  BOTTOM w0.305: RT236.1 44.82,19.87 v2(44.53,19.58)
  BOTTOM w0.508: v2(46.03,29.62) 46.13,29.53 CT206.1
  vias: v2(12.67,38.61) v2(12.81,52.39) v2(12.79,51.73) v2(13.23,38.61) v2(45.19,31.34) v2(46.83,12.6) v2(49.53,33.22) v2(55.25,27.08) v2(55.19,26.36) v2(55.65,26.69) v2(55.66,26.03) v3(43.66,37.51)
+3VALWP: length 7.7
  TOP w0.127: 325.28,44.73 v3(325.28,42.5)
  TOP w0.254: 333.4,43.71 332.54,42.84 332.54,42.48 333.55,41.47 333.55,39.62 333.29,39.37 PR301.1
+3VLP: length 464.8
  TOP w0.508: v2(310.49,12.47) 309.98,12.98 RE684.1 ; v2(107.72,16.45) 108.12,16.86 v3(108.12,17.52) 109.19,18.59 109.19,20.27 111.6,22.67 118.93,22.67 119.81,21.79 v2(119.85,21.79) ; v2(299.7,26.86) 299.79,26.95 RE63.1 RE77.1 ; DU8.1 v2(19.33,33.27) ; PR15.1 350.19,13.28 349.68,13.79 348.62,13.79 345.21,10.37 344.45,10.37 341.66,7.58 340.07,7.58 339.34,8.31 v2(339.34,11.48) 339.69,11.83 345.09,11.83 349.94,16.68 349.94,23.52 349.44,24.03 346.93,24.03 346.17,24.79 346.17,28.15 345.86,28.46 345.86,28.47 345.49,28.84 345.48,28.84 345.41,28.92 v2(343.06,28.92) ; RU5.1 v2(19.2,34.54) ; RU7.1 v2(35.28,19.89) ; RE78.1 314.19,11.72 v2(314.95,12.48) ; RU1.1 v2(39.93,16.84)
  IN1 w0.508: v2(16,32.81) 16.79,32.81 17.25,33.27 v2(19.33,33.27) 19.33,34.41 v2(19.2,34.54) ; v2(62.13,21.11) 62.32,21.3 65.09,21.3 66.52,19.86 72.64,19.86 74.64,21.86 76.4,21.86 82.56,15.71 87.85,15.71 88.43,16.29 93.74,16.29 93.9,16.14 107.4,16.14 v2(107.72,16.45) ; v2(335.88,29.39) 335.88,30.12 333.08,30.12 332.45,30.76 332.45,37.67 v2(332.64,37.87)
  IN2 w0.508: v2(62.13,21.11) 60.67,21.11 60.22,20.66 v2(57.24,20.66) ; v2(39.93,16.84) 39.93,17.45 38.58,18.79 36.3,18.79 35.53,19.56 35.53,19.63 v2(35.28,19.89)
  IN3 w0.508: v2(343.06,28.92) 342.56,28.42 341.84,28.42 340.87,29.39 v2(335.88,29.39) ; v2(19.33,33.27) 22.51,30.09 22.51,28.92 23.27,28.15 26.83,28.15 27.33,28.66 32.37,28.66 32.76,28.27 33.64,28.27 34.16,27.75 34.16,22.53 34.63,22.06 34.63,21.3 34.89,21.04 34.89,20.28 v2(35.28,19.89) 35.28,20.01 36.07,20.8 36.32,20.8 39.35,23.83 44.72,23.83 45.35,23.2 49.54,23.2 51.31,21.44 54.18,21.44 54.95,20.66 v2(57.24,20.66) ; v2(310.49,12.47) 311.05,13.03 314.4,13.03 v2(314.95,12.48) v2(317.37,12.48) 318.36,11.48 v2(339.34,11.48) ; v2(299.7,26.86) 299.7,27.22 299.04,27.88 297.94,27.88 297.15,28.68 296.07,28.68 296.07,28.68 295.5,28.68 294.33,29.84 292.32,29.84 291.78,30.38 291.78,31 288.08,34.71 286.28,34.71 285.28,35.71 282.08,35.71 281.98,35.61 281.61,35.61 280.89,34.89 280.89,34.52 278.79,32.42 264.04,32.42 258.99,27.37 256.79,27.37 252.75,23.33 248.94,23.33 248.3,23.97 237.85,23.97 237.41,23.52 230.32,23.52 227.7,20.9 225.83,20.9 224.55,19.62 220.9,19.62 219.89,20.64 218.68,20.64 218.12,20.07 216.04,20.07 215.46,20.66 188.74,20.66 185.5,23.9 170.96,23.9 170.35,23.29 160.6,23.29 160,23.9 134.01,23.9 131.9,21.79 v2(119.85,21.79)
  BOTTOM w0.508: PR17.1 61.28,21.96 v2(62.13,21.11) ; PR25.2 299.7,25.81 v2(299.7,26.86) 300.72,26.86 301.46,26.12 305.48,26.12 307.81,23.79 307.81,21.26 313.79,15.28 314.57,15.28 v2(317.37,12.48)
+3VS: length 905.8
  TOP w0.254: CU108.2 31.42,27.21 UU6.1
  TOP w0.381: QH5.2 v2(278.45,74.67)
  TOP w0.457: QH5.5 281.2,74.67 281.62,75.1 v2(281.62,75.1)
  TOP w0.508: v2(225.9,93.96) 225.91,93.95 225.91,93.19 RD26.2 ; R375.1 28.6,19.38 v2(28.6,18.45) ; v2(228.88,72.41) 228.88,70.83 228.14,70.09 RD28.2 ; RH521.1 280.52,73.12 280.12,72.73 v2(279.93,72.73) RH463.1 RH462.1 ; v2(283.82,75.69) 283.49,75.36 RC63.2 RC62.2 ; R372.1 R371.1 29.79,19.07 v2(29.58,18.86) ; RE696.1 312.97,25.05 313.33,25.42 v2(313.33,25.49) ; v2(293.74,30.81) 294.56,30.81 296.14,32.39 303.73,32.39 v2(303.94,32.6) ; RD40.2 216,72.09 215.49,72.6 v2(215.49,73.87) ; v2(220.67,94.13) 220.67,93.77 220.05,93.14 217.75,93.14 RD38.2 ; v2(241.91,73.63) 241.68,73.4 RD14.2 ; RE707.2 271.7,82.69 272.11,82.27 272.11,80.06 273.36,78.81 273.36,77.42 274.16,76.62 v2(274.16,75.96) ; RD59.2 228.56,97.24 228.18,96.86 v2(228.18,96.35) ; RE84.1 304.86,28.65 v2(305.14,28.93) ; 260.88,51.46 260.88,53.93 261.25,54.31 263.88,54.31 264.39,54.81 RH512.2 ; RD58.2 242.79,96.54 242.28,96.04 v2(242.28,95.99) 241.87,95.58 RD13.2 RD12.2 ; v2(258.36,86.48) RD1.2 RD2.2 ; 260.76,49.43 260.69,49.36 257.45,49.36 256.44,50.37 256.44,51.71 257.74,53 257.74,56.69 258.4,57.35 RH602.1 ; v2(30.84,29.59) 30.89,29.54 R378.1 ; RD27.2 224.21,96.29 v2(224.26,96.34) ; R377.1 R376.1 29.06,29.49 v2(28.96,29.59) ; RD39.2 v2(216.08,96.73) 216.08,97.39 216.84,98.16 RD60.2 217.65,101.04 215.8,102.89 v2(215.8,103.78) ; RE20.2 v2(348.03,32.13) ; CU108.2 32.63,27.46 v2(32.92,27.46) ; v2(86.32,16.72) 85.37,17.68 82.1,17.68 81.75,18.03 72.77,18.03 71.77,19.02 v3(66.32,19.02) 60.53,19.02 59.97,19.58 v2(59.4,19.58) 58.64,19.58 57.95,20.27 RT132.2 ; v2(168.68,170.7) 168.56,170.58 RL69.2 ; v2(26.89,29.59) 27.25,29.23 R379.1 ; v2(31.64,18.86) 31.65,18.87 R373.1 ; RD3.2 v2(257.39,69.87) ; RH614.1 v2(115.8,169.7) ; R374.1 v2(32.66,18.88) ; PRZ16.1 v2(58.51,28.28)
  TOP w1.016: 172.81,23.52 149.51,23.52 147.1,25.93 137.72,25.93 135.35,23.56 122.87,23.56 119.4,20.09 119.4,18.47 119.03,18.09 119.03,16.93 117.93,15.83 117.93,14.36 115.15,11.58 114.83,11.58 ; 222.28,17.93 198.26,17.93 191.65,24.54 179.3,24.54 178.16,23.4 174.33,23.4 ; 223.49,18.44 229.45,18.44 230.42,17.47 255.37,17.47 255.61,17.23 255.8,17.23 256.56,17.99 256.56,21.83 254.72,23.68 254.72,25.49 257.14,27.91 257.14,44.35 261.71,48.92
  TOP w2.032: 302.98,40.92 302.98,44.79 305.59,47.39 305.59,57.43
  TOP w5.08: 301.27,68.98 299.43,70.83 299.43,72.03 292.44,79.02 292.38,79.02 292.38,79.08 284.31,87.15 284.31,90.89 279.23,95.97 275,95.97
  IN1 w0.508: v2(52.81,31.67) 52.81,30.79 56.08,27.52 57.75,27.52 v2(58.51,28.28) 58.53,28.28 59.16,27.65 59.16,26.5 58.27,25.6 58.27,23.26 58.93,22.6 58.93,20.06 v2(59.4,19.58)
  IN1 w1.016: 350.52,46.71 353.87,46.71 356.77,43.81 356.77,42.49 357.43,41.83 360.91,41.83 361.67,41.07 361.67,40.46 362.11,40.02 363.62,40.02 364.34,40.74 364.34,44.4 365.35,45.41 372.24,45.41
  IN2 w0.508: v2(32.66,18.88) 32.59,18.96 32.59,25.83 32.92,26.17 v2(32.92,27.46) 32.92,27.53 31.27,29.18 31.25,29.18 v2(30.84,29.59) v2(28.96,29.59) v2(26.89,29.59) ; 157,174.9 155.35,173.25 151.73,173.25 143.22,164.74 122.77,164.74 121.41,166.1 117.22,166.1 116.36,166.96 116.36,169.19 115.85,169.7 v2(115.8,169.7) ; v2(73.51,41.11) 71.44,39.04 63.17,39.04 62.66,38.53 62.66,36.6 59.6,33.54 59.6,29.37 v2(58.51,28.28) ; v2(257.39,69.87) 257.71,69.87 258.22,70.38 258.22,73.05 257.71,73.56 257.71,85.83 v2(258.36,86.48)
  IN2 w1.016: 165.49,130.52 165.49,124.71 174.28,115.92 174.28,113.19 181.53,105.94 181.53,102.3 188.42,95.41 197.97,95.41 199.48,96.92 ; 202.78,96.42 211.99,96.42
  IN3 w0.508: v2(160.43,167.47) 160.38,167.53 160.38,168.11 160.73,168.46 161.23,168.46 161.25,168.49 162.84,168.49 164.68,166.65 v2(166.01,166.65) ; v2(32.66,18.88) 32.63,18.88 32.6,18.86 v2(31.64,18.86) v2(29.58,18.86) 29.17,18.45 v2(28.6,18.45) 28.22,18.45 27.72,18.96 v2(27.72,20.41)
  IN4 w0.508: 312.48,24.63 312.41,24.63 ; v2(52.81,31.67) 50.06,31.67 48.69,30.3 44.58,30.3 43.82,29.54 36.83,29.54 34.75,27.46 v2(32.92,27.46)
  IN4 w1.016: 158.46,118.13 162.2,121.88 166.23,125.91 166.23,131.09 ; 231.74,72.16 231.9,71.99 231.9,28 225.89,21.99 221.96,21.99 ; 312.41,24.63 309.02,28.03 305.78,28.03 ; 313.02,23.52 313.02,20.91 314.93,19 315.1,19 ; 304.51,29.3 304.41,29.39 304.41,30.26 304.32,30.35 304.32,32.22 v2(303.94,32.6) 303.24,33.3 303.24,35.62 303.24,35.62 ; 341.72,24.6 340.83,23.71 337.79,23.71 336.91,24.59 326.97,24.59 324.76,22.37 322.6,22.37 321.46,21.23 320.01,21.23 318.61,19.84
  BOTTOM w0.254: CM33.1 164.93,181.54 165.18,181.3 UM8.24 ; v2(225.07,16.42) 224.53,16.42 US1.1 ; C2498.1 223.72,107.9 223.72,107.45 223.47,107.2 U2407.1
  BOTTOM w0.356: CM19.1 166.57,174.03 RM18.1 ; v2(161.9,178.39) 162.02,178.28 CM22.1 CM21.1 162.07,177.05 162.07,176.67
  BOTTOM w0.381: 162.07,176.67 UM4.16 ; v2(178.52,178.08) 178.47,178.13 RM79.1 RM86.1 ; RM76.1 163.98,178.17 163.98,178.35 163.93,178.4 163.93,178.64 RM81.1 163.8,178.71 163.74,178.76 163.64,178.76 163.63,178.78 163.53,178.78 163.35,178.96 163.35,179.16 163.35,179.16 163.35,179.35 162.91,179.79 v2(162.72,179.79) ; UM4.12 159.47,174.84 v2(159.73,174.58) ; v2(178.65,182.9) RM26.1 RM66.2 ; v2(163.16,172.68) 162.07,171.6 UM4.5 162.07,168.5 CM20.1 ; RM85.1 v2(178.59,184.8) ; UM4.9 159.47,168.49 CM18.1
  BOTTOM w0.508: v2(168.68,170.7) 168.46,170.48 RM96.1 ; v2(278.45,74.67) 278.45,74.65 279.54,73.57 279.56,73.57 279.57,73.55 280.29,73.55 RH85.2 280.58,73.81 RH600.2 281.69,73.62 282.41,73.62 RH588.1 283.23,74.45 283.23,75.1 v2(283.82,75.69) ; 89.18,53.8 89.15,53.77 89.15,51.04 91.27,48.92 91.27,47.14 90.58,46.44 78.84,46.44 v2(73.51,41.11) ; 89.18,53.8 RF2.2 ; 89.18,53.8 RF1.2 ; PRF02.1 157.01,117.38 v2(157.44,117.82) ; R181.1 215.95,103.93 v2(215.8,103.78) 216.94,102.64 225.84,102.64 226.41,103.21 226.41,108.48 225.9,108.99 224.94,108.99 224.33,108.38 C2498.1 ; v2(165.04,173.72) CM19.1 ; v2(225.07,16.42) 225.07,16.3 225.58,15.79 226.53,15.79 227.03,16.28 228.29,16.28 228.65,15.92 RE656.1 ; CM18.1 159.85,168.48 160.36,167.97 160.36,167.54 v2(160.43,167.47) ; RL9.1 177.19,175.37 178.52,176.71 v2(178.52,178.08) ; PRA02.2 v2(124.55,115.68) ; RM20.1 163.23,167.59 164.17,166.65 v2(166.01,166.65) ; v2(293.74,30.81) 293.38,30.45 PR1803.1 ; PRA20.1 132.87,117.24 v2(132.66,117.04)
  BOTTOM w1.016: 62.17,9.58 62.17,8.18 64.04,6.3 64.65,6.3 64.65,6.3 67.47,6.3 67.72,6.05 93.89,6.05 96.89,9.05 109.54,9.05 111.43,10.95 112.65,10.95 ; 114.63,10.79 115.83,10.79 116.85,9.78 116.85,7.05 117.02,6.88
  vias: v2(113.31,11.58) v2(113.94,11.58) v2(157.57,118.58) v2(161.59,182.2) v2(163.47,172.04) v2(165.71,132.7) v2(165.71,132) v2(171.28,129.69) v2(171.38,144.87) v2(171.94,144.87) v2(178.92,132.74) v2(178.92,132.17) v2(201.95,97.24) v2(202.59,97.24) v2(221.13,20.33) v2(221.69,20.29) v2(254.53,95.78) v2(254.53,95.08) v2(255.17,95.78) v2(255.17,95.08) v2(255.8,95.78) v2(255.8,95.08) v2(269.26,93.97) v2(269.26,93.38) v2(269.85,93.97) v2(269.85,93.38) v2(286.59,72.24) v2(288.25,77.56) v2(288.44,76.67) v2(303.5,38.31) v2(303.5,37.73) v2(303.5,37.15) v2(303.5,36.56) v2(315.94,58.7) v2(315.94,58.11) v2(316.52,58.7) v2(316.52,58.11) v2(317.54,19) v2(318.2,19) v2(342.04,26.95) v2(342.04,26.37) v2(342.04,25.78) v2(342.62,26.95) v2(342.62,26.37) v2(342.62,25.78) v2(343.2,26.95) v2(343.2,26.37) v2(343.2,25.78) v2(343.72,26.06) v2(346.33,45.77) v2(346.33,45.08) v2(349.73,46.38) v2(349.76,47.32) v2(374.93,47.42) v2(374.93,46.73)
+3VS_ACC: length 279.8
  TOP w0.254: CS19.1 279.37,78.79 v1(278.09,77.5) 278,77.42 v2(277.52,77.42) ; RS9.2 115.68,173.19 RS18.2 RS19.2 v2(117.19,174.78) ; RS16.2 RS15.1 275.45,80.27 275.24,80.48 v2(274.67,80.48) ; RS10.2 v2(110.2,173.63) ; US2.8 114.67,171 114.89,170.79 RH614.2 114.38,169.82 CS18.1 114.02,169.38 v2(113.77,169.12) 112.42,169.12 112.18,169.36 CS17.1 112.18,170.33 112.16,170.35 US2.5
  IN1 w0.254: v2(117.19,174.78) 114.9,172.49 114.9,169.5 114.52,169.12 v2(113.77,169.12) 111.79,169.12 109.69,171.22 109.69,173.12 v2(110.2,173.63)
  IN2 w0.254: v2(274.67,80.48) 274.67,80.03 277.28,77.42 v2(277.52,77.42) ; v2(156.81,157.38) 155.85,158.34 152.81,158.34 152.18,158.97 123.75,158.97 122.46,160.25 122.46,164 121.1,165.37 114.9,165.37 113.77,166.5 v2(113.77,169.12)
  IN3 w0.254: v2(156.81,157.38) 156.81,155.73 157.67,154.87 161.65,154.87 165.54,150.98 179.51,150.98 182.18,148.32 184.54,148.32 185,147.85 193.15,147.85 197.68,143.32 207.07,143.32 208.9,141.48 208.9,136.81 208.14,136.05 208.14,133.22 207.47,132.55 207.47,129.28 204.15,125.96 204.15,115.84 203.42,115.11 203.42,110.82 205.16,109.08 208.14,109.08 210.04,110.98 214.47,110.98 215.44,110 219.23,110 219.69,109.54 233.03,109.54 233.83,110.34 237.11,110.34 237.67,110.9 259.59,110.9 263.02,107.47 269.52,107.47 274.75,102.24 274.75,97.38 275.39,96.75 275.39,89.32 274.03,87.97 274.03,81.11 v2(274.67,80.48)
+3VSP_SSD:
  vias: v3(362.36,14.44)
+5V_HDD:
  vias: v2(253.65,7.7) v2(254.71,7.47) v2(254.73,6.88) v3(252.06,8.34)
+5V_TOBII: length 5.8
  TOP w0.127: v3(299.56,42.44) v2(300.13,42.44)
  BOTTOM w0.508: CV1071.1 299,42.62 298.19,43.42 296.16,43.42 295.58,44 JTOBII.5
+5V_USB_PWR1: length 13.4
  TOP w3.556: 31.47,10.84 24.37,10.84 20.81,14.4 20.81,15.62
  vias: v2(20.22,18.62) v2(20.22,18.06) v2(20.81,18.62) v2(20.81,18.06) v2(21.39,18.62) v2(21.39,18.06) v2(21.98,18.62) v2(21.98,18.06) v3(21.05,19.33)
+5V_USB_PWR2: length 2.2
  TOP w0.508: v3(378.78,19.9) CU245.1 CU244.1
+5VALW: length 631.8
  TOP w0.254: C2519.1 168.63,101.34 168.27,101.34 168.17,101.44 UZ21.4 ; U19.3 79.8,20.8 v2(79.53,20.8)
  TOP w0.381: C2516.1 359.95,17.58 359.57,17.2 U16.3
  TOP w0.508: v2(360.15,36.95) 358.64,35.45 v2(358.64,34.49) ; v2(295.38,3.51) 295.42,3.55 JWDB.1 ; v2(359.03,21.21) v3(359.03,20.28) 359.03,18.46 359.43,18.06 C2516.1 ; RE158.1 151.86,171.73 151.41,171.28 v2(151.41,169.57) 151.65,169.33 RE156.1 ; CV1074.1 48.18,45.68 48.18,44.04 47.82,43.68 v2(47.82,42.47) ; v2(183.17,97.17) 182.04,96.04 177.63,96.04 v3(177.22,96.45) 171.27,102.4 169.14,102.4 168.78,102.04 C2519.1 ; C2521.1 79.27,21.05 v2(79.53,20.8) ; v2(154.4,167.85) 156.49,167.85 157.38,166.96 158.72,166.96 159.73,167.98 RE154.1 ; PR204.1 224.01,116.96 v2(224.53,116.45) 225.58,115.4 225.58,112.64 225.07,112.13 223.99,112.13 223.61,112.51 PR203.1 ; 267.84,7.96 v2(267.84,5.99) ; RE28.1 176.87,187.86 178.12,186.61 QE8.3 v2(179.54,186.61) ; PR5.2 v2(151.17,167.42)
  IN1 w0.508: v2(182.72,178.9) 182.72,179 181.68,180.04 181.68,181.87 180.37,183.18 180.37,185.12 179.54,185.94 v2(179.54,186.61) ; v2(250.6,14.6) 251.05,14.15 251.05,13.19 250.15,12.29 250.15,9.64 253.86,5.93 263.55,5.93 264.06,6.44 267.17,6.44 267.61,5.99 v2(267.84,5.99) ; v2(114.39,119.85) 114.39,120.13 114.9,120.64 116.14,120.64 118.84,123.34 124.36,123.34 126.01,124.99 126.01,131.72 127.02,132.73 127.02,139.13 130.4,142.51 130.4,145.48 131.09,146.18 v2(131.28,146.18) 131.28,146.46 130.3,147.44 130.3,147.94 130.33,147.98 131.07,148.71 134.51,148.71 140.3,154.51 142.57,154.51 143.67,155.6 143.67,157.45 149.75,163.54 149.75,166 v2(151.17,167.42) 150.72,167.87 150.72,168.87 v2(151.41,169.57) ; v2(295.38,3.51) 295.29,3.43 285.82,3.43 284.84,4.4 284.36,4.4 283.24,5.52 278.65,5.52 v2(277.29,4.16) ; v2(224.53,116.45) 221.23,116.45 220.42,115.64 216.89,115.64 216.32,116.22 214.16,116.22 213.7,116.67 206.41,116.67 v2(199.54,123.54)
  IN2 w0.508: v2(159.16,189.51) 157.89,189.51 152.73,184.34 152.44,183.91 152.19,183.67 150.04,181.52 149.98,181.44 149.93,181.35 149.9,181.26 149.89,181.16 149.89,177.48 149.89,177.13 149.76,176.45 149.49,175.81 149.11,175.23 148.86,174.99 147.54,173.66 v2(147.54,173.25) ; v2(190.3,105.78) 187.65,108.44 187.65,111.01 174.04,124.61 174.04,125.33 175.29,126.58 175.29,127.34 175.92,127.98 v2(176.05,127.98) 176.11,127.98 176.8,128.67 178.26,128.67 180.09,130.49 180.09,134.75 180.87,135.53 180.87,139.91 180.67,140.11 180.67,142.44 180.09,143.03 178.97,143.03 177.58,144.41 177.58,146.14 175.69,148.03 172.92,148.03 172.55,147.66 171.34,147.66 170.98,148.01 170.98,149.1 171.61,149.73 171.61,150.25 173.7,152.34 173.7,153.76 174.21,154.26 174.93,154.26 178.75,158.08 v2(179.3,158.08)
  IN3 w0.381: v2(45.31,47.98) 46.48,47.98 47.13,47.33 v2(47.13,45.91) 47.13,45.87 46.89,45.64 46.89,45.1 48.62,43.37 v2(48.65,43.37)
  IN3 w0.508: v2(154.4,167.85) 151.6,167.85 v2(151.17,167.42) 148.35,167.42 147.54,168.23 v2(147.54,173.25) ; v2(176.05,127.98) 176.11,127.98 v2(178.85,130.71) ; v2(316.19,23.26) 316.19,23.52 313.15,26.57 312.76,26.57 311.62,27.71 311.1,27.71 309.65,29.16 308.83,29.16 307.28,30.71 307.28,32.73 306.55,33.45 304.6,33.45 304.38,33.67 304.36,33.69 302.96,33.69 299.46,37.19 299.46,43.24 299.17,43.53 299.11,43.53 298.75,43.89 298.75,44.17 297.84,45.09 v2(297.26,45.09) ; v2(179.54,186.61) 177.41,188.75 159.92,188.75 v2(159.16,189.51) ; v2(199.54,123.54) 199.54,117.75 197.18,115.39 197.18,114.58 193.32,110.72 193.32,108.8 v2(190.3,105.78)
  IN3 w1.016: v2(190.3,105.78) 190.33,105.76 190.33,104.32 v2(183.17,97.17)
  IN4 w0.508: v2(372.2,38.25) 371.21,39.24 368.63,39.24 367.13,37.74 360.93,37.74 v2(360.15,36.95) ; v2(358.64,34.49) 358.64,31.11 360.71,29.04 360.71,27.1 361.72,26.08 361.72,23.63 360.64,22.55 359.74,22.55 359.03,21.84 ; v2(179.3,158.08) 178.63,158.75 178.63,163.58 179.5,164.45 179.5,170.93 180.87,172.3 180.87,176.96 182.72,178.81 v2(182.72,178.9) ; 359.03,21.84 358.85,21.84 357.78,22.91 353.58,22.91 352.34,24.14 346.97,24.14 346.49,24.62 346.49,24.63 343.49,27.63 342.31,27.63 341.91,28.03 341.74,28.03 341.61,28.15 337.91,28.15 336.78,27.02 v2(336.63,27.02) ; 359.03,21.84 v2(359.03,21.21)
  BOTTOM w0.203: v2(47.13,45.91) 46.96,46.07 UT4.D11
  BOTTOM w0.254: v2(45.31,47.98) 45.33,48 45.72,48 UT4.H10
  BOTTOM w0.406: JDGFF1.E2 177.27,130.9 177.46,130.71 ; 177.46,130.71 v2(178.85,130.71) ; 177.46,130.71 177.27,130.52 JDGFF1.D2 ; JDGFF1.C5 175.47,128.56 v2(176.05,127.98)
  BOTTOM w0.508: RM92.1 RM91.1 161.74,192.63 160.73,193.65 RM94.1 159.89,193.35 159.69,193.15 159.69,190.92 159.1,190.33 159.1,189.57 v2(159.16,189.51) 160.27,189.51 RM93.1 ; PR10.2 v2(131.28,146.18) ; UE12.5 302.89,43.08 302.89,41.79 CE80.1 303.84,42.11 303.84,43.43 303.18,44.09 302.38,44.09 301.22,45.25 301.22,45.29 301.07,45.45 CE81.1 299.17,46.19 CE82.1 299.13,45.72 299.11,45.71 299.09,45.71 298.87,45.48 298.87,45.46 298.59,45.18 RE161.2 297.27,45.04 297.27,45.09 v2(297.26,45.09) ; v2(267.84,5.99) 267.84,4.39 270.5,1.73 274.86,1.73 v2(277.29,4.16) ; v2(246.88,14.6) 246.88,14.59 245.8,13.51 244.97,13.51 244.2,12.74 244.2,10.56 243.69,10.06 242.47,10.06 241.64,10.88 241.64,11.45
  BOTTOM w1.016: 178.65,21.55 178.65,22.5 183.17,27.03 v2(183.17,97.17)
  vias: v2(37.77,13.84) v2(37.97,28.9) v2(38.33,13.85) v2(38.52,28.89) v2(55.19,24.81) v2(55.19,24.25) v2(178.27,20.66) v2(178.9,20.66) v2(334.52,28.55) v2(334.52,27.79) v2(334.52,27.02) v2(334.52,26.36) v2(334.49,25.68) v2(335.1,28.55) v2(335.1,27.79) v2(335.1,27.02) v2(335.1,26.36) v2(335.08,25.68) v2(335.84,25.68) v2(335.86,28.55) v2(335.86,27.79) v2(335.86,27.02) v2(335.86,26.36) v2(336.33,19.07) v2(336.33,17.99) v2(336.63,28.55) v2(336.63,27.79) v2(336.63,26.36) v2(336.6,25.68) v2(336.91,19.07) v2(336.91,17.99) v2(337.49,19.07) v2(337.49,17.99) v2(372.08,37.55) v2(372.77,37.55) v2(372.95,38.2) v3(336.52,17.04)
+5VALW_LED: length 15.7
  TOP w0.508: JPWR.2 JPWR.1 176.96,183.02 177.51,183.56 179.57,183.56 v3(181.51,185.5) 181.51,187.07 181,187.58 QE8.1
+5VALWP: length 28.4
  TOP w0.203: v2(333.7,36.5) 333.07,36.5 PR302.2 ; v2(326.64,37.79) 326.78,37.93 PU301.14
  IN4 w0.203: v2(332.07,27.77) 332.21,27.77 332.41,27.98 332.41,36.57 332,36.98 328.26,36.98 327.44,37.79 v2(326.64,37.79)
  IN4 w0.254: v2(332.19,26.88) 332.64,26.88 333.15,27.39 333.15,29.03 334.9,30.78 334.9,35.3 v2(333.7,36.5)
  vias: v3(328.58,20.72)
+5VS: length 631.7
  TOP w0.508: PRI95.2 103.54,41.17 PRI92.1 103.15,41.17 102.62,40.64 101.74,40.64 100.84,41.54 v2(100.84,42.21) ; v2(104.47,58.54) 104.75,58.82 105.7,58.82 PRI52.1 106.08,57.68 PRI55.2 ; PRI217.1 82.55,42.72 82.32,42.95 82.32,43.52 v2(82.3,43.54) ; CE86.1 159.67,177.94 v2(160.44,178.71) ; PRZ03.1 v2(58.57,32.15) ; v2(100.8,32.28) 100.8,31.96 101.61,31.15 PRI14.2 103.33,32.05 PRI11.1 ; v2(100.8,32.28) 100.8,35.37 98.81,37.36 98.81,41.4 v2(99.66,42.25) ; v2(100.8,32.28) 99.26,32.28 98.09,31.11 v3(98.09,24.92) 98.09,23.59 98.83,22.86 v2(100.46,22.86) PRI27.1 103.33,22.08 PRI30.2 ; v2(148.41,11.71) 147.27,10.57 141.91,10.57 139.38,13.1 132.81,13.1 v2(132.71,13) ; v2(102.37,50.95) 103.03,50.95 104.34,49.64 PRI107.1 PRI110.2 ; PRI229.1 83.4,36.34 v2(82.45,37.3) ; v2(83.02,28.85) 83.3,28.57 PRI208.1 ; PRZ44.2 65.23,35.91 65.66,35.48 v2(65.86,35.48)
  IN1 w0.508: v2(99.66,42.25) 100.8,42.25 v2(100.84,42.21) ; v2(81.3,40.85) 80.91,40.46 80.91,39.59 79.7,38.37 69.64,38.37 68.16,36.89 68,36.89 66.6,35.48 v2(65.86,35.48) ; v2(104.47,58.54) 101.76,58.54 v2(100.96,57.74) 100.46,57.24 v2(99.24,57.24) ; v2(102.37,50.95) 102.31,50.89 v2(99.24,50.89) ; v2(369.73,48.41) 369.73,50.05 365.73,54.06 358.36,54.06 355.07,50.77 352.22,50.77 v2(351.66,51.33)
  IN1 w2.032: 303.24,64.94 294.8,73.39 294.8,85.7 285.59,94.91 285.59,98.38 280.06,103.91 277.08,103.91 275.56,105.43
  IN2 w0.508: v2(58.57,32.15) 58.19,32.15 57.5,31.46 57.5,29.45 56.43,28.38 56.43,27.88 56.49,27.82 56.49,27.51 56.71,27.29 56.71,25.78 56.35,25.42 54.93,25.42 54.58,25.07 54.58,23.77 53.49,22.69 53.49,20.09 54.25,19.33 54.25,17.88 54.84,17.3 55.85,17.3 55.9,17.35 ; v2(99.24,50.89) 98.22,51.9 v2(94.07,51.9)
  IN2 w1.016: 189.83,111.85 189.83,111.91 183.73,118.01 183.73,120.8
  IN2 w2.54: 252.06,110.32 265.36,110.32 266.71,108.98 268.96,108.98
  IN3 w0.508: 87.68,24.22 87.68,23.05 v2(87.39,22.76) ; 87.68,24.22 87.94,23.96 93.81,23.96 94.84,22.93 100.38,22.93 v2(100.46,22.86) ; 87.68,24.22 87.68,24.56 83.39,28.85 v2(83.02,28.85) ; v2(109.38,115.64) 112.44,115.64 118.86,122.07 119.38,122.07 120.78,123.47 122.41,123.47 125.75,126.81 125.75,130.43 126.92,131.6 133.11,131.6 134.01,132.5 134.01,142.31 135.47,143.76 135.47,144.8 136.24,145.57 143.22,145.57 143.98,144.81 143.98,140.49 146.52,137.95 150.23,137.95 155.76,143.48 166.88,143.48 166.89,143.5
  IN4 w0.508: v2(65.86,35.48) 65.56,35.48 64.44,34.36 61.06,34.36 58.85,32.15 v2(58.57,32.15) ; v2(83.02,28.85) 82.16,29.72 82.16,35.39 82.45,35.68 v2(82.45,37.3) 82.45,40.16 82,40.6 81.56,40.6 v2(81.3,40.85) 82.3,41.85 v2(82.3,43.54) ; v2(130.68,111.11) 130.68,110.55 130.2,110.07 115.78,110.07 110.2,115.64 v2(109.38,115.64) ; v2(169.03,143.56) 169.03,145.03 167.12,146.94 167.12,150.42 157.95,159.58 157.95,168.22 159.03,169.3 159.03,169.89 158.4,170.52 158.4,174.11 160.44,176.16 v2(160.44,178.71)
  IN4 w2.032: 311.69,58.76 311.69,50.82 316.32,46.19 316.32,36.07 316.08,35.82 316.08,28.84 320.58,24.34 320.58,24.22
  BOTTOM w0.254: PUA01.18 129.42,114.03 129.77,113.69 PCA08.1 129.82,112.72 PRA01.2 ; PUI08.9 82.38,42.78 PCI204.1 ; PUI07.9 83.27,28.61 v2(83.02,28.85) 82.78,29.09 PCI206.1 ; PCI211.1 82.32,36.38 PUI09.9
  BOTTOM w0.508: RF3.2 91.55,53.68 CF4.1 91.55,51.43 91.78,51.2 91.78,51.08 92.42,50.44 93.14,50.44 93.65,50.94 93.65,51.49 v2(94.07,51.9) 94.07,60.03 90.19,63.9 89.24,63.9 87.28,61.94 87.28,60.39 JFAN1.2 ; PCI211.1 82.21,37.06 v2(82.45,37.3) ; PRI54.2 104.83,58.85 104.8,58.82 104.75,58.82 v2(104.47,58.54) ; v2(100.96,57.74) 100.96,64.21 104.65,67.89 PRI70.2 106.58,68.02 PRI67.1 ; v2(100.8,32.28) 100.89,32.37 PRI12.2 ; PRG15.2 v2(148.41,11.71) ; PRI94.2 100.85,42.23 v2(100.84,42.21) ; v2(376.55,47.17) 375.87,47.85 RF6.2 ; v2(99.66,42.25) 99.66,43.75 98.45,44.96 98.45,50.1 v2(99.24,50.89) v2(99.24,57.24) 99.24,64.85 101.37,66.99 101.37,68.53 102.94,70.09 102.94,71.83 103.85,72.74 PRI69.2 104.49,73.35 104.19,73.65 104.19,74.93 105.97,82.58 105.97,112.03 109.38,115.44 v2(109.38,115.64) 109.38,119.02 108.17,120.23 108.17,122.64 107.53,123.28 107.53,125.42 CE61.1 108.36,125.49 108.82,125.02 110.23,125.02 110.7,124.56 JFC.1 ; CF5.1 373.56,49.39 374.66,50.49 375.8,50.49 v2(376.45,51.14) JFAN2.2 ; PRG02.1 132.66,14.69 132.66,14.69 PRG04.2 PRG03.2 132.66,13.06 v2(132.71,13) ; PRI109.2 102.38,50.94 v2(102.37,50.95) ; PRA01.2 v2(130.68,111.11) ; PR1201.1 352.12,53.29 351.66,52.83 v2(351.66,51.33) ; 171.16,147.28 169.7,147.28 169.13,146.71 169.13,144.59 169.03,144.49 v2(169.03,143.56) ; v2(100.46,22.86) 100.82,22.49 PRI29.2 ; v2(82.3,43.54) PCI204.1
  vias: v2(153.44,13.1) v2(154.03,13.1) v2(170.45,134.09) v2(170.45,133.37) v2(180.35,128.29) v2(180.36,127.72) v2(189.45,110.7) v2(190.02,110.7) v2(196.88,110.39) v2(197.83,110.34) v2(234.09,10.31) v2(234.09,9.68) v2(234.72,10.31) v2(234.72,9.68) v2(235.36,10.31) v2(235.36,9.68) v2(235.99,10.31) v2(235.99,9.68) v2(238.34,108.74) v2(238.92,108.74) v2(249.64,108.74) v2(250.23,108.74) v2(256.63,10.63) v2(256.63,9.99) v2(256.63,9.36) v2(257.26,10.63) v2(257.26,9.99) v2(257.26,9.36) v2(269.65,111.08) v2(269.9,110.51) v2(270.22,111.02) v2(311.62,61.24) v2(311.69,61.87) v2(312.2,61.55) v2(321.59,23.33) v2(322.16,23.33) v2(323.75,5.36) v2(324.07,5.93) v2(324.32,5.36) v2(345.36,15.52) v2(345.85,15.97) v2(346.28,16.43) v2(346.4,15.8) v2(346.79,16.89) v2(346.91,16.25) v2(370.32,48.41)
+5VS_TP_LED: length 20
  TOP w0.254: Q2409.4 92.15,20.28 C2508.1 C2501.1 92.15,19.46 92.54,19.07 v3(94.16,19.07) 95.45,17.78 v2(95.45,17.17)
  IN4 w0.254: v2(95.45,17.17) 95.45,17.11 96.96,15.6 107.18,15.6 v2(107.64,15.14)
+12V_COMP: length 6.3
  BOTTOM w0.127: PR1206.1 355.4,50.19 354.8,50.19 354.31,49.7 v1(354.31,49.54)
  BOTTOM w0.254: PU1201.1 357.33,53.12 357.17,53.27 356.92,53.27 356.67,53.01 356.67,51 356.34,50.67 PR1206.1
+12V_COMP_1: length 2.9
  BOTTOM w0.127: v1(352.33,51.2) 353.67,51.2 PC1207.1
  BOTTOM w0.508: PC1207.1 354.94,50.7 PR1206.2
+12V_ENA: length 7.8
  BOTTOM w0.254: PU1201.3 358.33,53.9 357.34,54.89 v1(355.12,54.89) PR1201.2 PR1205.1
+12V_FAN: length 414.2
  TOP w1.016: 237.51,4.72 231.98,4.72 227.2,9.5 227.2,10.62 223.35,14.46 199.44,14.46 190.97,22.92 179.97,22.92 178.83,21.78 148.96,21.78 146.43,24.31 138.4,24.31 135.42,21.33 123.59,21.33 121.91,19.65 121.91,19.35 120.18,17.62 120.18,16.45 119.07,15.35 119.07,13.85 115.38,10.15 98.45,10.15 97.44,11.17 97.44,13.33 v3(96.72,14.06) 96.72,16.03 96.39,16.36
  IN1 w1.016: 373.91,52.55 377.75,52.55 378.82,51.48 378.82,46.23 376.02,43.43 376.02,40.46 375.56,40 375.56,22.25 377.7,20.11 377.7,18.68 372.98,13.96 364.32,13.96 362.39,12.02 354.55,12.02 353.22,10.69 349.91,10.69 346.68,7.46 338.78,7.46 333.63,2.31 305.53,2.31 303.38,4.46 298.85,4.46 297,2.61 296.91,2.52 285.47,2.52 284.47,3.51 283.99,3.51 282.87,4.63 279.01,4.63 277.3,2.91 247.22,2.91 246.49,3.65 242.56,3.65 241.32,2.41
  BOTTOM w1.016: 96.11,18.16 96.09,18.18 96.09,20.99 93.75,23.33 88.21,23.33 86.42,25.12 81.18,25.12 79.96,26.34 79.96,37.46 78.94,38.48 73.33,38.48 72.62,39.19 72.62,41.48 85.74,54.6 CF6.1
  vias: v2(96.04,17.21) v2(96.65,17.17) v2(240.33,2.31) v2(240.66,1.7) v2(372.26,52.28) v2(372.9,52.28)
+12V_FB: length 5.2
  BOTTOM w0.254: v1(356.71,54.19) 356.91,54.19 357.83,53.27 PU1201.2
  BOTTOM w0.508: v1(356.71,54.19) 356.36,54.19 355.85,53.68 PC1204.2 355.88,53.24 PR1203.2 PR1204.1
+12V_LX:
  vias: v2(363.19,50.7) v2(363.19,50.12) v2(363.19,49.49) v2(363.19,48.85) v3(360.84,52.47)
+12V_SNUB: length 2
  TOP w0.127: PR1202.2 v3(358.18,51.97)
+12V_SS: length 1.2
  BOTTOM w0.127: PC1206.1 356.2,49.25 356.21,49.24 v1(356.21,48.48)
+12V_VIN: length 17.7
  TOP w0.127: v2(358.7,47.39) 358.3,47.39 v3(358.17,47.27)
  IN1 w0.508: v2(366.87,47.27) 367.44,47.84 367.44,51.27 366.23,52.47 361.15,52.47 360.58,51.9 360.58,51.27 358.7,49.39 v2(358.7,47.39)
+12VP: length 18.1
  IN1 w0.508: v2(354.23,52.42) 356.69,54.89 366.12,54.89 v2(368.68,52.32)
  BOTTOM w0.254: v2(354.23,52.42) PR1203.1 354.96,53.24 PC1204.1
  vias: v2(369.37,52.32) v3(369.22,49.93)
+19V_ADPIN_1:
  vias: v2(120.1,154.61) v2(120.31,155.67) v2(120.61,155.17) v2(120.69,154.61) v2(120.89,155.67) v2(121.2,155.17) v2(121.27,154.61) v2(121.47,155.67) v2(121.78,155.17) v2(121.86,154.61) v2(122.06,155.67) v2(122.36,155.17) v2(122.44,154.61) v2(122.64,155.67) v2(122.95,155.17) v2(123.05,154.6) v2(123.23,155.67) v2(123.53,155.17) v2(123.63,154.6) v2(123.81,155.67) v2(124.12,155.17) v2(124.22,154.6) v2(124.4,155.67) v2(124.7,155.17) v2(124.98,155.67) v2(125.28,155.17) v2(125.56,155.67) v2(125.88,163.42) v2(125.87,155.17) v2(126.15,155.67) v2(126.47,163.42) v2(126.45,155.17) v2(126.73,155.67) v2(127.04,155.17) v2(127.32,155.67) v3(120.87,157.57) v3(123.66,157.57) v3(126.52,159.6)
+19V_ADPIN_2:
  vias: v3(151.6,154.84) v3(152.56,151.92) v3(152.75,153.57)
+19V_VIN_1: length 33.6
  TOP w0.508: PR36.1 117,172.13 116.49,171.63 116.49,168.87 117.05,168.31 PC4.1
  BOTTOM w0.508: PRS58.1 113.25,165.23 PRS57.1 116.63,165.68 117.93,166.98 v2(117.93,167.58) ; PRS59.1 114.48,168.12 114.99,167.61 PCS69.1 115.55,167.54 v2(117.25,167.54) 117.25,168.83 116.51,169.57 116.51,170.35 117.37,171.21 117.37,172.86 116.67,173.57 115.46,173.57 115.14,173.25 112.04,173.25 111.53,172.74 PQS12.3 110.2,172.44 109.69,171.94 109.69,171.28 110.33,170.65 110.33,170.14 110.57,169.9 PRS63.1
  vias: v3(119.79,165)
+19V_VIN_2: length 2.9
  BOTTOM w0.508: PRS70.1 144.87,153.6 v2(144.83,153.64) ; PRS69.1 v2(149.38,152.36) ; PRS66.1 v2(144.82,149.69)
  vias: v2(138.2,151.41) v2(138.2,150.82) v2(138.2,150.24) v2(138.79,151.41) v2(138.79,150.82) v2(138.79,150.24) v2(139.37,151.41) v2(139.37,150.82) v2(139.37,150.24) v2(142.52,153.64) v2(143.28,153.64) v2(144.07,153.64) v2(145.64,153.64) v2(146.41,153.64) v2(147.17,153.64) v2(147.93,153.64) v2(148.74,153.67) v3(144.3,150.96)
+AVDD09: length 7.2
  TOP w0.203: UL1.7 189.89,167.51 v2(189.99,167.41) ; v2(189.77,171.44) 189.69,171.51 UL1.17 ; UL1.1 189.34,165.11 189.54,164.91 v2(189.54,164.77)
  TOP w0.254: v2(189.07,174.84) 189.06,174.83 189.06,174.27 188.81,174.02 188.25,174.02 187.99,174.27 UL1.23
  BOTTOM w0.127: v3(190.85,177.51) 190.53,177.51 189.32,176.29 RL38.1
  vias: v2(184.44,163) v2(184.75,163.47) v2(189.07,175.4)
+AVDD18: length 4.9
  TOP w0.203: v2(190.02,172.26) 189.97,172.31 189.51,172.31 189.51,172.31 UL1.19 ; v2(190.02,165.63) 189.89,165.76 189.65,165.76 189.49,165.91 UL1.3 ; v2(189.99,166.55) 189.87,166.55 189.71,166.71 UL1.5 ; UL1.21 189.3,173.11 189.36,173.18 v2(190.04,173.18)
  vias: v2(185,162.77) v2(185.3,163.27) v3(190.41,172.62)
+AVDD25: length 31
  TOP w0.203: v2(189.67,170.37) 189.61,170.31 UL1.14 ; v2(189.64,168.66) 189.59,168.71 UL1.10 ; v2(186.14,162.65) 186.17,162.67 186.17,163.58 186.06,163.68 186.06,163.75 186.04,163.77 186.04,163.89 185.99,163.94 UL1.83 ; v2(186.91,175.22) 186.79,175.11 UL1.26
  TOP w0.254: v2(187.19,163.41) 187.19,163.41 UL1.86
  IN1 w0.508: v2(187.19,163.41) 187.19,163.41 187.19,163.37 186.47,162.65 v2(186.14,162.65) 185.55,162.05 184.65,162.05 183.37,160.77 182.53,160.77 182.08,161.21 182.08,162.08 182.46,162.46 182.46,164.42 183.61,165.57 183.61,170.14 186.91,173.44 v2(186.91,175.22)
  BOTTOM w0.508: v2(189.64,168.66) 189.25,169.06 CL49.1 ; v2(189.67,170.37) 189.56,170.27 CL48.1 ; v2(186.91,175.22) 186.84,175.28 CL47.1
  vias: v3(187.22,159.03)
+AVDD33: length 41.1
  TOP w0.203: CL42.1 186.71,162.14 186.71,162.82 186.5,163.04 186.5,163.72 186.39,163.82 UL1.84 ; UL1.4 189.56,166.31 189.79,166.09 190.39,166.09 190.76,165.71 191.49,165.71 v2(191.62,165.84) ; UL1.12 v2(189.7,169.51)
  TOP w0.254: UL1.28 185.99,174.99 v2(185.83,175.16)
  TOP w0.508: CL43.1 186.84,176.24 v2(186.84,176.87) ; v2(186.27,161.25) 186.52,161.5 CL42.1
  IN1 w0.508: v2(185.83,175.16) 185.83,176.24 186.46,176.87 v2(186.84,176.87) 188.62,176.87 190.72,174.78 v2(190.97,174.78)
  IN2 w0.508: v2(190.97,174.78) 190.97,170.78 v2(189.7,169.51) 189.7,169.47 190.72,168.46 190.72,166.69 191.56,165.84 v2(191.62,165.84) 191.62,165.81 193.2,164.23 193.2,162.08 192.05,160.93 188.43,160.93 187.8,161.57 186.59,161.57 v2(186.27,161.25)
  BOTTOM w0.127: CL41.1 190.84,165.06 v3(191.48,164.42)
  BOTTOM w0.508: CL41.1 191.48,165.76 191.56,165.84 v2(191.62,165.84)
+DVDD09: length 2.8
  TOP w0.203: UL1.44 179.59,174.78 v2(179.22,175.16) ; UL1.51 178.06,171.11 v2(177.89,171.28) 178.13,171.51 UL1.50
  vias: v2(177.31,171.28) v2(181.76,163.41) v2(181.76,162.82) v2(183.76,175.97) v2(184.05,175.47) v3(181,176.81)
+DVDD18: length 18.9
  TOP w0.203: UL1.52 177.95,170.71 v2(177.82,170.58) ; UL1.70 180.79,163.61 180.37,163.19 v2(180.37,163)
  TOP w0.254: v2(182.72,175.51) 182.72,175.34 183.19,174.87 UL1.35
  IN2 w1.016: 182.02,174.84 181.26,174.08 181.26,165.57 178.65,162.96
  BOTTOM w0.508: CL59.1 178.45,170.58 v2(177.82,170.58) ; CL60.1 182.71,174.71 182.72,174.71 v2(182.72,175.51)
  vias: v2(177.51,161.82) v2(180.31,162.42) v2(183.1,176) v3(178.08,162.58)
+DVDD18_UPS: length 2.1
  TOP w0.203: 177.63,165.39 177.76,165.51 UL1.65
  TOP w0.508: CL64.1 177.63,165.39
  vias: v1(174.02,165.38)
+DVDD25_UPS:
  vias: v1(177.7,164.49)
+DVDD33: length 18.5
  TOP w0.203: v2(181.06,163.23) 181.19,163.36 UL1.71 ; v2(183.4,175.47) 183.4,175.4 183.59,175.21 UL1.34
  TOP w0.457: CL45.1 181.07,163.22 v2(181.06,163.23)
  IN1 w0.508: v2(181.06,163.23) 181.06,168.38 181.96,169.27 181.96,173.76 183.4,175.2 v2(183.4,175.47)
  BOTTOM w0.508: CL46.1 183.6,174.71 183.4,174.91 v2(183.4,175.47) ; v2(181.06,163.23) 181.06,162.75 181.03,162.71 RL44.1
+DVDD3318: length 16
  TOP w0.127: RL8.1 176.36,177.46 v1(175.78,176.87)
  TOP w0.203: UL1.41 180.79,176.05 CL1.1
  TOP w0.254: CL2.1 177.65,174.45 178.02,174.08 178.02,173.37 178.02,173.36 178.02,173.36 178.24,173.13 178.25,173.13 178.27,173.11 UL1.46
  TOP w0.508: RL8.1 RL6.1 RL58.1 179.21,177.46 v2(179.67,177) 180.12,176.54 CL1.1 ; RL2.1 RL1.1
  IN2 w0.508: v2(175.73,174.08) 176.36,174.08 179.29,177 v2(179.67,177)
+V18R: length 3.9
  TOP w0.127: v1(292.83,27.75) RE24.1
  TOP w0.254: 294.18,26.92 294.45,26.66 294.5,26.66 294.72,26.44 294.72,26.38 294.74,26.37 UE5.124
  TOP w0.508: RE24.1 294.18,26.92
+VCC_CORE: length 29.5
  TOP w0.508: v2(126.03,27.1) 127.2,27.1 127.71,26.59 RC197.1
  BOTTOM w0.102: v2(138.23,67.54) UC1.K18
  BOTTOM w0.254: UC1.M24 v2(140.04,61.12)
  BOTTOM w0.305: v2(131.83,49.8) UC1.B35 ; v2(138.23,59.31) UC1.J27 ; v2(132.75,52.54) UC1.C32 ; v2(136.41,53.46) UC1.F31 ; v2(140.06,66.63) UC1.L19 ; UC1.J21 v2(138.23,64.8) UC1.K20 ; v2(132.75,48.88) UC1.C36 ; v2(139.94,68.46) 139.61,68.13 UC1.L17 ; v2(140.04,61.12) UC1.L25 ; v2(138.23,61.14) UC1.J25 ; v2(130,57.49) UC1.A29 ; UC1.L23 139.92,62.82 139.92,62.96 v2(139.92,62.96) ; v2(131.83,51.63) UC1.B33 ; v2(134.58,50.71) UC1.D34 ; v2(134.58,53.46) UC1.D31 ; v2(130.92,58.4) UC1.A28 ; v2(130.92,56.57) UC1.A30 ; UC1.M30 v2(140.93,55.71) ; v2(138.23,57.49) UC1.J29 ; v2(139.15,55.66) UC1.L30 ; UC1.B37 132.29,47.63 v2(131.76,48.15) ; v2(138.23,52.54) UC1.H32 ; v2(130,59.31) UC1.A27 ; v2(131.83,53.46) UC1.B31 ; v2(140.98,60.23) UC1.M26 ; v2(138.23,62.97) UC1.J23 ; v2(140.98,65.71) UC1.M20 ; v2(132.75,50.71) UC1.C34 ; 140.98,69.37 UC1.M16 ; v2(140.06,64.8) UC1.L21 ; v2(134.58,48.88) UC1.D36 ; v2(130.92,60.23) UC1.A25 ; v2(138.23,55.66) UC1.J30 ; v2(138.23,53.46) UC1.H31 ; v2(134.58,52.54) UC1.D32
  BOTTOM w0.381: UC1.G32 v2(136.41,52.54) UC1.F32 ; UC1.K31 v2(139.15,53.46) UC1.J31
  vias: v2(119.66,46.51) v2(120.3,46.51) v2(120.62,44.16) v2(120.62,43.39) v2(120.62,42.63) v2(120.62,41.87) v2(120.62,41.11) v2(120.62,39.58) v2(120.62,38.82) v2(120.62,38.06) v2(120.62,37.3) v2(120.62,36.54) v2(120.62,35.01) v2(120.62,34.25) v2(120.62,33.49) v2(120.62,32.73) v2(120.62,28.92) v2(120.93,46.51) v2(120.93,45.74) v2(120.96,62.47) v2(120.96,61.88) v2(121.2,44.16) v2(121.2,43.39) v2(121.2,42.63) v2(121.2,41.87) v2(121.2,41.11) v2(121.2,39.58) v2(121.2,38.82) v2(121.2,38.06) v2(121.2,37.3) v2(121.2,36.54) v2(121.2,35.01) v2(121.2,34.25) v2(121.2,33.49) v2(121.2,32.73) v2(121.2,31.96) v2(121.2,30.44) v2(121.2,29.68) v2(121.2,28.92) v2(121.53,62.47) v2(121.53,61.88) v2(121.52,46.51) v2(121.52,45.74) v2(121.85,69.11) v2(121.85,68.53) v2(121.85,67.94) v2(121.78,44.16) v2(121.78,43.39) v2(121.78,42.63) v2(121.78,41.87) v2(121.78,41.11) v2(121.78,39.58) v2(121.78,38.82) v2(121.78,38.06) v2(121.78,37.3) v2(121.78,36.54) v2(121.78,35.01) v2(121.78,34.25) v2(121.78,33.49) v2(121.78,32.73) v2(121.78,31.96) v2(121.78,30.44) v2(121.78,29.68) v2(121.78,28.92) v2(122.1,62.47) v2(122.1,61.88) v2(122.1,46.51) v2(122.1,45.74) v2(122.43,69.11) v2(122.43,68.53) v2(122.43,67.94) v2(122.37,48.73) v2(122.37,47.97) v2(122.37,47.2) v2(122.37,44.16) v2(122.37,43.39) v2(122.37,42.63) v2(122.37,41.87) v2(122.37,41.11) v2(122.37,39.58) v2(122.37,38.82) v2(122.37,38.06) v2(122.37,37.3) v2(122.37,36.54) v2(122.37,35.01) v2(122.37,34.25) v2(122.37,33.49) v2(122.37,32.73) v2(122.37,31.96) v2(122.37,30.44) v2(122.37,29.68) v2(122.37,28.92) v2(122.65,58.44) v2(122.65,57.68) v2(122.69,62.47) v2(122.69,61.88) v2(122.69,46.51) v2(122.69,45.74) v2(123.02,69.11) v2(123.02,68.53) v2(123.02,67.94) v2(122.95,48.73) v2(122.95,47.97) v2(122.95,47.2) v2(122.95,44.16) v2(122.95,43.39) v2(122.95,42.63) v2(122.95,41.87) v2(122.95,41.11) v2(122.95,39.58) v2(122.95,38.82) v2(122.95,38.06) v2(122.95,37.3) v2(122.95,36.54) v2(122.95,35.01) v2(122.95,34.25) v2(122.95,33.49) v2(122.95,32.73) v2(122.95,31.96) v2(122.95,30.44) v2(122.95,29.68) v2(122.95,28.92) v2(123.22,57.68) v2(123.27,62.47) v2(123.27,61.88) v2(123.27,46.51) v2(123.27,45.74) v2(123.54,31.96) v2(123.54,30.44) v2(123.54,29.68) v2(123.6,69.11) v2(123.6,68.53) v2(123.6,67.94) v2(123.6,67.36) v2(123.6,66.77) v2(123.6,66.19) v2(123.79,64.54) v2(123.79,63.78) v2(123.79,63.02) v2(123.79,62.25) v2(123.79,61.49) v2(123.79,59.97) v2(123.79,59.21) v2(123.79,58.44) v2(123.79,57.68) v2(123.79,53.87) v2(123.79,53.11) v2(123.79,52.35) v2(123.79,51.59) v2(123.79,50.82) v2(123.79,49.3) v2(123.79,48.54) v2(123.79,47.78) v2(123.79,47.01) v2(123.79,46.25) v2(123.79,45.49) v2(123.79,43.97) v2(123.79,43.2) v2(123.79,42.44) v2(124.38,64.54) v2(124.38,63.78) v2(124.38,63.02) v2(124.38,62.25) v2(124.38,61.49) v2(124.38,59.97) v2(124.38,59.21) v2(124.38,58.44) v2(124.38,57.68) v2(124.38,56.92) v2(124.38,55.4) v2(124.38,54.63) v2(124.38,53.87) v2(124.38,53.11) v2(124.38,52.35) v2(124.38,51.59) v2(124.38,50.82) v2(124.38,49.3) v2(124.38,48.54) v2(124.38,47.78) v2(124.38,47.01) v2(124.38,46.25) v2(124.38,45.49) v2(124.38,43.97) v2(124.38,43.2) v2(124.38,42.44) v2(124.96,63.78) v2(124.96,63.02) v2(124.96,62.25) v2(124.96,61.49) v2(124.96,59.97) v2(124.96,59.21) v2(124.96,58.44) v2(124.96,57.68) v2(124.96,56.92) v2(124.96,55.4) v2(124.96,54.63) v2(124.96,53.87) v2(124.96,53.11) v2(124.96,52.35) v2(124.96,51.59) v2(124.96,50.82) v2(124.96,49.3) v2(124.96,48.54) v2(124.96,47.78) v2(124.96,47.01) v2(124.96,46.25) v2(124.96,45.49) v2(124.96,43.97) v2(124.96,43.2) v2(124.96,42.44) v2(125.54,63.02) v2(125.54,62.25) v2(125.54,61.49) v2(125.54,59.97) v2(125.54,59.21) v2(125.54,58.44) v2(125.54,57.68) v2(125.54,56.92) v2(125.54,55.4) v2(125.54,54.63) v2(125.54,53.87) v2(125.54,53.11) v2(125.54,52.35) v2(125.54,51.59) v2(125.54,50.82) v2(125.54,49.3) v2(125.54,48.54) v2(125.54,47.78) v2(125.54,47.01) v2(125.54,46.25) v2(125.54,45.49) v2(125.54,43.97) v2(126.13,62.25) v2(126.13,61.49) v2(126.13,59.97) v2(126.13,59.21) v2(126.13,58.44) v2(126.13,57.68) v2(126.13,56.92) v2(126.13,55.4) v2(126.13,54.63) v2(126.13,53.87) v2(126.13,53.11) v2(126.13,52.35) v2(126.13,51.59) v2(126.13,50.82) v2(126.13,49.3) v2(126.13,48.54) v2(126.13,47.78) v2(126.13,47.01) v2(126.13,46.25) v2(126.13,45.49) v2(126.71,61.49) v2(126.71,59.97) v2(126.71,59.21) v2(126.71,58.44) v2(126.71,57.68) v2(126.71,56.92) v2(126.71,55.4) v2(126.71,54.63) v2(126.71,53.87) v2(126.71,53.11) v2(126.71,52.35) v2(126.71,51.59) v2(126.71,50.82) v2(126.71,49.3) v2(126.71,48.54) v2(126.71,47.78) v2(126.71,47.01) v2(126.71,46.25) v2(126.71,45.49) v2(127.3,61.49) v2(127.3,59.97) v2(127.3,59.21) v2(127.3,58.44) v2(127.3,57.68) v2(127.3,56.92) v2(127.3,55.4) v2(127.3,54.63) v2(127.3,53.87) v2(127.3,53.11) v2(127.3,52.35) v2(127.3,51.59) v2(127.3,50.82) v2(127.3,49.3) v2(127.3,48.54) v2(127.3,47.78) v2(127.3,47.01) v2(127.3,46.25) v2(127.3,45.49) v2(128.22,59.87) v2(128.25,58.65) v2(128.22,57.52) v2(128.18,56.25) v2(128.24,55.16) v2(128.24,54.06) v2(128.26,52.97) v2(128.26,51.88) v2(128.26,50.81) v2(128.26,49.67) v2(128.26,48.53) v2(129.12,59.88) v2(129.15,58.66) v2(129.17,57.53) v2(129.52,56.3) v2(129.89,55.08) v2(129.94,53.99) v2(129.97,60.27) v2(129.99,52.89) v2(130.01,51.8) v2(129.99,50.73) v2(130.01,49.59) v2(129.99,48.45) v2(130.93,59.32) v2(130.93,57.47) v2(131.75,52.52) v2(131.75,50.74) v2(131.75,48.84) v2(131.88,60.27) v2(131.88,58.43) v2(131.88,56.52) v2(132.7,59.25) v2(132.75,58.4) v2(132.7,57.47) v2(132.75,56.58) v2(132.7,55.63) v2(132.7,51.63) v2(132.7,49.79) v2(132.74,48.11) v2(132.77,60.23) v2(133.66,62.05) v2(133.72,61.09) v2(133.72,59.25) v2(133.72,57.47) v2(133.72,55.63) v2(133.66,52.46) v2(133.66,50.68) v2(133.72,48.9) v2(134.54,60.27) v2(134.54,58.43) v2(134.54,56.59) v2(134.54,51.63) v2(134.54,49.79) v2(134.59,62.03) v2(134.59,61.12) v2(134.58,59.31) v2(134.58,57.49) v2(134.58,55.66) v2(135.5,62.03) v2(135.5,61.09) v2(135.5,59.19) v2(135.5,57.47) v2(135.5,52.52) v2(135.56,55.57) v2(135.56,50.74) v2(135.56,48.9) v2(136.41,62.97) v2(136.39,62.05) v2(136.41,61.14) v2(136.39,60.27) v2(136.41,59.31) v2(136.39,58.36) v2(136.41,57.49) v2(136.39,56.59) v2(136.41,55.66) v2(136.39,51.63) v2(136.45,50.68) v2(136.45,49.73) v2(137.34,62.94) v2(137.34,61.03) v2(137.34,59.19) v2(137.34,57.47) v2(137.34,52.46) v2(137.34,50.68) v2(137.34,49.92) v2(138.24,68.46) v2(138.23,65.67) v2(138.23,63.95) v2(138.23,62.11) v2(138.23,60.27) v2(138.23,58.43) v2(138.23,56.65) v2(138.23,51.57) v2(138.23,50.74) v2(139.12,64.84) v2(139.12,49.85) v2(139.18,69.35) v2(139.18,67.51) v2(139.18,65.67) v2(139.18,62.94) v2(139.18,61.09) v2(139.18,59.25) v2(139.18,57.47) v2(139.18,51.63) v2(139.92,69.37) v2(139.92,63.9) v2(139.92,52.54) v2(139.95,50.73) v2(140.07,67.51) v2(140.07,65.6) v2(140.07,60.14) v2(140.07,56.52) v2(141.57,60.98) v2(141.57,60.09) v2(141.6,56.92) v2(141.94,66.36) v2(141.97,64.53) v2(141.96,60.53) v2(142.33,60.98) v2(142.26,56.89) v2(142.43,60.07) v2(142.74,60.55) v2(142.89,56.94) v2(143.09,60.07) v2(143.33,61.05) v2(143.43,62.55) v2(143.94,61.05) v2(144.04,62.55) v2(144.54,61.03) v2(144.62,62.55) v2(148.12,62.55) v2(148.16,61.01) v2(148.73,62.55) v2(148.75,61.01) v2(149.32,62.55) v2(149.33,61.04) v2(149.94,61.04) v2(150.53,61.04) v2(151.2,61.05) v2(151.81,61.05) v2(152.39,61.05) v2(154.59,60.54) v2(154.91,71.4) v2(154.91,70.83) v2(155.35,60.54) v2(156.05,60.54) v2(156.24,66.72) v2(156.22,65.66) v2(156.52,64.43) v3(118.52,36.15)
+VCCGT: length 12.3
  TOP w0.508: v2(137.77,29.46) 137.25,29.98 RC691.1
  BOTTOM w0.203: v2(151.01,51.6) UC1.AB33
  BOTTOM w0.305: v2(146.46,48.88) UC1.U36 ; UC1.N40 v2(142.81,45.23) ; UC1.Y34 149.21,50.71 ; v2(144.63,47.06) UC1.R38 ; 147.38,50.71 UC1.V34 ; v2(140.98,47.06) UC1.L38 ; UC1.N38 v2(142.81,47.06) ; v2(140.98,45.23) UC1.L40 ; v2(139.15,47.06) UC1.J38 ; v2(143.72,50.71) UC1.P34 ; v2(144.63,48.88) UC1.R36 ; v2(146.46,47.06) UC1.U38 ; UC1.Y33 149.21,51.63 ; UC1.N36 v2(142.81,48.88) ; v2(144.63,45.23) UC1.R40 ; v2(139.15,45.23) UC1.J40
  vias: v2(137.28,47.95) v2(137.28,47.06) v2(137.28,46.17) v2(137.4,44.2) v2(137.85,30.5) v2(137.77,28.45) v2(137.79,27.66) v2(138.23,44.08) v2(138.29,47) v2(138.29,45.22) v2(138.43,30.71) v2(138.43,26.97) v2(138.7,42.19) v2(138.7,41.61) v2(138.7,41.02) v2(138.7,40.44) v2(138.7,39.52) v2(138.7,38.94) v2(138.7,38.36) v2(138.7,37.77) v2(138.7,36.73) v2(138.7,36.15) v2(138.7,35.56) v2(138.7,34.98) v2(139.12,47.95) v2(139.12,46.17) v2(139.06,30.71) v2(139.06,26.97) v2(139.16,48.85) v2(139.18,44.39) v2(139.7,30.71) v2(139.7,26.97) v2(139.9,42.19) v2(139.9,41.61) v2(139.9,41.02) v2(139.9,40.44) v2(139.9,39.52) v2(139.9,38.94) v2(139.9,38.36) v2(139.9,37.77) v2(139.9,36.73) v2(139.9,36.15) v2(139.9,35.56) v2(139.9,34.98) v2(140.07,48.77) v2(140.13,47) v2(140.13,45.22) v2(140.07,44.08) v2(140.33,30.71) v2(140.33,26.97) v2(140.97,50.57) v2(141.02,49.85) v2(141.02,48.84) v2(140.96,48.01) v2(140.96,46.17) v2(141.02,44.33) v2(141.15,29.92) v2(141.15,28.9) v2(141.17,42.19) v2(141.17,41.61) v2(141.17,41.02) v2(141.17,40.44) v2(141.17,39.52) v2(141.17,38.94) v2(141.17,38.36) v2(141.17,37.77) v2(141.17,36.73) v2(141.17,36.15) v2(141.17,35.56) v2(141.17,34.98) v2(141.17,27.99) v2(141.17,26.97) v2(141.54,30.85) v2(141.91,47.06) v2(141.91,45.16) v2(141.91,44.08) v2(141.97,48.84) v2(142.18,30.85) v2(142.16,29.89) v2(142.19,28.9) v2(142.19,27.99) v2(142.19,26.97) v2(142.57,42.19) v2(142.57,41.61) v2(142.57,41.02) v2(142.57,40.44) v2(142.57,39.52) v2(142.57,38.94) v2(142.57,38.36) v2(142.57,37.77) v2(142.57,36.73) v2(142.57,36.15) v2(142.57,35.56) v2(142.57,34.98) v2(142.8,50.57) v2(142.8,49.85) v2(142.8,48.01) v2(142.8,46.11) v2(142.8,44.33) v2(142.81,30.85) v2(143.13,26.97) v2(143.45,30.85) v2(143.75,48.84) v2(143.75,47.06) v2(143.75,45.16) v2(143.75,44.14) v2(143.76,26.97) v2(144.09,42.26) v2(144.09,41.67) v2(144.09,41.09) v2(144.09,40.5) v2(144.09,39.59) v2(144.09,39) v2(144.09,38.42) v2(144.09,37.84) v2(144.09,36.79) v2(144.09,36.21) v2(144.09,35.63) v2(144.09,35.04) v2(144.28,30.85) v2(144.4,26.97) v2(144.61,49.74) v2(144.58,47.95) v2(144.58,46.17) v2(144.64,44.39) v2(145.03,26.97) v2(145.53,47) v2(145.59,48.84) v2(145.59,45.21) v2(145.59,44.14) v2(145.55,42.26) v2(145.55,41.67) v2(145.55,41.09) v2(145.55,40.5) v2(145.55,39.59) v2(145.55,39) v2(145.55,38.42) v2(145.55,37.84) v2(145.55,36.79) v2(145.55,36.21) v2(145.55,35.63) v2(145.55,35.04) v2(145.87,26.97) v2(146.04,43.63) v2(146.46,49.74) v2(146.48,48.01) v2(146.48,45.28) v2(146.48,44.14) v2(147.31,47.06) v2(147.44,48.84) v2(147.37,46.23) v2(147.44,45.22) v2(147.55,29.87) v2(147.55,28.85) v2(147.55,27.84) v2(148.32,49.79) v2(148.28,48.88) v2(148.26,47.95) v2(148.26,47.06) v2(148.26,46.17) v2(148.56,29.87) v2(148.56,28.85) v2(148.56,27.84) v2(149.15,27) v2(149.21,47) v2(149.2,30.66) v2(149.28,48.84) v2(149.83,30.66) v2(149.78,27) v2(150.12,47.06) v2(150.42,27) v2(150.47,30.66) v2(151.1,30.66) v2(151.05,27) v2(151.84,29.87) v2(151.84,28.85) v2(151.84,27.84) v2(151.83,26.97) v2(151.95,30.66) v2(152.46,26.97) v2(152.59,30.66) v2(152.86,29.87) v2(152.86,28.85) v2(152.86,27.84) v2(153.1,26.97) v2(153.22,30.66) v2(153.73,26.97) v2(153.86,30.66) v2(154.32,54.6) v2(154.31,53.96) v2(154.32,53.32) v2(154.33,52.54) v2(154.33,51.97) v2(154.57,26.97) v2(154.7,30.66) v2(155.92,52.79) v2(155.92,52.16) v2(156.1,54.67) v2(156.1,54.09) v2(156.1,53.46) v2(157.61,26.85) v2(158.24,26.85) v2(158.4,28.15) v2(158.4,27.58) v2(158.88,26.85) v2(159.51,26.85) v3(148.3,34.76)
+VCCIO: length 5.6
  TOP w0.102: v2(158.37,59.88) 158.37,59.67 v3(158.63,59.41)
  TOP w0.508: v2(142.96,75.08) 142.84,74.95 RC10.1 142.34,75.19 142.01,75.52 RC14.1
  BOTTOM w0.356: v2(158.37,59.88) UC1.AK24 UC1.AJ23 ; UC1.AK11 157.53,71.65 157.45,71.65 v2(157.45,71.64) ; v2(158.37,68.07) UC1.AK14
  vias: v2(147.03,72.29) v2(147.61,72.29) v2(149.38,72.73) v2(149.96,72.73) v2(150.65,72.73) v2(151.23,72.73) v2(152.11,73.11) v2(152.69,73.11) v2(153.69,72.98) v2(153.69,72.29) v2(154.28,72.98) v2(154.28,72.29) v2(154.91,72.92) v2(154.9,72.29) v2(162.84,106.44) v2(162.84,105.8) v2(163.47,106.44) v2(163.47,105.8) v2(164.11,106.44) v2(164.11,105.8)
+VCCIOP: length 4.5
  BOTTOM w0.254: 160.5,107.52 160.5,108.51 v1(161.5,109.51) 162.15,110.15 PRF05.1 162.13,110.52 161.34,110.52 PCF11.1
+VCCRTCEXT: length 5.1
  TOP w0.127: CH264.2 268.69,67.97 v1(268.32,67.97)
  TOP w0.254: UH1.BF47 UH1.BG47 269.46,64.19 269.46,64.23 269.33,64.35 269.33,64.67 269.27,64.73
  TOP w0.508: CH264.2 269.27,64.73
+VCCSA: length 25.6
  IN1 w0.508: v2(128.36,110.83) 126.33,108.8 v2(126.33,101.05)
  BOTTOM w0.254: UC1.AB8 150.18,75.72 v2(150.96,75.72) ; UC1.AB6 v2(149.21,78.51) ; v2(149.25,76.74) 149.25,76.73 UC1.AB7 ; UC1.V7 UC1.W7 146.92,77.26 v2(147.28,77.62) ; UC1.Y8 UC1.Y7 UC1.Y6 147.85,78.06 v2(148.3,78.51) ; v2(150.96,76.67) 150.96,76.54 150.65,76.23 UC1.AC8
  BOTTOM w0.305: UC1.T7 144.27,77.14 v2(144.68,77.56) UC1.U7 ; UC1.R7 142.85,76.73 v2(142.71,76.73) 142.67,76.73 142.35,77.05 UC1.P7 142.35,77.21 142.03,77.53 v2(141.82,77.53) 141.76,77.53 141.43,77.21 UC1.N7 ; 150.02,77.7 UC1.AC7
  BOTTOM w0.33: UC1.AA7 148.57,77.32 148.57,77.88 UC1.AA6
  BOTTOM w0.356: UC1.AB6 150.02,77.7
  BOTTOM w0.381: v2(149.25,77.56) 148.75,78.06 UC1.AA6
  BOTTOM w0.508: PRA17.2 v2(128.36,110.83)
  vias: v2(130.59,101.62) v2(130.59,99.85) v2(133.51,101.69) v2(133.51,99.91) v2(143.75,77.53) v2(144.32,104.87) v2(144.77,106.34) v2(144.77,105.57) v2(145.08,104.87) v2(145.53,106.34) v2(145.53,105.57) v2(145.85,104.87) v2(146.29,106.34) v2(146.29,105.57) v2(146.61,104.87) v2(147.05,106.34) v2(147.05,105.57) v2(147.37,104.87) v2(147.81,106.34) v2(147.81,105.57) v2(148.13,104.87) v2(148.58,106.34) v2(148.58,105.57) v3(137.76,90.57)

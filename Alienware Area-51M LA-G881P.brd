# Allegro board Alienware Area-51M LA-G881P.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+PWR_SRC on TOP: 124.91,106.83 117.35,114.39 117.35,118.86 118.14,119.65 122.81,119.65 123.61,118.85 123.61,115.06 124.54,114.13 151.29,114.13 152.37,113.05 158.11,113.05 159.67,114.62 159.67,119.32 158.69,120.3 158.69,130.54 157.58,131.66 156.24,131.66 156.13,131.77 156.13,135.11 156.11,135.13 155.35,135.13 155.35,131.85 155.15,131.65 154.15,131.65 154,131.8 154,140.93 155.25,142.18 163.62,142.18 165.95,139.85 165.95,133.51 165.94,133.5 165.94,130.65 172.86,123.73 180.76,123.73 184.05,127.01 184.05,134.51 184.21,134.67 185.95,134.67 186.17,134.89 186.17,138.45 185.6,139.02 184.49,139.02 184.05,139.47 184.05,150.77 184.42,151.14 189.2,151.14 189.45,150.89 189.45,146.14 191.16,144.42 191.16,127.41 194.45,124.12 209.23,124.12 209.86,123.5 209.86,118.17 209.15,117.46 192.08,117.46 181.45,106.83
+PWR_SRC on BOTTOM: 122.75,119.56 122.75,115.72 115.03,108 112.79,108 110.38,110.41 110.38,115.31 115.14,120.08 122.23,120.08
+PWR_SRC on BOTTOM: 219.39,112.93 200.27,112.93 200.26,112.92 197.32,112.92 196.98,113.27 196.17,113.27 194.57,111.67 188.16,111.67 187.56,111.07 167.84,111.07 165.88,113.04 165.88,113.12 162.58,113.12 161.44,114.26 161.44,116.86 158.3,120.01 157.47,120.01 153.82,123.66 153.82,140.87 155.41,142.45 163.16,142.45 165.76,139.85 165.76,133.63 165.32,133.18 165.32,128.92 167.7,126.55 169.35,126.55 173.63,122.26 181,122.26 181.03,122.29 182.86,122.29 184.6,124.03 184.6,125.58 182.22,127.95 182.22,130.52 182.53,130.82 182.53,131.47 182.22,131.78 182.22,141.7 184.17,143.66 189.83,143.66 190.4,143.09 190.4,133.25 192.5,131.15 192.5,129.56 196.12,125.94 209.01,125.94 212.63,122.32 262.17,122.32 262.26,122.24 262.26,119.33 262.87,118.73 269.17,118.73 269.58,119.14 269.58,122.2 269.71,122.32 283.46,122.32 285.42,120.37 285.42,113.64 284.68,112.9 276.57,112.9 275.81,112.14 275.81,111.52 275.05,110.76 275.05,108.93 275.36,108.62 276.84,108.62 276.92,108.55 276.92,101.47 276.75,101.29 269.71,101.29 269.08,101.93 269.08,102.26 269.14,102.32 269.14,110.62 268.48,111.28 221.04,111.28
+PWR_SRC on IN1: 206.82,117.91 204.53,120.2 204.53,124.69 205.79,125.94 209.01,125.94 212.51,122.45 224.72,122.45 225.42,121.75 239.5,121.75 240.28,122.53 253.62,122.53 254.31,121.84 262.2,121.84 265.31,118.73 270.93,118.73 274.52,122.32 283.46,122.32 285.42,120.37 285.42,113.64 284.68,112.9 266.64,112.9 265.99,113.55 239.57,113.55 235.21,117.91
+PWR_SRC on GND2: 54.05,20.98 53.56,21.46 53.56,31.29 75.13,52.86 79.85,52.86 79.87,52.86 81.3,53.54 81.88,55.01 81.88,58.57 81.88,58.59 82.05,59.41 82.64,60 82.65,60.01 98.51,76.41 104.86,98.32 112.64,98.32 113.88,97.07 113.88,95.38 113.65,95.15 108.5,95.15 100.02,71.51 100.07,71.42 99.72,66.76 95.55,64.65 95.49,64.67 95.42,64.66 95.36,64.67 95.16,64.58 95.09,64.37 90.86,60.34 86.07,57.01 86.04,56.99 86.02,56.97 83.91,54.87 83.91,53.6 83.17,52.86 79.87,49.55 76.06,49.55 56.86,30.35 56.86,21.34 56.5,20.98
+PWR_SRC on IN2: 305.28,30.12 304.14,31.27 302.11,31.27 300.46,32.92 300.46,46.3 300.8,46.64 301.83,46.64 302.49,47.3 302.49,49.62 301.91,50.2 301.91,50.95 301.13,51.73 300.66,51.73 300.46,51.93 300.46,56.41 293.75,63.12 293.75,68.41 292.64,71.52 293.08,74 297.78,75.72 299.37,75.84 302.99,71.08 305.31,68.89 308.67,65.46 312.37,62.38 312.37,57.88 315.52,54.74 315.52,32.13 313.51,30.12
+PWR_SRC on IN2: 155.16,142.24 162.57,142.24 165.08,139.73 165.08,134.56 164.44,133.92 164.44,129.51 165.4,128.55 165.4,123.9 166.35,122.94 166.35,112.41 163.83,109.89 113.32,109.89 112.78,110.44 110.07,113.15 110.07,114.87 116.5,121.3 152.48,121.3 153.76,122.58 153.76,140.84
+PWR_SRC on IN2: 274.9,111.73 272.38,114.26 201.07,114.26 200.02,115.31 196.62,118.7 192.12,118.7 189.89,120.93 189.89,127.15 186.59,130.45 186.59,134.39 187.48,135.28 192.88,135.28 194.15,134.01 194.15,130.13 198.34,125.94 201.07,125.94 202.53,124.48 210.78,124.48 212.78,122.48 225.89,122.48 226.27,122.1 228.63,122.1 228.64,122.07 228.89,121.86 229.2,121.94 229.26,121.96 229.55,121.85 229.84,121.96 229.91,121.94 230.22,121.86 230.46,122.07 230.48,122.1 283.59,122.1 284.61,121.08 284.61,120.93 285.84,119.69 285.84,107.78 284.95,106.89 278.1,106.89 277.46,107.53 277.46,111.53 277.26,111.73
+PWR_SRC on IN3: outline of 115 points within 205.46,104.16 285.59,123.78
+PWR_SRC on IN3: 179.07,123.87 183.31,128.12 183.31,140.4 186.32,143.41 190.65,143.41 192.35,141.7 192.35,128.69 191.93,128.27 191.93,123.47 182.73,114.27 119.76,114.27 119.72,114.32 118.65,114.32 117.88,115.09 117.88,120.42 118.76,121.29 153.36,121.29 153.89,121.82 153.89,140.8 155.76,142.68 164.71,142.68 168.17,139.22 168.17,129.37 173.19,124.36 177.25,124.36 177.74,123.87
+PWR_SRC on IN3: 305.28,30.12 304.14,31.27 302.11,31.27 300.46,32.92 300.46,43.77 303.05,46.37 303.05,50.7 301.78,51.97 301.78,53.49 300.46,54.82 300.46,56.41 295.51,61.36 295.51,63.29 293.75,65.04 293.75,67.59 293.21,68.13 293.21,73.49 294.42,74.7 298.35,74.7 301.48,71.58 303.11,71.58 308.8,65.34 315.52,60.23 315.52,32.13 313.51,30.12 ; 4 cut-outs
+PWR_SRC on GND4: 189.72,115.21 187.07,117.86 187.07,126.62 186.44,127.26 186.44,133.5 186.95,134.01 191.08,134.01 191.87,133.22 191.87,129.38 193.09,128.17 208.07,128.17 209.3,126.94 209.3,117.96 206.55,115.21
+RTC_CELL on TOP (solid shape): 265.77,70.63 265.77,69.11 266.44,68.44 266.44,68.19 267.1,67.52 267.1,64.19 268.4,62.88 268.77,62.88 268.89,62.77 268.89,62.13 268.83,62.08 268.61,62.08 268.49,62.21 268.43,62.21 268.33,62.31 267.97,62.31 266.56,63.71 266.56,66.43 265.02,67.97 265.02,70.67 265.06,70.71 265.7,70.71
+SDC on BOTTOM (solid shape): 128.49,134.79 128.49,133.83 128.39,133.74 127.51,133.74 127.32,133.54 127.32,132.22 127.12,132.02 125.82,132.02 125.67,132.17 125.67,132.93 126.28,133.54 126.28,134.66 126.47,134.86 128.42,134.86
+SDC_IN on TOP (solid shape): outline of 165 points within 122.53,120.67 158.24,138.96
+SDC_IN on BOTTOM (solid shape): 128.68,138.58 128.68,136.36 128.55,136.23 127.6,136.23 127.34,136.48 127.34,138.71 127.47,138.83 128.42,138.83
+SDC_IN on BOTTOM (solid shape): 139.64,124.68 139.64,123.8 139.28,123.44 137.34,123.44 137.18,123.59 137.18,124.8 137.38,124.99 139.33,124.99
+SDC_IN on BOTTOM (solid shape): 127.81,143.56 127.81,143.08 127.91,142.99 128.72,142.99 128.92,142.79 128.92,142.37 128.79,142.23 127.72,142.23 127.08,142.88 127.08,143.6 127.2,143.72 127.65,143.72
+SDC_IN on BOTTOM (solid shape): 150.38,140.84 151.37,140.84 151.52,140.69 151.52,140.07 151.41,139.96 150.67,139.96 150.55,139.98 150.42,139.96 149.82,139.96 149.43,140.35 149.43,141.11 149.53,141.21 150.02,141.21
+SDC_IN on BOTTOM (solid shape): 125.96,134.17 125.96,133.44 125.51,132.99 125.51,131.91 125.86,131.56 125.86,130.34 125.85,130.33 125.85,130.11 126.1,129.86 127.08,129.86 127.53,130.31 130.86,130.31 130.96,130.22 130.96,127.74 130.63,127.41 124.58,127.41 123.49,128.49 123.49,133.96 123.81,134.28 125.85,134.28
+SDC_IN on IN2 (solid shape): outline of 368 points within 126.67,121.64 152.67,131.09
+SDC_IN on IN3 (solid shape): outline of 367 points within 126.67,121.64 152.59,130.86
+SDC_IN on IN1: 127.36,131.16 134.01,131.16 138.02,127.15 145.77,127.15 147.47,128.85 152.53,128.85 153.16,128.22 153.16,125.14 152.55,124.53 149.88,124.53 146.05,120.7 130.43,120.7 127.02,124.1 127.02,130.83
+SDC_IN on IN4: 127.2,131.82 135.43,131.82 136.96,130.3 136.96,128.06 137.64,127.38 139.09,127.38 140.11,126.36 140.11,124.53 140.94,123.7 142.52,123.7 147.9,129.08 153.62,129.08 154.53,128.17 154.53,122.15 153.21,120.83 150.65,120.83 150.39,120.57 145.36,120.57 145.31,120.62 130.45,120.62 126.87,124.2 126.87,131.49
+TBTA_VBUS on TOP (solid shape): 9.81,46.95 9.81,46.63 9.74,46.57 7.27,46.57 7.14,46.7 7.14,46.76 7.27,46.89 8.09,46.89 8.28,47.08 9.68,47.08
+TBTA_VBUS on TOP (solid shape): 6.58,44.55 6.88,44.55 7.04,44.4 9.07,44.4 9.17,44.5 9.17,44.5 9.22,44.55 9.99,44.55 10.13,44.41 10.13,43.39 10,43.27 9.24,43.27 8.6,43.9 8.31,43.9 8.22,43.99 8.2,43.99 8.13,44.07 6.98,44.07 6.91,44.14 6.65,44.14 6.45,44.35 5.74,44.35 5.66,44.42 5.66,44.52 5.74,44.6 6.53,44.6
+TBTA_VBUS on TOP (solid shape): outline of 141 points within 45.36,43.7 51.13,51.39
+TBTA_VBUS on BOTTOM (solid shape): 49.01,50.93 49.01,50.19 48.95,50.14 48.46,50.14 48.38,50.06 48.34,50.06 48.28,49.99 48.28,49.96 48.02,49.7 48.02,49.26 47.99,49.24 47.99,49.1 47.18,48.29 47.18,48.2 46.96,47.98 46.16,47.98 46.08,48.06 46.08,48.26 45.96,48.38 45.75,48.38 45.62,48.51 45.62,48.76 45.64,48.83 45.7,48.86 45.81,48.84 45.92,48.87 46.02,49.01 46,49.17 46.06,49.23 46.36,49.23 46.41,49.29 46.42,49.28 46.97,48.96 46.65,49.52 46.65,49.52 48.23,51.11 48.47,51.11 48.83,51.11
+TBTA_VBUS on BOTTOM: 7.46,47.62 6.58,47.62 6.4,47.45 6.4,44.22 6.55,44.07 6.91,44.07 7.29,43.69 8.67,43.69 9.21,43.14 10.06,43.14 10.16,43.24 10.16,44.35 10.03,44.47 7.84,44.47 7.71,44.6 6.63,44.6 6.51,44.73 6.51,45.43 6.89,45.81 6.89,46.25 6.95,46.31 8.92,46.31 9.11,46.12 9.81,46.12 10.16,46.48 10.16,46.51 10.25,46.6 10.25,47.84 10.19,47.9 9.68,47.9 9.46,47.68 8.76,47.68 8.54,47.9 7.74,47.9
+TBTA_VBUS on IN3: 16.43,54.02 16.91,53.54 16.91,50.72 15.49,49.3 15.49,48.28 15.18,47.98 15.18,47.5 14.82,47.14 14.82,46.73 14.39,46.3 14.39,43.56 12.64,41.81 9.57,41.81 8.86,42.52 6.75,42.52 5.88,43.38 5.88,47.34 7.05,48.51 7.99,48.51 8.86,49.38 8.86,51.46 11.42,54.02
+TBTA_VBUS on IN4: 9.54,41.78 8.75,42.57 5.82,42.57 5.31,43.08 5.31,48 6.32,49.02 8.02,49.02 8.83,49.83 8.83,51.43 10.72,53.33 10.72,57.08 11.27,57.63 26.89,57.63 27.73,56.79 27.73,55.29 28.46,54.56 45.57,54.56 49.91,50.21 49.91,48.41 49.15,47.65 31.27,47.65 27.74,44.12 27.28,44.17 27.11,43.74 19.47,43.74 17.52,41.78 ; 2 cut-outs
ADPS_ISL95338_1 on BOTTOM (solid shape): 123.34,148.51 123.34,148.03 124.59,146.78 124.59,146.63 124.54,146.58 123.76,146.58 123.62,146.72 123.62,146.75 123.46,147.11 123.06,147.09 122.55,147.09 122.55,147.09 122.17,147.09 122.12,147.14 122.12,148.56 122.15,148.59 123.27,148.59
ADPS_ISL95338_2 on BOTTOM (solid shape): 145.45,145.59 145.45,145.24 146.14,144.55 146.64,144.55 146.95,144.23 146.95,144.1 146.91,144.06 146.1,144.06 146.1,144.06 145.23,144.06 145.11,144.18 144.58,144.18 144.5,144.26 144.5,145.6 144.68,145.79 145.25,145.79
B+_BIAS on BOTTOM: 49.74,23.98 52.48,23.98 52.58,23.89 52.58,20.09 52.39,19.91 52.03,19.91 51.87,19.75 51.87,18.21 50.51,16.85 45.62,16.85 45.5,16.72 45.5,15.96 45.24,15.71 43.45,15.71 43.23,15.49 43.23,14.3 42.93,13.99 41.02,13.99 40.92,14.09 40.92,15.77 41.25,16.1 41.25,18.23 42.03,19.01 48.2,19.01 48.72,19.53 48.72,22.96
B+_VCCIO on BOTTOM (solid shape): 154.56,117.37 154.56,115.72 154.6,115.68 154.6,115.33 154.53,115.26 154.05,115.26 153.95,115.16 153.95,113.87 154.41,113.41 154.41,111.94 154.36,111.88 153.34,111.88 153.03,112.19 153.03,112.49 152.69,112.84 151.35,112.84 150.82,113.36 150.82,116.91 151.43,117.52 154.41,117.52
BATT+ on TOP (solid shape): 199.2,138.83 199.2,132.27 199.29,132.18 199.29,127.79 198.96,127.47 193.62,127.47 193.52,127.56 193.52,133.45 193.64,133.56 193.64,136.69 194.25,136.94 193.64,137.19 193.64,137.78 193.97,138.11 195.63,138.11 195.63,134.76 196.4,134.76 196.4,138.11 197.83,138.11 198.62,138.9 199.14,138.9
BATT+ on TOP: 121.02,110.23 121.02,107.12 120.73,106.83 119.99,106.83 119.99,107.01 119.69,107.01 119.69,106.83 116.03,106.83 112.61,103.41 108.74,103.41 107.16,104.98 107.16,111.46 109.08,113.37 117.88,113.37
BATT+ on TOP: 108.23,70.38 108.23,60.98 107.4,60.16 106.39,60.16 103.97,57.74 99.85,57.74 98.7,58.89 98.7,69.56 101.37,72.22 106.39,72.22
BATT+ on TOP: 74.83,33.35 78.74,33.35 80.9,31.19 80.9,25.27 80.18,24.55 71.61,24.55 71.24,24.92 71.24,26.92 72.1,27.77 73.37,27.77 74.19,28.6 74.19,32.71
BATT+ on BOTTOM: 70.86,27.46 78.19,27.46 78.45,27.2 78.45,23.39 76.29,21.23 66.13,21.23 65.87,21.49 65.87,26.01 66.18,26.32 69.72,26.32
BATT+ on IN3: 193.64,129.28 193.64,134.71 193.65,134.72 193.65,135.79 194.41,136.55 198.55,136.55 199.59,135.51 199.59,134.28 199.61,134.26 199.61,123.63 199.48,123.5 199.48,120.45 197.87,118.84 193.58,118.84 192.27,120.16 192.27,127.92 ; 1 cut-out
BATT+ on IN3: 174.59,113.31 175.09,112.8 175.09,105.94 174.08,104.93 162.72,104.93 161.89,105.76 139.39,105.76 138.91,106.25 124.89,106.25 124.56,106.58 117.24,106.58 116.22,105.56 113.15,105.56 109.8,108.91 109.8,110.6 112.5,113.31
BATT+ on IN3: 79.46,24.6 71.72,24.6 71.71,24.61 70.96,24.61 70.31,25.26 70.31,27.23 69.57,27.97 69.57,30.05 70.12,30.6 70.12,32.89 69.57,33.44 69.57,37.75 71.55,39.73 71.55,42.62 72.33,43.4 78.68,43.4 80.9,41.18 80.9,36.09 79.8,35 79.8,24.94
BATT+ on GND3: 116.28,106.7 116.04,106.94 116.04,108.76 127.96,120.67 150.44,120.67 158.84,129.08 158.84,145.84 161.13,148.13 161.13,166.41 172.16,177.44 178.8,177.44 183.12,173.12 187.82,173.12 188.56,172.38 188.56,164.47 187.54,163.45 187.54,159.05 198.47,148.13 198.47,129.67 197.85,129.06 190.44,129.06 189.32,130.18 189.32,143.77 185.26,147.83 185.26,152.78 180.41,157.63 179.27,157.63 178.02,158.88 178.02,168.66 176.47,170.2 174.36,170.2 173.45,169.29 173.45,166.29 174.97,164.76 174.97,153.67 170.15,148.85 170.15,143.51 167.86,141.23 167.86,125.73 155.94,113.82 130.04,113.82 122.92,106.7
BATT++ on BOTTOM: 73.48,19.72 73.68,19.52 73.68,17.61 73.18,17.1 71.53,17.1 71.5,17.08 71.5,9.57 71.27,9.35 65.91,9.35 65.66,9.6 65.66,17.23 65.47,17.42 63.84,17.42 63.65,17.61 63.65,19.39 63.98,19.72
BGATE_CHG on TOP (solid shape): 205.7,138.26 205.7,137.63 205.19,137.12 204.94,137.12 204.22,136.4 204.22,135.14 203.84,134.76 203.18,134.76 202.97,134.97 202.97,136.99 203.03,137.06 204.24,137.06 205.51,138.33 205.64,138.33
BOOT_1.2V on TOP (solid shape): 218.34,120.39 218.34,119.56 218.52,119.38 218.52,118.01 218.46,117.96 218.35,117.96 218.31,117.99 218.31,119.11 217.78,119.64 217.4,119.64 217.3,119.75 217.3,120.42 217.37,120.5 218.24,120.5
BST1_ISL95338_1 on BOTTOM: 121.84,145.41 123.55,145.41 123.75,145.21 124.48,145.21 124.59,145.11 124.59,145.03 124.51,144.96 123.55,144.96 123.42,145.08 122.53,145.08 122.35,144.9 122.35,144.7 122.3,144.65 121.82,144.65 121.77,144.7 121.77,145.34
BST1_ISL95338_2 on BOTTOM: 143.87,142.44 144.37,142.44 144.43,142.5 144.84,142.5 145.03,142.7 146.89,142.7 146.96,142.62 146.96,142.49 146.89,142.42 145.26,142.42 145.06,142.21 144.83,142.21 144.35,141.73 143.87,141.73 143.79,141.81 143.79,142.36
BST1_R_ISL95338_1 on BOTTOM (solid shape): 121.62,145.26 121.62,144.67 121.5,144.55 121.5,143.5 121.37,143.38 120.72,143.38 120.65,143.45 120.65,145.12 120.86,145.33 121.56,145.33
BST1_R_ISL95338_2 on BOTTOM (solid shape): 143.6,142.35 143.6,140.58 143.55,140.53 142.86,140.53 142.77,140.61 142.77,141.51 142.89,141.63 142.89,142.36 142.95,142.41 143.54,142.41
BST2_3V on TOP (solid shape): 329.89,43.03 329.89,42.47 329.79,42.37 328.02,42.37 327.91,42.47 327.91,43.05 327.96,43.1 329.82,43.1
BST2_5V on TOP (solid shape): 329.82,34.29 329.82,33.83 329.44,33.45 328.02,33.45 327.89,33.58 327.89,34.06 327.96,34.14 328.9,34.14 329.13,34.36 329.74,34.36
BST2_+1VALWP on TOP (solid shape): 268.81,10.92 268.81,8.84 268.76,8.79 268.15,8.79 268.05,8.89 268.05,10.92 268.12,11 268.73,11
BST2_ISL95338_1 on BOTTOM: 126.34,143.66 126.47,143.66 126.52,143.61 126.52,142.8 126.95,142.36 126.95,140.97 126.87,140.89 126.26,140.89 126.21,140.94 126.21,141.45 126.47,141.7 126.47,142.06 126.36,142.16 126.36,142.59 126.26,142.7 126.26,143.58
BST2_ISL95338_2 on BOTTOM: 148.68,141.12 148.81,141.12 148.87,141.06 148.87,140.29 149.64,139.53 149.64,138.71 149.57,138.64 149.19,138.64 149.06,138.77 149.06,139.66 148.62,140.1 148.62,141.06
BST2_R_ISL95338_1 on BOTTOM (solid shape): 126.95,140.53 126.95,139.49 126.81,139.35 125.06,139.35 124.99,139.41 124.99,140.25 125.34,140.6 126.88,140.6
BST2_R_ISL95338_2 on BOTTOM (solid shape): 150.38,139.31 150.51,139.27 150.65,139.28 150.69,139.24 150.69,138.03 150.02,137.36 148.82,137.36 148.78,137.4 148.78,138.34 148.82,138.38 149.69,138.38 150.01,138.69 150.01,139.24 150.07,139.31
BST2_VCCIO on BOTTOM (solid shape): 151.41,112.35 151.41,110.32 151.28,110.2 150.77,110.2 150.71,110.26 150.71,112.35 150.77,112.42 151.35,112.42
BST_1.2V on TOP (solid shape): 220.43,122.51 220.43,121.11 220.32,120.99 217.45,120.99 217.28,121.16 217.28,122.49 217.41,122.62 220.33,122.62
BST_3V on TOP (solid shape): 328.88,41.63 328.88,41.1 328.78,40.99 328.78,40.38 328.73,40.33 328.73,39.55 328.65,39.47 328.6,39.47 328.5,39.57 328.5,40.31 327.86,40.94 327.86,41.63 327.94,41.7 328.8,41.7
BST_5V on TOP (solid shape): 328.73,37.18 328.73,35.74 328.88,35.58 328.88,35 328.88,34.85 328.83,34.8 328.04,34.8 327.91,34.92 327.91,35.61 328.5,36.19 328.5,37.13 328.57,37.21 328.7,37.21
BST_+1VALWP on TOP (solid shape): 267.44,11.02 267.44,10.13 267.33,10.03 266.78,10.03 266.34,10.46 265.84,10.46 265.57,10.2 264.62,10.2 264.57,10.25 264.57,10.56 265.08,11.07 267.39,11.07
BST_CHG on TOP (solid shape): 205.45,138.64 205.45,138.52 204.18,137.25 202.55,137.25 202.48,137.31 202.48,138.17 202.51,138.2 203.29,138.2 203.35,138.14 203.35,137.95 203.54,137.75 203.92,137.75 204.56,138.39 204.56,138.64 204.62,138.71 205.38,138.71
BST_CHG_R on TOP (solid shape): 201.89,139.06 201.89,137.31 201.83,137.25 201.13,137.25 201.08,137.3 201.08,139.07 201.16,139.15 201.8,139.15
BST_VCCIO on BOTTOM (solid shape): 152.87,112.23 152.87,112.1 153.25,111.72 154.27,111.72 154.33,111.66 154.33,111.53 154.27,111.47 152.17,111.47 152.11,111.53 152.11,112.29 152.17,112.35 152.74,112.35
BST_VCCSA on BOTTOM: 132.79,113.92 131.77,113.92 130.63,115.06 130.4,115.06 130.33,115.14 130.33,115.31 130.35,115.34 131.09,115.34 131.77,114.65 132,114.65 132.26,114.91 132.82,114.91 132.92,114.81 132.92,114.04
BST_VCCSA_R on BOTTOM: 133.58,116.18 134.21,116.18 134.26,116.13 134.26,114.07 134.19,113.99 133.63,113.99 133.55,114.07 133.55,116.15
CPU_B+ on BOTTOM (solid shape): 114.73,90.45 114.73,82.78 112.84,80.88 111.56,80.88 111.37,80.7 111.37,79.87 111.21,79.72 111.21,74.69 111.4,74.5 111.4,74.06 111.43,74.04 111.43,71.7 111.33,71.6 110.29,71.6 110.18,71.7 110.18,71.93 110.21,71.96 110.21,72.97 110.07,73.11 109.12,73.11 108.9,73.33 108.9,75.86 108.79,75.97 108.79,78.32 106.63,80.48 106.63,90.37 106.98,90.73 114.45,90.73
CPU_B+ on TOP: 103.85,37.49 104.01,37.33 104.45,37.33 105.75,36.03 105.75,33.93 105.5,33.68 104.55,33.68 102.01,36.22 102.01,38.76 102.26,39.01 103.59,39.01 103.85,38.76
CPU_B+ on TOP: 105.82,56.79 105.94,56.67 105.94,56.03 107.02,54.95 107.02,51.65 106.77,51.39 104.16,51.39 103.59,51.97 103.59,54.76 103.09,55.27 103.09,56.6 103.28,56.79
CPU_B+ on TOP: 142.65,16.6 147.03,16.6 147.41,16.22 147.41,13.23 147.03,12.85 142.2,12.85 141.88,13.17 141.88,14.69 142.39,15.2 142.39,16.34
CPU_B+ on TOP: 101.5,29.68 103.78,29.68 103.88,29.58 103.88,27.68 104.04,27.52 104.04,26.57 103.66,26.19 101.82,26.19 101.69,26.31 101.69,27.01 101.5,27.2 101.18,27.2 100.99,27.39 100.99,28.03 101.43,28.47 101.43,29.61
CPU_B+ on TOP: 105.56,64.6 107.66,64.6 107.91,64.35 107.91,62.32 107.78,62.19 105.5,62.19 105.37,62.32 105.37,64.41
CPU_B+ on TOP: 124.55,16.03 127.79,16.03 127.98,15.83 127.98,13.93 126.52,12.47 123.15,12.47 123.02,12.6 123.02,13.49 123.85,14.31 123.85,15.33
CPU_B+ on TOP: 101.75,48.16 104.42,48.16 104.55,48.03 104.55,46.38 105.56,45.36 105.56,43.08 105.31,42.82 103.79,42.82 103.53,43.08 103.53,43.62 103.42,43.73 101.96,43.73 101.62,44.07 101.62,48.03
CPU_B+ on BOTTOM: 105.75,67.4 107.91,67.4 108.1,67.21 108.1,63.84 108.36,63.59 108.86,63.59 109.18,63.27 109.24,63.27 109.31,63.21 109.31,60.35 109.24,60.28 108.17,60.28 108.04,60.41 108.04,61.68 107.85,61.87 106.83,61.87 106.32,62.38 105.56,62.38 105.5,62.44 105.5,67.14
CPU_B+ on BOTTOM: 101.69,48.09 104.48,48.09 104.55,48.03 104.55,46.95 104.8,46.7 105.12,46.7 105.82,46 105.82,43.2 105.69,43.08 104.74,43.08 104.61,43.2 104.61,44.47 104.48,44.6 103.53,44.6 102.96,45.17 101.56,45.17 101.43,45.3 101.43,47.84
CPU_B+ on BOTTOM: 103.85,38.76 103.85,37.42 103.97,37.3 105.31,37.3 105.82,36.79 105.82,33.87 105.75,33.81 104.67,33.81 104.55,33.93 104.55,35.2 104.36,35.39 102.07,35.39 101.94,35.52 101.94,38.69 102.26,39.01 103.59,39.01
CPU_B+ on BOTTOM: 147.32,16.57 142.62,16.57 142.42,16.37 142.42,15.3 141.88,14.76 141.88,12.47 142.01,12.34 142.52,12.34 142.58,12.41 142.58,12.72 142.7,12.84 145.32,12.84 145.39,12.91 145.39,13.7 145.85,14.16 145.85,15.12 146.02,15.3 147.34,15.3 147.42,15.38 147.42,16.47
CPU_B+ on BOTTOM: 106.39,56.6 106.39,55.59 106.64,55.33 106.64,54.7 106.9,54.44 107.09,54.44 107.28,54.25 107.28,51.39 107.21,51.33 106.13,51.33 106.01,51.46 106.01,52.79 105.82,52.98 104.8,52.98 104.55,53.24 104.55,53.81 104.42,53.93 103.47,53.93 103.15,54.25 103.15,56.6 103.34,56.79 106.2,56.79
CPU_B+ on BOTTOM: 123.91,16.79 124.68,16.79 125.25,16.22 127.85,16.22 128.04,16.03 128.04,15.01 127.98,14.95 126.52,14.95 126.45,14.88 126.45,13.99 126.14,13.68 125.44,13.68 125.18,13.42 125.18,12.47 125.12,12.41 123.15,12.41 122.96,12.6 122.96,13.04 123.15,13.23 123.79,13.23 123.85,13.29 123.85,16.72
CPU_B+ on BOTTOM: 101.91,30.25 103.59,30.25 103.91,29.93 103.91,28.28 104.1,28.09 104.8,28.09 105.05,27.84 105.82,27.84 106.01,27.65 106.01,24.92 105.94,24.85 104.86,24.85 104.74,24.98 104.74,26.25 104.55,26.44 102.7,26.44 102.64,26.38 101.75,26.38 101.56,26.57 101.56,27.02 101.38,27.2 101.12,27.2 100.99,27.33 100.99,28.15 101.12,28.28 101.43,28.28 101.56,28.41 101.56,29.9
CPU_B+ on BOTTOM: 94.77,43.08 98.39,43.08 98.77,42.7 98.77,24.6 97.75,23.58 95.27,23.58 94.39,24.47 94.39,42.7
CPU_B+ on IN1: 126.77,24.53 147.85,24.53 151.15,21.23 151.15,15.33 149,13.17 125.63,13.17 118.45,20.34 97.43,20.34 94.39,23.39 94.39,27.77 95.08,28.47 102.48,28.47 104.64,26.31 108.29,26.31 110.07,24.53 111.09,24.53 113.25,26.69 124.61,26.69 ; 3 cut-outs
CPU_B+ on GND2: 95.19,22.88 94.58,23.5 94.58,56.05 105.5,66.97 105.5,76.24 111.47,82.21 111.47,88.56 111.96,89.05 118.99,89.05 120.01,88.02 120.01,70.49 119.71,70.18 119.71,66.09 119.79,66.01 119.79,54.36 117.98,52.55 110.43,52.55 106.26,48.39 106.26,25.02 104.13,22.88
CPU_B+ on IN2: 109.4,77.32 113.61,77.32 113.79,77.14 116.77,77.14 119.02,74.89 119.02,44.6 114.48,40.05 114.24,39.82 114.24,39.19 114.48,38.95 114.48,34.67 113.55,33.75 113.55,32.29 112.09,30.83 110.25,30.83 107.89,28.47 107.89,26.63 105.85,24.58 96.95,24.58 90.86,30.67 90.86,44.88 102.13,56.16 102.13,61.95 105.33,65.15 105.33,73.25
CPU_B+ on IN3: 114.48,76.45 114.48,27.64 110.71,23.88 103.68,23.88 102.21,25.35 91.77,25.35 90.17,26.95 90.17,46.51 102.13,58.47 102.13,60.67 106.58,65.11 106.58,74.72 109.17,77.32 113.61,77.32
DCIN_ISL95338_1 on TOP (solid shape): 124.64,148.92 124.64,147.78 124.51,147.65 123.8,147.65 123.67,147.81 123.47,147.88 123.47,148.94 123.49,148.97 124.59,148.97
DCIN_ISL95338_1 on BOTTOM (solid shape): 125.22,149.83 125.22,148.79 124.89,148.46 124.89,148.3 124.84,148.11 124.89,147.92 124.89,146.94 124.82,146.86 124.76,146.86 124.69,146.94 124.69,147.09 123.52,148.26 123.52,149.81 123.65,149.93 125.12,149.93
DCIN_ISL95338_2 on TOP (solid shape): 146.65,146.96 146.65,145.54 146.47,145.36 145.76,145.36 145.58,145.54 145.58,147.06 145.67,147.15 146.46,147.15
DCIN_ISL95338_2 on BOTTOM (solid shape): 146.58,147.7 146.58,145.63 146.96,145.25 147.23,145.25 147.29,145.18 147.29,144.42 147.24,144.37 147.09,144.37 146.13,145.33 146.05,145.33 145.35,146.03 145.35,147.7 145.43,147.78 146.5,147.78
DH_1.2V on TOP (solid shape): 219.16,120.46 219.16,119.54 218.96,119.34 218.96,117.98 218.93,117.96 218.74,117.96 218.69,118.01 218.69,119.4 218.48,119.62 218.48,120.44 218.62,120.58 219.04,120.58
DH_1.2V on TOP (solid shape): 234.6,120.17 234.6,118.51 234.34,118.26 233.58,118.26 233.39,118.45 233.39,119.28 233.71,119.59 233.71,120.04 233.96,120.29 234.47,120.29
DH_1.2V on IN4 (solid shape): 220.17,121.09 220.17,120.56 219.07,119.47 218.63,119.47 218.54,119.56 218.54,120.95 218.99,121.4 219.86,121.4
DH_1.2V on IN4 (solid shape): 234.56,120.31 234.56,118.97 234.45,118.85 232.86,118.85 232.73,118.98 232.73,120.19 233.13,120.59 234.28,120.59
DL_1.2V on TOP (solid shape): 236.19,120.8 236.19,119.91 236,119.72 234.98,119.72 234.79,119.91 234.79,120.74 235.11,121.05 235.93,121.05
DL_1.2V on TOP (solid shape): 221.17,118.69 221.17,118.18 220.97,117.98 220.78,117.98 220.33,117.52 219.49,117.52 219.43,117.59 219.43,117.84 219.66,118.07 219.66,118.48 219.94,118.77 221.09,118.77
DL_1.2V on IN4 (solid shape): 236.44,120.6 236.44,119.02 236.19,118.77 235.49,118.77 235.36,118.9 234.88,119.38 234.88,120.83 235.1,121.05 235.99,121.05
DL_1.2V on IN4: 219.96,118.25 219.96,118.37 220.14,118.55 222.3,118.55 222.41,118.44 222.41,117.77 222.29,117.64 220.07,117.64 219.95,117.76 219.95,118.23
EN_TPLED on TOP: 86.46,21.23 86.46,18.03 86.59,17.9 87.61,17.9 87.88,18.18 87.88,19.18 88.24,19.53 88.75,19.53 88.98,19.76 88.98,20.39 88.79,20.57 87.53,20.57 87.17,20.93 87.17,21.26 87.08,21.35 86.58,21.35
GPU_FAN_FB on BOTTOM: 375.56,46.07 376.33,46.07 376.83,46.58 376.83,46.89 376.86,46.92 377.57,46.92 377.67,46.82 377.67,45.44 377.57,45.33 375.55,45.33 375.44,45.44 375.44,45.95
ISL95338_N001 on BOTTOM (solid shape): 124.01,152.86 125.42,152.86 125.53,152.75 125.53,151.62 125.37,151.47 121.18,151.47 121.09,151.56 121.09,153.03 121.24,153.17 123.7,153.17
ISL95338_N003 on BOTTOM (solid shape): 131.57,147.16 131.57,146.64 131.51,146.58 131.01,146.58 130.87,146.44 130.87,145.99 130.97,145.89 130.97,145.28 130.94,145.24 130.34,145.24 130.28,145.31 130.28,145.88 130.15,146.01 129.74,146.01 129.66,146.08 129.66,146.72 130.15,147.21 131.53,147.21
ISL95338_N004 on BOTTOM (solid shape): 143.79,147.66 143.79,146.07 143.66,145.95 139.73,145.95 139.28,146.39 139.28,147.66 139.68,148.06 143.39,148.06
ISL95338_N006 on BOTTOM (solid shape): 154.21,144.17 154.21,143.81 153.55,143.15 153.55,142.85 153.45,142.75 152.96,142.75 152.91,142.8 152.91,143.38 152.72,143.57 152.26,143.57 152.2,143.63 152.2,144.24 152.28,144.32 154.06,144.32
LG1_ISL95338_1 on TOP (solid shape): 119.85,135.34 119.85,134.52 119.66,134.33 118.77,134.33 118.64,134.45 118.64,135.28 118.9,135.53 119.66,135.53
LG1_ISL95338_1 on BOTTOM (solid shape): 124.59,143.93 124.59,143.81 124.44,143.65 124.17,143.65 123.35,142.83 123.09,142.83 122.96,142.96 122.96,143.15 123.66,143.85 123.66,143.91 123.73,143.99 124.53,143.99
LG1_ISL95338_1 on IN4 (solid shape): 119.85,136.68 119.85,134.52 119.66,134.33 118.96,134.33 118.71,134.58 118.71,136.55 118.9,136.74 119.79,136.74
LG1_ISL95338_1 on IN4 (solid shape): 123.91,143.47 123.91,143.03 122.9,142.01 122.58,142.01 122.33,142.26 122.33,142.9 123.15,143.72 123.66,143.72
LG1_ISL95338_2 on TOP (solid shape): 150.96,136.99 150.96,136.23 150.71,135.98 149.69,135.98 149.5,136.17 149.5,136.61 149.63,136.74 149.82,136.74 150.2,137.12 150.84,137.12
LG1_ISL95338_2 on BOTTOM (solid shape): 147.01,141.47 147.01,141.27 146.93,141.19 146.9,141.19 145.94,140.23 145.69,140.23 145.63,140.29 145.63,140.61 146.07,141.06 146.07,141.44 146.14,141.51 146.97,141.51
LG1_ISL95338_2 on IN1 (solid shape): 150.96,136.93 150.96,136.29 150.65,135.98 149.57,135.98 149.38,136.17 149.38,136.61 149.95,137.18 150.71,137.18
LG1_ISL95338_2 on IN1 (solid shape): 146.46,140.93 146.46,140.55 146.14,140.23 146.14,139.22 146.01,139.09 145.5,139.09 145.38,139.22 145.38,140.29 146.2,141.12 146.27,141.12
LG2_ISL95338_1 on TOP (solid shape): 121.51,138.39 121.51,136.09 121.43,136.01 120.29,136.01 120.19,136.12 120.19,136.79 120.2,136.79 120.2,138.4 120.35,138.56 121.34,138.56
LG2_ISL95338_1 on BOTTOM (solid shape): 125.27,143.68 125.3,143.64 125.3,142.69 125.29,142.68 125.15,142.59 125.06,142.45 124.88,142.27 124.88,142.24 124.68,142.05 124.08,142.05 123.88,142.25 123.88,142.42 124.06,142.59 124.51,142.59 124.61,142.69 124.68,142.69 124.79,142.66 124.91,142.69 124.92,142.69 125.07,142.84 125.07,143.64 125.11,143.68 125.27,143.68
LG2_ISL95338_1 on IN4 (solid shape): 121.25,137.95 121.25,136.27 120.99,136.01 120.29,136.01 120.19,136.12 120.19,137.84 120.42,138.07 121.12,138.07
LG2_ISL95338_1 on IN4 (solid shape): 124.99,142.69 124.99,142.33 123.66,140.99 123.3,140.99 122.96,141.33 122.96,141.69 124.17,142.9 124.78,142.9
LG2_ISL95338_2 on TOP (solid shape): 142.38,125.45 142.38,124.69 142.24,124.55 141.38,124.55 141.31,124.61 141.31,125.44 141.44,125.56 142.26,125.56
LG2_ISL95338_2 on BOTTOM (solid shape): 147.67,141.1 147.67,140.49 147.74,140.43 147.74,139.89 147.44,139.59 147.41,139.59 147.19,139.37 146.81,139.37 146.71,139.47 146.71,139.59 147.24,140.11 147.24,140.11 147.4,140.27 147.4,140.29 147.46,140.35 147.46,141.09 147.54,141.17 147.6,141.17
LG2_ISL95338_2 on IN4 (solid shape): 142.38,125.92 142.38,124.63 142.19,124.44 141.51,124.44 141.31,124.64 141.31,125.87 141.53,126.08 142.21,126.08
LG2_ISL95338_2 on IN4 (solid shape): 147.6,139.91 147.6,139.72 146.96,139.09 146.96,138.64 146.71,138.39 146.01,138.39 145.95,138.45 145.95,139.47 146.58,140.1 147.41,140.1
LG_3V on TOP (solid shape): 321.64,45.82 321.64,44.96 321.49,44.8 320.57,44.8 320.47,44.91 320.47,45.79 320.6,45.92 321.54,45.92
LG_3V on TOP (solid shape): 326.67,40.53 326.67,40.21 327.63,39.24 327.81,39.24 327.89,39.16 327.89,39.06 327.84,39.01 327.1,39.01 326.24,39.88 326.24,39.88 325.73,40.38 325.73,40.77 325.96,41 326.2,41
LG_3V on IN1 (solid shape): 321.64,45.72 321.64,44.78 321.39,44.52 320.73,44.52 320.5,44.75 320.5,45.69 320.65,45.84 321.51,45.84
LG_3V on IN1 (solid shape): 327.1,39.72 327.1,39.37 326.97,39.24 326.41,39.24 325.83,39.83 325.42,39.83 324.41,40.84 324.41,41.04 324.71,41.35 325.48,41.35
LG_5V on TOP (solid shape): 321.79,37.84 321.79,37.03 321.67,36.9 320.93,36.9 320.78,37.06 320.78,37.84 320.93,38 321.64,38
LG_5V on TOP (solid shape): 327.94,37.56 327.94,37.49 327.25,36.8 326.39,36.8 326.24,36.95 326.24,37.23 326.36,37.36 326.85,37.36 327.13,37.64 327.86,37.64
LG_5V on IN1 (solid shape): 322.3,37.26 322.3,36.73 321.97,36.4 321.18,36.4 320.7,36.87 320.7,37.79 320.83,37.92 321.64,37.92
LG_5V on IN1 (solid shape): 326.44,37.26 327.23,37.26 327.33,37.16 327.33,36.95 326.9,36.52 326.29,36.52 326.11,36.35 325.09,36.35 324.99,36.45 324.99,37.29 325.14,37.44 326.26,37.44
LG_+1VALWP on TOP (solid shape): 265.36,8.38 265.36,8.17 266.22,7.31 266.22,7.06 266.06,6.91 265.89,6.91 264.9,7.9 264.89,7.9 264.57,8.21 264.57,8.21 264.57,8.4 264.63,8.47 265.27,8.47
LG_+1VALWP on IN1 (solid shape): 272.11,18.16 272.11,17.09 271.98,16.97 271.14,16.97 270.94,17.17 270.94,18.08 271.17,18.31 271.96,18.31
LG_+1VALWP on IN1 (solid shape): 265.8,7.92 265.99,7.87 266.17,7.92 266.98,7.92 267.11,7.8 267.11,7.01 267.03,6.93 265.81,6.93 265.3,7.44 265.3,7.72 265.51,7.92
LG_+1VALWP on TOP: 271.04,18.41 272.24,18.41 272.29,18.36 272.29,17.59 271.94,17.24 271.09,17.24 270.92,17.42 270.92,18.29
LG_CHG on BOTTOM (solid shape): 199.65,155.09 199.65,154.33 199.55,154.23 198.97,154.23 198.2,153.47 198.2,152.14 198.13,152.07 197.35,152.07 197.32,152.1 197.32,153.83 198.64,155.15 199.59,155.15
LG_CHG on IN1 (solid shape): 200.68,155.01 200.68,154.22 200.58,154.12 198.72,154.12 198.54,154.3 198.54,154.96 198.76,155.17 200.51,155.17
LG_CHG on TOP: 204.09,139.88 205.36,139.88 205.41,139.82 205.41,139.75 205.33,139.67 204.32,139.67 204.24,139.6 203.89,139.6 203.4,139.11 203.17,139.11 203,139.29 203,139.47 203.45,139.93 204.04,139.93
LG_CHG on IN1: 203.91,139.82 203.91,139.65 203.78,139.52 203.71,139.52 203.35,139.16 203.12,139.16 202.11,140.18 202.11,140.79 202.41,141.09 202.64,141.09
LG_VCCSA on IN4 (solid shape): 130.2,113.56 130.2,113 129.97,112.77 128.85,112.77 128.73,112.9 128.73,113.69 128.83,113.79 129.97,113.79
LG_VCCSA on IN4 (solid shape): 145.31,117.09 145.31,115.39 145.14,115.21 144.3,115.21 144.09,115.42 144.09,117.04 144.25,117.19 145.21,117.19
LG_VCCSA on BOTTOM: 128.85,114.83 129.01,114.83 129.06,114.78 129.06,114.02 129.21,113.87 129.21,112.93 129.03,112.75 128.78,112.75 128.63,112.9 128.63,113.87 128.78,114.02 128.78,114.76
LG_VCCSA on BOTTOM: 144.14,117.3 145.13,117.3 145.31,117.11 145.31,116.24 145.24,116.16 144.11,116.16 143.99,116.28 143.99,117.14
LX1_ISL95338_1 on TOP (solid shape): 114.12,143.75 115.88,143.75 116.04,143.91 119.15,143.91 119.15,143.91 119.86,143.91 120.17,143.6 120.17,141.7 119.66,141.18 119.66,136.29 119.53,136.17 114.71,136.17 114.25,136.62 114.25,140.87 114.1,141.02 111.8,141.02 111.79,141.05 111.54,141.21 111.28,141.05 111.27,141.02 111.12,141.02 110.51,141.63 110.51,143.76 110.67,143.91 113.96,143.91
LX1_ISL95338_1 on BOTTOM: 123.27,144.36 123.28,144.37 123.55,144.37 123.6,144.41 124.54,144.41 124.61,144.35 124.61,144.23 124.56,144.18 123.72,144.18 122.54,143 122.14,142.59 122.14,139.91 121.56,139.34 121.56,137.31 121.44,137.18 115.66,137.18 110.07,142.77 110.07,144.99 110.39,145.31 113.82,145.31 113.94,145.18 113.94,144.3 113.95,144.29 113.95,143.85 114.12,143.68 115.82,143.68 116.17,144.03 116.17,145.18 116.36,145.37 119.09,145.37 119.28,145.18 119.28,143.85 120.17,142.96 121.18,142.96 122.07,143.85 122.07,144.17 122.27,144.36
LX1_ISL95338_2 on BOTTOM (solid shape): 146.98,141.85 146.98,141.75 146.9,141.68 146.06,141.68 145.86,141.48 145.86,141.16 143.68,138.98 143.68,137.42 144.5,136.6 146.71,136.6 147.09,136.22 147.09,132.26 146.71,131.88 139.19,131.88 139.15,131.91 138.39,131.91 138.14,132.17 138.14,135.95 138.46,136.27 140.18,136.27 140.37,136.46 140.37,137.95 140.29,138.03 139.73,138.03 139.71,138.01 138.84,138.01 138.71,138.14 138.71,140.99 138.9,141.18 141.57,141.18 141.82,140.93 141.82,140.64 142.13,140.33 143.55,140.33 144.23,141.02 144.23,141.37 144.3,141.44 145.38,141.44 145.82,141.88 145.96,141.88 145.97,141.9 146.93,141.9
LX1_ISL95338_2 on TOP: 148.74,132.03 148.75,132.04 148.75,136.77 147.5,138.02 147.5,139.07 147.39,139.18 146.34,139.18 145.48,140.04 140.93,140.04 140.49,139.6 140.49,132.29 140.75,132.03
LX2_ISL95338_1 on TOP (solid shape): 123.81,135.72 123.81,133.2 123.53,132.93 122.51,132.93 121.88,132.3 121.88,129.25 121.63,129 120.8,129 119.24,127.43 113.39,127.43 113.21,127.61 113.21,129.13 113.69,129.61 114.78,129.61 117.37,132.2 117.37,132.74 118.71,134.07 119.91,134.07 120.29,134.45 120.29,135.66 120.47,135.83 123.69,135.83
LX2_ISL95338_1 on BOTTOM (solid shape): 121.94,133.37 121.94,128.17 121.69,127.91 119.76,127.91 119.23,127.38 113.36,127.38 113.18,127.56 113.18,129.06 113.93,129.8 115,129.8 117.37,132.18 117.37,133.12 118.13,133.88 121.44,133.88
LX2_ISL95338_1 on BOTTOM (solid shape): 125.7,143.62 125.7,142.93 125.7,142.93 125.7,142.64 125.64,142.58 125.64,141.98 125.64,141.98 125.64,141.76 125.65,141.76 125.65,141.6 125.76,141.48 125.94,141.48 125.96,141.46 125.96,140.82 125.91,140.76 125.04,140.76 125.01,140.79 125.01,142.21 125.49,142.7 125.49,143.62 125.55,143.68 125.64,143.68
LX2_ISL95338_1 on IN4 (solid shape): 122.71,133.69 122.71,133.37 122.01,132.67 120.8,132.67 120.74,132.74 120.74,133.18 120.87,133.31 121.18,133.31 121.94,134.07 122.33,134.07
LX2_ISL95338_1 on IN4 (solid shape): 125.68,142.39 125.69,142.34 125.69,140.87 125.5,140.68 124.86,140.68 124.66,140.88 124.66,141.76 125.16,142.25 125.16,142.45 125.27,142.57 125.5,142.57
LX2_ISL95338_2 on TOP (solid shape): 149.33,131.39 149.33,130.58 149.99,129.92 150.72,129.92 151.15,129.49 151.15,128.67 150.84,128.36 147.85,128.36 147.66,128.55 147.66,129.69 147.34,130.01 145.95,130.01 145.5,129.56 145.5,127.12 145.5,127.11 145.5,125.03 145.34,124.86 143.14,124.86 142.89,125.12 142.89,131.01 143.41,131.53 149.19,131.53
LX2_ISL95338_2 on BOTTOM (solid shape): 148.07,141.11 148.07,139.77 148.07,139.77 148.07,139.34 148.19,139.22 148.19,137.52 148.1,137.43 147.4,137.43 147.38,137.44 147.38,138.39 147.57,138.57 147.57,139.52 147.61,139.57 147.65,139.62 147.88,139.85 147.88,141.12 147.93,141.16 148.01,141.16
LX2_ISL95338_2 on BOTTOM (solid shape): outline of 83 points within 142.78,123.09 149.85,131.53
LX2_ISL95338_2 on IN2 (solid shape): 149.38,131.39 149.38,130.07 149.13,129.82 146.02,129.82 145.57,129.37 145.57,127.79 145.44,127.66 143.32,127.66 142.84,128.14 142.84,128.6 143.25,129 143.25,130.6 144.21,131.57 149.2,131.57
LX2_ISL95338_2 on IN4 (solid shape): 145.5,132.23 145.5,131.02 145.38,130.9 144.61,130.9 144.49,131.02 144.49,132.17 144.68,132.36 145.38,132.36
LX2_ISL95338_2 on IN4 (solid shape): 148.23,139.34 148.23,137.63 147.98,137.37 147.34,137.37 147.22,137.5 147.22,138.96 147.79,139.53 148.04,139.53
LX2_ISL95338_2 on IN3: 149.38,131.44 149.38,130.07 149.13,129.82 146.02,129.82 145.57,129.37 145.57,127.79 145.44,127.66 143.15,127.66 142.74,128.06 142.74,128.57 143.17,129 143.17,130.55 144.19,131.57 149.25,131.57
LX_3V on TOP (solid shape): 329.82,41.88 329.82,41.04 329.13,40.36 329.13,39.49 329.08,39.44 329.01,39.44 328.93,39.52 328.93,40.87 329.11,41.04 329.11,41.88 329.16,41.93 329.77,41.93
LX_3V on TOP (solid shape): 319.05,52.42 319.05,48.38 319.96,47.47 319.96,42.95 319.73,42.72 317.75,42.72 317.58,42.9 317.58,43.71 316.89,44.4 314.91,44.4 314.76,44.55 314.76,45.82 314.43,46.15 312.53,46.15 310.42,48.26 310.42,50.81 310.05,51.18 307.18,51.18 307,51.36 307,53.16 307.41,53.57 317.91,53.57
LX_3V on IN1 (solid shape): 319.02,50.42 319.02,49.48 318.82,49.27 317.52,49.27 317.27,49.53 317.27,50.34 317.52,50.59 318.85,50.59
LX_3V on IN1 (solid shape): 329.79,42.52 329.79,40.99 329.26,40.46 329.03,40.46 328.73,40.76 328.73,42.44 328.85,42.57 329.74,42.57
LX_5V on TOP (solid shape): 329.16,37.13 329.16,36.27 329.84,35.58 329.84,34.97 329.74,34.87 329.18,34.87 329.01,35.05 329.01,35.66 328.9,35.76 328.9,37.16 328.95,37.21 329.08,37.21
LX_5V on TOP (solid shape): 320.26,37.23 320.26,33.33 320.04,33.11 320.04,27.15 319.38,26.49 312.9,26.49 311.5,27.9 311.5,28.98 311.99,29.47 311.99,33.45 312.19,33.65 314.12,33.65 314.38,33.91 314.38,35.43 314.5,35.56 316.03,35.56 316.03,35.55 316.29,35.55 316.45,35.39 316.45,34.48 316.77,34.16 317.57,34.16 317.91,34.5 317.91,37.3 318,37.39 320.11,37.39
LX_5V on IN1 (solid shape): 320.42,33.73 320.42,32.84 320.27,32.69 319.05,32.69 318.92,32.81 318.92,33.73 319.02,33.83 320.32,33.83
LX_5V on IN1 (solid shape): 329.82,35.61 329.82,35.48 328.88,34.54 328.62,34.54 328.09,35.08 328.09,35.28 329.03,36.22 329.21,36.22
LX_CHG on TOP (solid shape): 206.46,151.85 206.46,148.89 204.91,147.33 197.78,147.33 197.64,147.47 197.64,151.62 198.06,152.04 206.27,152.04
LX_CHG on TOP (solid shape): 205.45,139.41 205.45,139.28 205.38,139.22 204.3,139.22 203.54,138.45 202.59,138.45 202.58,138.47 202.25,138.47 202.16,138.55 202.16,139.09 202.22,139.15 202.67,139.15 202.83,138.99 203.44,138.99 203.92,139.47 205.38,139.47
LX_CHG on IN1 (solid shape): 198.83,149.24 198.83,146.96 198.6,146.73 197.82,146.73 197.7,146.85 197.7,149.22 197.83,149.35 198.72,149.35
LX_CHG on IN1 (solid shape): 202.72,138.99 203.45,138.99 203.63,139.16 203.78,139.16 203.92,139.03 203.92,138.83 203.85,138.72 203.82,138.59 203.8,138.52 203.74,138.49 203.61,138.44 203.51,138.35 203.48,138.35 203.22,138.1 201.85,138.1 201.6,138.35 201.6,138.96 201.8,139.16 202.54,139.16
LX_CHG on BOTTOM: 200.99,153.93 200.78,153.72 200.78,152.25 200.42,151.9 190.88,151.9 190.53,151.55 190.53,147.19 191.29,146.42 203.81,146.42 205.68,148.29 205.68,153.63 205.38,153.93
LX_VCCIO on BOTTOM (solid shape): 155.09,111.38 155.09,110.51 154.91,110.34 154.91,110.01 155.07,109.85 156.12,109.85 156.83,109.14 156.83,107.81 156.64,107.62 154.05,107.62 153.82,107.85 151.1,107.85 150.95,108 150.95,109.85 151.03,109.93 151.43,109.93 151.56,110.06 151.56,111.1 151.69,111.22 152.81,111.22 152.98,111.05 154.2,111.05 154.28,111.12 154.28,111.25 154.43,111.4 155.07,111.4
LX_VCCIO on IN1 (solid shape): 154.77,114.83 154.77,113.75 154.71,113.69 154.08,113.69 154.01,113.75 154.01,114.89 154.2,115.09 154.52,115.09
LX_VCCSA on BOTTOM (solid shape): 146.33,122.15 146.33,120.67 146.21,120.55 145.06,120.55 145,120.61 145,120.86 144.49,121.37 143.85,121.37 143.61,121.13 143.61,116.58 140.66,113.64 139.01,113.64 138.98,113.61 138.98,112.83 139.01,112.8 139.89,112.8 139.95,112.74 139.95,111.46 139.87,111.38 137.41,111.38 136.88,111.91 136.88,115.69 137.07,115.89 139.36,115.89 139.78,116.3 140.33,116.3 140.79,116.76 140.79,120.98 140.8,120.99 140.8,121.94 141.13,122.27 146.2,122.27
LX_VCCSA on IN4 (solid shape): 134.37,116.36 134.37,115.57 134.26,115.47 133.07,115.47 132.94,115.59 132.94,116.41 133.04,116.51 134.21,116.51
LX_VCCSA on IN4 (solid shape): 137.44,115.82 137.44,115.03 137.26,114.86 136.02,114.86 135.76,115.11 135.76,115.82 135.91,115.97 137.29,115.97
LX_VCCSA on BOTTOM: 130.33,116.33 131.44,116.33 131.69,116.57 133.26,116.57 133.45,116.38 133.45,115.39 133.3,115.24 132.23,115.24 131.39,116.08 130.35,116.08 130.28,116.15 130.28,116.28
Net_199 on IN1 (solid shape): 198.59,173.61 197.32,173.61 197.32,174.88 198.59,174.88
Net_199 on IN1 (solid shape): 198.59,171.07 197.32,171.07 197.32,172.34 198.59,172.34
Net_199 on IN1 (solid shape): 201.13,173.61 199.86,173.61 199.86,174.88 201.13,174.88
Net_199 on IN1 (solid shape): 201.13,171.07 199.86,171.07 199.86,172.34 201.13,172.34
Net_199 on IN1 (solid shape): 203.67,173.61 202.4,173.61 202.4,174.88 203.67,174.88
Net_199 on IN1 (solid shape): 203.67,171.07 202.4,171.07 202.4,172.34 203.67,172.34
Net_199 on IN1 (solid shape): 206.21,173.61 204.94,173.61 204.94,174.88 206.21,174.88
Net_199 on IN1 (solid shape): 206.21,171.07 204.94,171.07 204.94,172.34 206.21,172.34
Net_199 on IN1 (solid shape): 208.75,173.61 207.48,173.61 207.48,174.88 208.75,174.88
Net_199 on IN1 (solid shape): 208.75,171.07 207.48,171.07 207.48,172.34 208.75,172.34
P1 on BOTTOM (solid shape): 122.48,150.44 122.48,149.03 122.4,148.95 121.62,148.95 121.35,148.68 121.35,147.13 121.31,147.09 120.54,147.09 120.49,147.14 120.49,150.42 120.72,150.65 122.27,150.65
P1 on TOP: 108.29,159.22 106.96,160.55 106.96,161.35 108.47,168.47 108.8,168.81 114.83,168.81 114.96,168.68 114.96,163.98 114.58,163.6 113.31,163.6 112.61,162.9 112.61,161.57 112.48,161.44 109.37,161.44 109.18,161.25 109.18,160.49 109.24,160.42 112.36,160.42 112.55,160.23 112.55,159.41 112.36,159.22
P2 on TOP: 113.88,163.15 117.75,163.15 118.83,162.08 118.83,153.06 119.39,152.51 120.52,152.51 120.63,152.4 120.63,150.95 120.52,150.83 119.42,150.83 119.32,150.73 114.09,150.73 112.98,149.63 111.98,149.63 111.93,149.68 111.93,153.46 111.54,153.85 111.54,157.67 111.59,157.73 113.33,157.73 113.94,158.34 113.94,160.11 114.2,160.36 117.06,160.36 117.25,160.55 117.25,161.31 117.12,161.44 116.67,161.44 116.61,161.38 113.88,161.38 113.44,161.82 113.44,162.71
P3 on TOP (solid shape): 136.3,154.26 136.3,147.47 135.98,147.15 132.8,147.15 132.68,147.03 132.68,146.2 132.74,146.14 135.79,146.14 136.04,145.88 136.04,144.49 135.66,144.1 132.3,144.1 131.85,144.55 131.85,148.74 130.6,149.99 130.6,151.54 131.03,151.97 131.03,153.68 131.74,154.39 136.17,154.39
P4 on TOP: 137.5,149.25 141.38,149.25 143.01,147.61 143.7,147.61 144.27,147.03 144.27,145.55 144.07,145.35 142.29,145.35 142.07,145.14 142.07,144.93 141.63,144.49 141.63,141.37 140.23,139.98 140.23,136.52 140.1,136.39 136.74,136.39 135.24,134.88 134.07,134.88 134.04,134.91 134.04,142.89 134.09,142.94 137.39,142.94 137.51,143.07 137.51,143.65 137.38,143.79 137.38,145.95 137.63,146.2 140.68,146.2 140.74,146.26 140.74,147.03 137.44,147.03 137.31,147.15 137.31,149.06
PQ10A_GATE on BOTTOM: 147.31,166.8 147.26,166.85 147.26,167.63 147.02,167.87 147.02,170.01 147.16,170.14 148.46,170.14 148.57,170.03 148.57,167.84 148.43,167.7 147.91,167.7 147.81,167.6 147.81,166.87 147.74,166.8
PSID_2-2 on BOTTOM (solid shape): 134.44,146.4 134.44,145.96 134.73,145.67 137.09,145.67 137.25,145.5 137.25,144.87 137.09,144.7 134.21,144.7 133.69,145.22 133.69,146.43 133.75,146.49 134.35,146.49
PSID_2-4 on BOTTOM (solid shape): 133.9,147.86 133.9,147.23 133.54,146.87 133.54,144.97 133.7,144.81 133.7,144.15 133.56,144.01 132.9,144.01 132.36,144.56 132.36,145.31 132.79,145.73 132.79,146.57 132.3,147.06 132.3,147.92 132.58,148.19 133.57,148.19
SNB_1.2V on TOP: 236.85,113.78 238.69,113.78 238.82,113.66 238.82,112.2 238.69,112.07 237.74,112.07 237.61,112.2 237.61,112.89 237.42,113.08 236.85,113.08 236.73,113.21 236.73,113.66
SNB_3V on TOP (solid shape): 309.76,49.54 309.76,48.35 309.98,48.13 309.98,47.54 309.82,47.38 309,47.38 307.9,48.47 307.9,49.57 308.06,49.72 309.58,49.72
SNB_5V on TOP (solid shape): 311.45,33.4 311.45,30.86 311.35,30.76 309.4,30.76 309.21,30.95 309.21,33.42 309.34,33.55 311.3,33.55
SNB_+1VALWP on BOTTOM: 269.2,18.06 270.22,18.06 270.28,17.99 270.28,17.1 270.41,16.98 271.04,16.98 271.11,16.91 271.11,16.28 271.04,16.22 269.26,16.22 269.07,16.41 269.07,17.93
SNB_VCCIO on BOTTOM (solid shape): 153.09,107.19 153.09,105.23 152.97,105.12 151.35,105.12 151.25,105.21 151.25,106.06 151.08,106.23 151.08,107.14 151.36,107.41 152.86,107.41
SW_1.2V on TOP (solid shape): 246.1,119.2 246.1,112.84 245.24,111.97 240.38,111.97 240.25,112.1 240.25,113.81 239.74,114.32 233.58,114.32 233.39,114.51 233.39,117.31 233.9,117.82 235.23,117.82 235.68,118.26 235.68,118.83 235.8,118.96 240.38,118.96 241.01,119.59 245.71,119.59
SW_1.2V on TOP (solid shape): 221.4,119.91 221.41,119.9 221.41,119.24 221.27,119.1 220.93,119.1 220.6,119.43 220.01,119.43 219.35,118.77 219.35,118.04 219.25,117.94 219.14,117.94 219.11,117.97 219.11,119.23 219.32,119.44 219.32,120.32 219.36,120.37 220.95,120.37
SW_1.2V on IN4 (solid shape): 235.03,117.32 235.03,116.28 234.72,115.97 233.47,115.97 233.28,116.17 233.28,117.3 233.6,117.63 234.72,117.63
SW_1.2V on IN4 (solid shape): 221.53,119.77 221.92,119.77 222.05,119.64 222.05,118.87 221.94,118.76 221.16,118.76 220.4,119.53 220.4,120 220.56,120.17 221.13,120.17
SW_+1VALWP on TOP (solid shape): 267.44,9.68 267.44,8.89 267.23,8.68 265.88,8.68 265.4,9.17 264.63,9.17 264.57,9.23 264.57,9.42 264.63,9.48 265.4,9.48 265.59,9.29 266.06,9.29 266.5,9.73 267.39,9.73
SW_+1VALWP on BOTTOM (solid shape): 268.21,18.18 268.21,15.07 267.99,14.85 266.61,14.85 266.42,15.05 266.42,18.3 266.59,18.48 267.91,18.48
SW_+1VALWP on IN1 (solid shape): 268.27,16.05 268.27,14.2 268.02,13.94 267.44,13.94 267.26,14.12 267.26,15.92 267.54,16.2 268.12,16.2
SW_+1VALWP on IN1 (solid shape): 267.82,10.11 267.82,9.93 266.55,8.66 265.76,8.66 265.66,8.76 265.66,9.07 265.81,9.22 265.96,9.22 266.22,9.47 266.22,9.55 267.13,10.46 267.46,10.46
SW_+1VALWP on TOP: 269.16,21.26 269.16,19.66 269.06,19.56 268.86,19.56 268.83,19.58 267.97,19.58 267.82,19.43 267.82,18.21 267.99,18.03 270.41,18.03 270.51,17.93 270.51,15.34 270.2,15.03 269.84,15.03 268.16,13.36 264.12,13.36 263.81,13.67 263.81,14.38 263.75,14.44 263.75,21.36 263.87,21.47 268.95,21.47
SWR_18_PG on TOP: 172.04,163.87 171.77,163.87 171.7,163.8 171.7,162.93 171.05,162.29 171.05,161.68 171.12,161.61 171.59,161.61 171.65,161.67 171.65,162.19 172.07,162.61 172.07,163.84
TBT_A_CC1 on BOTTOM: 10.32,45.87 13.36,45.87 13.43,45.81 13.43,45.3 13.3,45.17 12.92,45.17 12.79,45.3 10.51,45.3 9.81,44.6 7.97,44.6 7.84,44.73 6.7,44.73 6.57,44.85 6.57,45.04 6.7,45.17 8.16,45.17 8.35,44.98 9.43,44.98
TBT_A_CC2 on TOP: 7.14,46.38 8.54,46.38 8.6,46.44 11.21,46.44 11.27,46.51 11.65,46.51 11.84,46.31 12.48,46.31 12.6,46.44 13.36,46.44 13.43,46.38 13.43,46 13.36,45.93 12.86,45.93 12.73,45.81 8.79,45.81 8.6,46 7.2,46 7.08,46.12 7.08,46.31
TBT_DEMA1 on BOTTOM: 45.19,19.63 45.41,19.4 46.66,19.4 46.79,19.53 46.79,19.84 46.41,20.22 46.41,20.93 46.33,21 45.25,21 45.19,20.94
TBT_SVR_IND on TOP (solid shape): 24.05,56.86 24.05,53.33 23.81,53.08 21.46,53.08 21.26,53.28 21.26,56.92 21.37,57.03 23.89,57.03
TBT_SVR_IND on BOTTOM: 20.83,48.19 20.83,48.17 20.92,48.08 20.92,47.8 20.88,47.76 20.83,47.76 20.62,47.55 20.62,47.4 20.55,47.33 20.29,47.33 20.17,47.45 20.17,48.21 20.16,48.22 20.16,48.34 19.84,48.66 19.84,49.4 20.5,50.05 20.5,50.93 20.54,50.9 20.6,50.87 20.55,50.92 20.55,51.51 20.5,51.48 20.5,52.43 21.26,53.19 21.26,57 21.54,57.28 22.96,57.28 23.09,57.16 23.09,53.17 22.56,52.64 22.45,52.64 21.37,51.56 21.37,50.14 21.03,49.8 21.03,49.77 20.65,49.39 20.65,49.04 20.77,48.92 20.77,48.33 20.78,48.33 20.78,48.25
UG1_ISL95338_1 on BOTTOM (solid shape): 115.85,145.21 115.85,143.93 115.76,143.84 114.37,143.84 114.26,143.95 114.26,145.12 114.45,145.31 115.75,145.31
UG1_ISL95338_1 on BOTTOM (solid shape): 122.88,144.98 123.03,144.94 123.18,144.98 123.37,144.98 123.5,144.86 123.63,144.86 123.69,144.79 124.55,144.79 124.59,144.75 124.59,144.61 124.52,144.54 123.54,144.54 123.5,144.5 122.5,144.5 122.48,144.53 122.48,144.83 122.63,144.98
UG1_ISL95338_1 on IN4 (solid shape): 110.51,144.55 110.51,144.17 109.75,143.41 109.63,143.41 109.12,143.91 109.12,144.23 109.69,144.8 110.26,144.8
UG1_ISL95338_1 on IN4 (solid shape): 122.78,145.31 123.39,145.31 123.52,145.18 123.52,144.52 123.47,144.47 123.45,144.47 123.27,144.52 123.08,144.47 121.51,144.47 121.39,144.6 121.39,145.46 121.56,145.64 122.45,145.64
UG1_ISL95338_1 on BOTTOM: 109.05,145.25 109.31,145.25 109.63,144.93 109.63,144.49 109.88,144.23 109.88,143.6 109.75,143.47 109.5,143.47 108.86,144.1 108.86,145.06
UG1_ISL95338_1 on IN4: 113.71,143.88 113.52,144.07 113.52,145 113.72,145.2 116.27,145.2 116.72,144.75 116.72,144.27 116.33,143.88
UG1_ISL95338_2 on BOTTOM (solid shape): 140.23,137.71 140.23,136.79 140.1,136.66 138.76,136.66 138.65,136.77 138.65,137.64 138.81,137.8 140.15,137.8
UG1_ISL95338_2 on BOTTOM (solid shape): 139.78,131.2 139.78,130.21 139.61,130.04 138.85,130.04 138.85,130.04 138.22,130.04 138.13,130.14 138.13,131.23 138.22,131.32 139.66,131.32
UG1_ISL95338_2 on BOTTOM (solid shape): 146.03,142.27 146.95,142.27 146.97,142.25 146.97,142.13 146.91,142.07 145.99,142.07 145.94,142.03 145.92,142.03 145.9,142.01 145.76,142.01 145.31,141.56 144.87,141.56 144.74,141.69 144.74,141.95 144.87,142.07 145.12,142.07 145.38,142.33 145.97,142.33
UG1_ISL95338_2 on IN1 (solid shape): 140.04,131.65 140.04,130.17 139.93,130.05 138.69,130.05 138.55,130.2 138.55,132.03 138.66,132.14 139.55,132.14
UG1_ISL95338_2 on IN1 (solid shape): 145.76,142.14 145.76,142.01 145.63,141.88 145.38,141.88 144.3,140.8 143.66,140.8 143.47,140.99 143.47,141.44 144.49,142.45 145.44,142.45
UG1_ISL95338_2 on IN1 (solid shape): 140.25,138.33 140.25,136.83 140.16,136.74 139.7,136.74 139.65,136.69 139.65,135.87 139.62,135.83 138.56,135.83 138.4,136 138.4,138.22 138.63,138.46 140.12,138.46
UG2_ISL95338_1 on TOP (solid shape): 121.82,128.36 121.82,127.47 121.56,127.21 120.71,127.21 120.52,127.4 120.52,128.26 120.74,128.48 121.69,128.48

# Allegro board Alienware Area-51M LA-G881P.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_D55: length 120.2
  IN1 w0.122: v2(237.35,89.24) 237.35,89.25 236.77,89.82 236.77,90.81 236.32,91.26 233.09,91.26 232.96,91.39 232.02,91.39 231.66,91.75 229.02,91.75 227.98,92.8 223.61,92.8 223.06,93.35 222.42,93.35 222.3,93.23 222.3,92.92 222.18,92.8 221.93,92.8 221.81,92.92 221.81,93.23 221.69,93.35 221.44,93.35 221.32,93.23 221.32,92.92 221.2,92.8 220.96,92.8 220.83,92.92 220.83,93.23 220.71,93.35 220.47,93.35 220.35,93.23 220.35,92.92 220.22,92.8 219.98,92.8 219.86,92.92 219.86,93.23 219.74,93.35 217.37,93.35 216.81,92.8 205.18,92.8 205.05,92.93 166.75,92.93 164.21,90.38 163.63,90.38 162.55,89.3 162.55,88.39 v2(162.55,88.38)
  IN3 w0.15: v2(249.89,86.51) 249.89,87.21 249.7,87.4 246.5,87.4 246.22,87.68 243.65,87.68 243.37,87.4 241.38,87.4 241.14,87.17 240.84,87.17 240.64,87.36 240.64,87.49 240.45,87.68 240.05,87.68 239.85,87.49 239.85,87.36 239.65,87.17 238.18,87.17 237.54,87.81 236.46,87.81 236.32,87.95 236.32,88.61 236.5,88.79 236.86,88.79 237.02,88.85 237.35,89.18 v2(237.35,89.24)
  BOTTOM w0.102: v2(162.55,88.38) 162.04,88.38 160.68,87.03 160.68,86.99 158.9,85.21 158.9,82.72 UC1.AM1
  BOTTOM w0.157: JDIMM3.225 232.66,84.78 235.89,88.01 236.15,88.01 237.35,89.21 v2(237.35,89.24) ; v2(249.89,86.51) 249.89,86.32 248.35,84.78 JDIMM1.225
DDR_A_D56: length 122.7
  IN2 w0.102: v2(158.42,87.5) 158.42,87.96 159.24,88.79 159.27,88.79
  IN2 w0.15: 159.27,88.79 160.78,90.3 165.78,90.3 167.06,89.02 174.34,89.02 175.62,90.3 176.2,90.3 176.35,90.15 176.35,89.07 176.5,88.92 176.8,88.92 176.95,89.07 176.95,90.15 177.1,90.3 177.4,90.3 177.55,90.15 177.55,89.07 177.7,88.92 178,88.92 178.15,89.07 178.15,90.15 178.3,90.3 178.6,90.3 178.75,90.15 178.75,89.07 178.9,88.92 179.2,88.92 179.35,89.07 179.35,90.15 179.5,90.3 179.8,90.3 179.95,90.15 179.95,89.52 180.1,89.37 180.4,89.37 180.55,89.52 180.55,90.15 180.7,90.3 183.69,90.3 184.97,89.02 229.2,89.02 230.02,89.84 234.04,89.84 v2(234.57,90.37)
  IN3 w0.15: v2(234.57,90.37) 234.95,90.75 235.43,90.75 237.09,92.42 238.42,92.42 238.67,92.66 248.58,92.66 v2(248.76,92.47)
  BOTTOM w0.102: v2(158.42,87.5) 157.89,87.5 157.22,86.83 157.22,86.43 157.26,86.38 157.26,85.06 157.36,84.96 157.36,83.78 157.42,83.72 157.42,83.03 157.36,82.97 157.36,81.18 UC1.AK3
  BOTTOM w0.157: JDIMM3.237 233.04,87.78 233.76,88.49 233.76,89.56 v2(234.57,90.37) ; v2(248.76,92.47) 248.39,90.51 248.39,89.33 246.83,87.78 JDIMM1.237
DDR_A_D57: length 118.4
  IN2 w0.102: v2(155.99,84.48) 156.08,84.57 160.79,84.57 163.66,87.43 167.04,87.43
  IN2 w0.15: v2(238.59,87.7) 238.54,87.65 212.65,87.65 211.66,86.66 177.46,86.66 176.69,87.43 176.27,87.43 176.12,87.29 176.12,86.34 175.97,86.19 175.67,86.19 175.52,86.34 175.52,87.29 175.37,87.43 175.07,87.43 174.92,87.29 174.92,86.34 174.77,86.19 174.47,86.19 174.32,86.34 174.32,87.29 174.17,87.43 173.92,87.43 173.77,87.29 173.77,86.47 173.62,86.32 173.32,86.32 173.17,86.47 173.17,87.29 173.02,87.43 172.72,87.43 172.57,87.29 172.57,86.47 172.42,86.32 172.12,86.32 171.97,86.47 171.97,87.29 171.82,87.43 171.52,87.43 171.37,87.29 171.37,86.47 171.22,86.32 170.92,86.32 170.77,86.47 170.77,87.29 170.62,87.43 170.32,87.43 170.17,87.29 170.17,86.47 170.02,86.32 169.72,86.32 169.57,86.47 169.57,87.29 169.42,87.43 167.69,87.43 167.68,87.44 167.33,87.44 167.32,87.43 167.04,87.43
  IN3 w0.15: v2(250.67,87.44) 250.67,87.98 250.52,88.13 246.77,88.13 246.51,88.39 241.62,88.39 241.39,88.16 240.9,88.16 240.67,88.39 238.7,88.39 238.59,88.28 v2(238.59,87.7)
  BOTTOM w0.102: v2(155.99,84.48) 155.92,84.48 155.04,83.6 155.04,82.75 UC1.AH1
  BOTTOM w0.157: JDIMM3.236 238.76,87.53 v2(238.59,87.7) ; v2(250.67,87.44) 250.56,87.32 250.29,87.32 250.16,87.45 250.16,87.88 250.25,87.97 252.29,87.97 252.73,87.53 JDIMM1.236
DDR_A_D58: length 120.8
  IN2 w0.102: v2(157.62,86.6) 157.62,87.28 157.06,87.85 157.06,88.76
  IN2 w0.15: 157.06,88.76 157.06,89.35 159.62,91.91 185.64,91.91 186.34,91.21 186.72,91.21 186.87,91.36 186.87,91.81 187.02,91.96 187.32,91.96 187.47,91.81 187.47,91.36 187.62,91.21 187.92,91.21 188.07,91.36 188.07,91.81 188.22,91.96 188.52,91.96 188.67,91.81 188.67,91.36 188.82,91.21 189.12,91.21 189.27,91.36 189.27,91.81 189.42,91.96 189.72,91.96 189.87,91.81 189.87,91.36 190.02,91.21 190.32,91.21 190.47,91.36 190.47,91.81 190.62,91.96 190.92,91.96 191.07,91.81 191.07,91.36 191.22,91.21 191.51,91.21 191.66,91.36 191.66,91.81 191.81,91.96 192.11,91.96 192.26,91.81 192.26,91.36 192.41,91.21 192.71,91.21 192.86,91.36 192.86,91.81 193.01,91.96 193.31,91.96 193.46,91.81 193.46,91.36 193.61,91.21 193.9,91.21 194.05,91.36 194.05,91.81 194.2,91.96 194.5,91.96 194.65,91.81 194.65,91.36 194.8,91.21 195.1,91.21 195.25,91.36 195.25,91.81 195.4,91.96 195.7,91.96 195.85,91.81 195.85,91.36 196,91.21 196.3,91.21 196.45,91.36 196.45,91.69 196.6,91.84 196.9,91.84 197.05,91.69 197.05,91.36 197.2,91.21 202.01,91.21 202.71,91.91 204.03,91.91 204.97,90.96 210.41,90.96 210.49,90.88 219.47,90.88 219.55,90.96 228.58,90.96 229.57,91.96 233.3,91.96 v2(233.56,91.7)
  IN3 w0.15: v2(233.56,91.7) 233.51,91.66 233.51,91.04 233.73,90.83 234.02,90.83 234.43,91.23 235.27,91.23 237.02,92.99 238.35,92.99 239.2,93.83 246.42,93.83 v2(246.97,93.28)
  BOTTOM w0.102: UC1.AK4 157.46,80.36 157.46,80.95 157.56,81.06 157.56,82.89 157.62,82.94 157.62,83.91 157.56,83.97 157.56,84.59 157.62,84.64 157.62,86.6 v2(157.62,86.6)
  BOTTOM w0.157: JDIMM1.249 246.27,90.78 246.97,91.48 v2(246.97,93.28) ; JDIMM3.249 232.46,90.78 233.39,91.7 v2(233.56,91.7)
DDR_A_D59: length 121.7
  IN2 w0.15: v2(242.82,90.63) 242.42,91.03 236.82,93.32 229.01,93.32 228.55,92.87 227.2,92.87 227.18,92.89 207.83,92.89 207.5,92.56 205.49,92.56 204.72,93.32 159.1,93.32 155.68,89.89 v2(155.68,87.74)
  IN3 w0.15: v2(251.35,90.2) 251.51,90.05 251.51,90.02 251.95,89.58 253.13,89.58 253.28,89.43 253.28,89.01 253.15,88.88 251.7,88.88 250.94,89.64 249.17,89.64 249.02,89.79 249.02,90.19 248.87,90.34 248.31,90.34 248.15,90.18 248.15,89.8 247.98,89.64 247.4,89.64 247.1,89.93 246.92,89.93 246.81,90.04 246.81,90.29 246.67,90.43 245.75,90.43 245.68,90.36 245.68,90.13 245.48,89.93 245.09,89.93 244.89,90.13 244.89,90.34 244.83,90.4 243.52,90.4 243.06,89.93 242.7,89.93 242.53,90.11 242.53,90.3 242.62,90.39 242.62,90.42 v2(242.82,90.63)
  BOTTOM w0.102: UC1.AH2 155.15,81.82 154.62,82.35 154.62,84.64 154.65,84.67 154.65,84.99
  BOTTOM w0.157: v2(242.82,90.63) 242.42,91.03 JDIMM3.250 ; v2(155.68,87.74) 155.53,87.68 154.65,85.55 154.65,84.99 ; v2(251.35,90.2) 251.35,90.72 251.66,91.03 JDIMM1.250
DDR_A_D60: length 123.8
  IN2 w0.15: v2(237.69,88.52) 237.69,88.52 230.1,88.52 229.68,88.11 212.39,88.11 211.51,87.22 183.59,87.22 183.2,87.61 182.99,87.61 182.84,87.46 182.84,87.37 182.69,87.22 182.44,87.22 182.29,87.37 182.29,87.86 182.14,88.01 181.84,88.01 181.69,87.86 181.69,87.37 181.54,87.22 181.29,87.22 181.14,87.37 181.14,87.86 180.99,88.01 180.69,88.01 180.54,87.86 180.54,87.37 180.39,87.22 180.09,87.22 179.94,87.37 179.94,87.86 179.79,88.01 179.49,88.01 179.34,87.86 179.34,87.37 179.19,87.22 178.89,87.22 178.74,87.37 178.74,87.86 178.59,88.01 178.29,88.01 178.14,87.86 178.14,87.37 177.99,87.22 177.55,87.22 176.76,88.01 166.85,88.01 166.83,88.03 163.93,88.03 160.82,84.92 159.94,84.92 159.79,85.07 159.79,86.11 159.64,86.26 159.34,86.26 159.19,86.11 159.19,85.07 159.04,84.92 158.74,84.92 158.59,85.07 158.59,86.11 158.44,86.26 158.14,86.26 157.99,86.11 157.99,85.07 157.84,84.92 156.29,84.92 156.2,85.02 v2(156.16,85.02)
  IN3 w0.15: v2(237.69,88.52) 237.74,88.57 237.74,88.57 238.07,88.9 240.59,88.9 240.79,89.1 240.79,89.51 240.99,89.7 241.38,89.7 241.58,89.51 241.58,89.1 241.78,88.9 246.71,88.9 246.98,88.63 250.66,88.63 251.32,87.97 252.21,87.97 252.4,87.78 252.4,87.23 252.25,87.08 251.99,87.08 251.84,87.23 v2(251.84,87.44)
  BOTTOM w0.102: v2(156.16,85.02) 156.21,85.02 156.41,84.83 156.41,84.36 155.29,83.24 155.29,83.01 155.49,82.81 155.49,82.27 155.71,82.05 155.71,81.16 155.58,81.03 155.58,80.32 UC1.AH4
  BOTTOM w0.157: v2(251.84,87.44) 252.75,86.53 JDIMM1.232 ; v2(237.69,88.52) 237.54,88.36 237.54,87.48 238.49,86.53 JDIMM3.232
DDR_A_D61: length 123.7
  IN2 w0.102: v2(159.33,88.31) 159.57,88.31 159.88,88 163.49,88 163.96,88.47 167.04,88.47
  IN2 w0.15: v2(235.77,90.4) 235.77,89.57 235.25,89.05 229.98,89.05 229.5,88.56 207.26,88.56 207.16,88.47 192.04,88.47 191.89,88.32 191.89,88.25 191.74,88.1 191.44,88.1 191.29,88.25 191.29,88.32 191.14,88.47 190.84,88.47 190.69,88.32 190.69,87.83 190.54,87.68 190.24,87.68 190.09,87.83 190.09,88.32 189.94,88.47 189.64,88.47 189.49,88.32 189.49,87.83 189.34,87.68 189.04,87.68 188.89,87.83 188.89,88.32 188.74,88.47 188.44,88.47 188.29,88.32 188.29,87.83 188.14,87.68 187.84,87.68 187.69,87.83 187.69,88.32 187.54,88.47 187.24,88.47 187.09,88.32 187.09,87.83 186.94,87.68 186.64,87.68 186.49,87.83 186.49,88.32 186.34,88.47 186.04,88.47 185.89,88.32 185.89,87.83 185.74,87.68 185.44,87.68 185.3,87.83 185.3,88.32 185.15,88.47 184.85,88.47 184.7,88.32 184.7,87.83 184.55,87.68 184.25,87.68 184.1,87.83 184.1,88.32 183.95,88.47 167.04,88.47
  IN3 w0.15: v2(250.06,92.47) 249.58,92 247.9,92 247.75,92.15 238.81,92.15 238.61,91.96 237.28,91.96 235.77,90.46 v2(235.77,90.4)
  BOTTOM w0.102: UC1.AK2 156.98,82.1 156.64,82.44 156.64,82.81 156.65,82.82 156.65,83.45 156.6,83.5 156.6,83.64 157.01,84.05 157.01,86.92 158.72,88.63 159.01,88.63 v2(159.33,88.31)
  BOTTOM w0.157: v2(250.06,92.47) 249.77,92.18 248.85,89.75 248.85,89.14 246.49,86.78 JDIMM1.233 ; JDIMM3.233 232.7,86.78 235.76,89.84 235.76,90.38 v2(235.77,90.4)
DDR_A_D62: length 124.4
  IN2 w0.15: v2(156.19,86.17) 156.43,86.17 156.6,86.33 156.6,89.53 159.48,92.41 197.63,92.41 197.78,92.26 197.78,91.81 197.93,91.66 198.23,91.66 198.38,91.81 198.38,92.26 198.53,92.41 198.83,92.41 198.98,92.26 198.98,91.81 199.13,91.66 199.43,91.66 199.58,91.81 199.58,92.26 199.73,92.41 200.03,92.41 200.18,92.26 200.18,91.81 200.33,91.66 200.63,91.66 200.78,91.81 200.78,92.26 200.93,92.41 204.34,92.41 205.11,91.65 207.88,91.65 208.19,91.96 210.89,91.96 211.04,91.81 211.04,91.64 211.19,91.49 211.49,91.49 211.64,91.64 211.64,91.81 211.79,91.96 212.09,91.96 212.24,91.81 212.24,91.64 212.39,91.49 212.69,91.49 212.84,91.64 212.84,91.81 212.99,91.96 217.48,91.96 217.63,91.81 217.63,91.57 217.78,91.42 218.08,91.42 218.23,91.57 218.23,91.81 218.38,91.96 218.68,91.96 218.83,91.81 218.83,91.57 218.98,91.42 219.28,91.42 219.43,91.57 219.43,91.81 219.58,91.96 224.74,91.96 224.89,91.81 224.89,91.57 225.04,91.42 225.34,91.42 225.49,91.57 225.49,91.81 225.64,91.96 225.94,91.96 226.09,91.81 226.09,91.57 226.24,91.42 226.54,91.42 226.69,91.57 226.69,91.81 226.84,91.96 228.93,91.96 229.38,92.41 235.21,92.41 235.36,92.26 235.36,92.01 235.21,91.86 235.09,91.86 v2(234.95,91.73)
  IN3 w0.15: v2(248.14,93.28) 248.14,93.67 247.47,94.33 238.99,94.33 238.18,93.52 237.88,93.52 237.68,93.72 237.68,94.01 237.53,94.16 237.03,94.16 236.88,94.01 236.88,93.72 236.61,93.44 236.41,93.44 234.95,91.98 v2(234.95,91.73)
  BOTTOM w0.102: 155.26,84.99 155.26,84.82 154.82,84.38 154.82,82.43 155.03,82.22 155.16,82.22 155.48,81.9 155.48,81.6 UC1.AH3 ; 156.13,86.17 v2(156.19,86.17)
  BOTTOM w0.157: 156.13,86.17 155.83,86.17 155.26,85.6 155.26,84.99 ; JDIMM3.245 233.01,89.78 234.95,91.72 v2(234.95,91.73) ; JDIMM1.245 246.47,89.78 246.68,89.99 246.68,90.5 247.43,91.25 247.43,92.04 248.08,92.68 248.08,93.22 v2(248.14,93.28)
DDR_A_D63: length 117.6
  IN2 w0.102: 155.41,84.41 156.11,83.72 156.92,83.72 157.03,83.61 v2(157.03,83.33)
  IN2 w0.15: v2(241.25,90.55) 240.28,90.55 240.13,90.7 240.13,90.81 239.98,90.96 239.68,90.96 239.53,90.81 239.53,90.7 239.38,90.55 239.04,90.55 238.29,91.31 238.29,91.52 238.37,91.6 238.37,91.81 238.16,92.03 237.95,92.03 237.86,91.94 237.65,91.94 236.73,92.87 229.2,92.87 228.74,92.41 208,92.41 207.69,92.1 205.3,92.1 204.53,92.87 159.29,92.87 156.15,89.72 156.15,87.61 155.41,86.87 155.41,84.41
  IN3 w0.15: v2(252.52,90.2) 253.15,90.2 254.15,89.2 254.15,88.42 253.58,87.84 253.05,87.84 252.47,88.43 251.51,88.43 250.8,89.13 247.19,89.13 246.89,89.43 242.37,89.43 v2(241.25,90.55)
  BOTTOM w0.102: v2(157.03,83.33) 157,83.29 157,82.65 UC1.AK1
  BOTTOM w0.157: JDIMM3.246 240.72,90.03 v2(241.25,90.55) ; JDIMM1.246 252.7,90.03 v2(252.52,90.2)
DDR_A_DQS0: length 119.5
  IN2 w0.102: v2(153.76,41.98) 154.34,41.98 154.69,41.63 154.69,40.29 154.92,40.06 155.59,39.66 156.99,38.74 157.04,38.75 157.06,38.74
  IN2 w0.165: v2(234.5,28.08) 234.31,28.27 234.31,28.53 234.3,28.54 234.01,28.83 232.89,28.83 228.73,29.81 227.86,29.81 224.35,31.27 219.34,31.27 210.49,33.68 200.15,33.68 193.05,34.64 192.48,34.64 177.16,34.64 177,34.81 177,35.95 176.67,36.28 175.59,36.28 175.27,35.95 175.27,34.81 175.1,34.64 166.1,34.64 164.5,35.31 164.37,35.39 158.35,37.89 157.41,38.5 157.06,38.74
  IN4 w0.147: v2(248.33,27.94) 248.23,27.84 248.23,27.46 248.02,27.24 245.96,27.24 245.66,27.53 245.66,27.68 245.52,27.82 245.07,27.82 244.93,27.68 244.93,27.53 244.63,27.24 243.98,27.24 243.69,27.53 243.69,27.68 243.54,27.82 243.1,27.82 242.96,27.68 242.96,27.53 242.66,27.24 240.91,27.24 240.62,27.53 240.62,27.61 240.51,27.71 237.47,27.71 237.26,27.51 237.26,27.08 236.97,26.79 236.13,26.79 235.53,27.39 235.53,28.48 235.36,28.65 234.95,28.65 234.5,28.2 v2(234.5,28.08)
  BOTTOM w0.102: UC1.AF38 154.24,46.28 153.87,45.91 153.87,44.31 153.81,44.26 153.81,43.93 154.27,43.47 154.27,41.9 154.13,41.76 153.98,41.76 v2(153.76,41.98)
  BOTTOM w0.173: JDIMM3.13 232.4,29.78 232.51,29.67 232.78,29.67 232.94,29.5 233.92,29.5 234.5,28.92 v2(234.5,28.08) ; v2(248.33,27.94) 248.18,28.09 248.18,28.67 247.08,29.78 JDIMM1.13
DDR_A_DQS1: length 116.2
  IN1 w0.147: v2(235.96,33.55) 235.96,33.53 236.25,33.24 236.25,33.1 236.17,33.02 232.57,33.02 231.72,32.66 226.77,32.66 226.21,33.22 219.41,33.22 219.01,33.62 211.9,33.62 211.54,33.25 205.26,33.25 204.65,33.87 191.2,33.87 191.05,34.02 166.38,34.02 166.38,34.02 165.81,34.02 164.43,34.73 158.82,40.34 158.63,40.34 157.33,41.64 157.33,42.02 157.5,42.19 157.63,42.19 157.92,41.9 v2(157.92,41.76)
  IN3 w0.165: v2(235.96,33.55) 236.15,33.36 236.15,33.1 236.48,32.77 239.66,32.77 240.15,32.29 243.74,32.29 244.42,32.96 249.69,32.96 251.34,34.61 251.34,35.04 v2(251.45,35.15)
  BOTTOM w0.102: v2(157.92,41.76) 158.19,42.03 158.48,42.03 158.72,42.28 158.72,43.16 158.32,43.57 158.32,44.26 158.25,44.33 158.25,45.06 158.48,45.29 158.48,45.93 158.29,46.11 158.03,46.11 157.89,46.25 UC1.AK38
  BOTTOM w0.173: v2(251.45,35.15) 251.3,35 251.3,34.76 251.5,34.56 252.16,34.56 252.4,34.8 252.76,34.8 252.98,35.03 JDIMM1.34 ; JDIMM3.34 239.04,35.03 238.81,34.8 238.2,34.8 237.69,34.29 236.55,34.29 236.27,34.01 236.27,33.9 235.96,33.59 v2(235.96,33.55)
DDR_A_DQS2: length 110.7
  IN1 w0.147: v2(237.09,39.48) 237.09,40.2 236.76,40.53 235.96,40.53 234.83,39.39 231.25,39.39 230.69,38.84 220.14,38.84 219.13,39.85 199.26,39.85 196.09,43.02 165.89,43.02 165.42,43.49 165.07,43.49 v2(164.89,43.67)
  IN3 w0.165: v2(249.74,41.18) 249.53,41.39 249.19,41.39 249.07,41.28 249.07,41.04 249.34,40.78 249.34,40.55 248.42,39.63 242.23,39.63 241.51,38.91 237.24,38.91 237.09,39.06 v2(237.09,39.48)
  BOTTOM w0.102: UC1.AP38 162.14,46.01 162.14,45.36 161.89,45.11 161.89,44.37 161.94,44.31 161.94,43.93 161.79,43.78 161.79,43.64 161.89,43.53 162.52,43.53 162.85,43.19 163.79,43.19 164.05,43.45 164.66,43.45 v2(164.89,43.67)
  BOTTOM w0.173: JDIMM1.55 246.65,40.28 246.76,40.16 247.01,40.16 247.58,39.59 249.72,39.59 249.88,39.74 249.88,40.18 249.23,40.82 249.23,41.06 249.41,41.23 249.69,41.23 v2(249.74,41.18) ; JDIMM3.55 232.67,40.28 232.79,40.16 233.74,40.16 233.83,40.25 236.69,40.25 236.93,40.01 236.93,39.64 v2(237.09,39.48)
DDR_A_DQS3: length 100
  IN1 w0.147: v2(171.18,47.72) 171.05,47.72 170.9,47.87 170.9,48.06 171.05,48.21 187.54,48.21 188.25,47.5 198.73,47.5 200.15,46.08 203.68,46.08 203.97,46.37 203.97,46.49 204.12,46.64 204.99,46.64 205.13,46.49 205.13,46.37 205.43,46.08 214.12,46.08 214.75,45.45 225.58,45.45 225.8,45.67 233.46,45.67 233.89,45.24 236.39,45.24 237.18,46.02 237.18,46.03 237.35,46.2 v2(237.54,46.2)
  IN3 w0.165: v2(237.54,46.2) 237.54,45.83 237.65,45.72 239.04,45.72 239.75,46.43 245.49,46.43 245.67,46.25 247.71,46.25 248.27,46.81 249.92,46.81 250.42,46.32 250.42,45.96 250.58,45.8 250.58,45.76 v2(250.72,45.62)
  BOTTOM w0.102: UC1.AV36 165.52,48.43 165.89,48.79 167.03,48.79 167.28,48.55 167.28,48.23 167.4,48.11 167.68,48.11 168.16,48.59 170.71,48.59 170.94,48.36 170.94,48.3 170.94,48.3 170.94,48.28
  BOTTOM w0.109: 170.94,48.28 170.94,47.96 v2(171.18,47.72)
  BOTTOM w0.147: JDIMM3.76 238.69,45.53 238.4,45.24 237.38,45.24 237.16,45.45 237.16,45.76 237.38,45.98 237.38,46.04 v2(237.54,46.2)
  BOTTOM w0.173: v2(250.72,45.62) 250.58,45.47 250.58,45.43 250.41,45.27 250.41,45.1 250.59,44.93 251.69,44.93 252.06,45.3 252.72,45.3 252.94,45.53 JDIMM1.76
DDR_A_DQS4: length 105
  IN1 w0.147: v2(234.71,75.26) 234.71,75.28 235,75.57 235,75.67 234.9,75.77 230.86,75.77 230.01,76.61 226.1,76.61 225.68,77.03 224.06,77.03 223.75,76.72 214.13,76.72 212.17,77.2 209.59,77.2 209.15,76.76 192.28,76.76 190.84,78.2 173.25,78.2 172.07,79.39 169.76,79.39 168.78,79.12 168.15,78.48 168.15,78.29 168.39,78.05 168.53,78.05 168.83,78.36 169.01,78.36 169.09,78.27 v2(169.09,78)
  IN3 w0.165: v2(249.63,73.34) 249.53,73.23 249.53,72.76 249.26,72.49 244.63,72.49 244.22,72.9 239.44,72.9 238.57,73.76 236.45,73.76 236.3,73.61 235.13,73.61 234.71,74.02 v2(234.71,75.26)
  BOTTOM w0.102: v2(169.09,78) 168.67,78 168.35,78.33 167.88,78.33 167.32,77.77 166.47,77.77 166.41,77.71 164.75,77.71 164.52,77.47 164.52,77.24 164.42,77.14 UC1.AV7
  BOTTOM w0.173: v2(234.71,75.26) 234.55,75.09 234.55,74.95 234.72,74.78 234.92,74.78 235.02,74.68 235.02,74.29 234.83,74.1 234.58,74.1 233.53,73.05 232.79,73.05 232.56,73.28 JDIMM3.179 ; v2(249.63,73.34) 249.53,73.44 249.53,73.85 249.12,74.26 248.03,74.26 247.04,73.28 JDIMM1.179
DDR_A_DQS5: length 108.5
  IN1 w0.147: v2(241.78,79.06) 241.68,78.97 241.68,78.71 241.76,78.64 241.97,78.64 242.11,78.49 242.11,78.26 241.85,78 241.18,78 238.05,81.12 232.54,81.12 230.2,83.46 212.59,83.46 212.56,83.43 206.33,83.43 206.22,83.54 198.71,83.54 198.56,83.68 198.56,83.9 198.27,84.19 197.62,84.19 197.32,83.9 197.32,83.68 197.18,83.54 196.93,83.54 196.27,84.19 182.94,84.19 182.21,84.92 179.42,84.92 179.01,84.5 179.01,83.68 178.86,83.54 178.08,83.54 176.17,85.44 169.07,85.44 168.25,84.63 168.25,84.13 167.44,83.31 167.15,83.31 167.02,83.44 167.02,83.53 167.26,83.76 167.26,83.97 167.13,84.1 v2(167.03,84.1)
  IN3 w0.165: v2(241.78,79.06) 241.93,79.22 241.93,79.57 242.2,79.84 244.52,79.84 245.38,78.99 246.4,78.99 246.68,79.27 247.89,79.27 248.7,78.46 248.93,78.46 249.31,78.84 249.31,79.34 249.94,79.97 250.66,79.97 251.29,79.34 v2(251.29,78.42)
  BOTTOM w0.102: 164.87,83.43 164.17,83.43 163.82,83.07 163.82,82.33 163.38,81.89 UC1.AU2
  BOTTOM w0.109: v2(167.03,84.1) 167.03,84.17 166.86,84.34 166.7,84.34 166.35,83.99 165.61,83.99 165.04,83.43 164.87,83.43
  BOTTOM w0.173: v2(251.29,78.42) 251.29,78.02 251.42,77.88 251.97,77.88 252.5,78.41 252.84,78.41 252.95,78.53 JDIMM1.200 ; JDIMM3.200 240.85,78.53 240.96,78.41 241.76,78.41 241.99,78.64 241.99,78.76 241.78,78.97 v2(241.78,79.06)
DDR_A_DQS6: length 119.6
  IN1 w0.147: v2(160.82,86.59) 160.93,86.7 161.16,86.7 161.16,86.69 161.38,86.69 162.07,86.01 163.02,86.01 163.75,86.73 163.75,86.79 167.68,90.72 168.53,90.72 168.68,90.58 168.68,90.21 168.97,89.92 169.62,89.92 169.91,90.21 169.91,90.58 170.06,90.72 170.5,90.72 170.65,90.58 170.65,90.21 170.94,89.92 171.59,89.92 171.89,90.21 171.89,90.58 172.03,90.72 172.54,90.72 172.69,90.58 172.69,90.23 172.98,89.94 173.63,89.94 173.92,90.23 173.92,90.49 174.16,90.72 174.4,90.72 174.55,90.58 174.55,90.43 174.84,90.13 175.49,90.13 175.79,90.43 175.79,90.58 175.93,90.72 201.83,90.72 202.51,90.05 226.13,90.05 227.38,88.8 229.18,88.8 229.54,89.15 231.19,89.15 233.07,87.27 236.04,87.27 236.23,87.08 236.23,86.95 236.03,86.75 v2(236.03,86.75)
  IN3 w0.165: v2(250.04,83.56) 250.21,83.74 250.21,84.24 250.05,84.4 248.08,84.4 247.58,84.91 240.13,84.91 239.34,85.7 236.59,85.7 236.2,86.09 236.2,86.58 v2(236.03,86.75)
  BOTTOM w0.102: v2(160.82,86.59) 160.87,86.64 161.01,86.64 161.24,86.41 161.24,86.17 159.68,84.61 159.68,83.8 159.65,83.78 159.3,83.42 159.3,83.06 159.39,82.97 159.39,82.36 159.51,82.23 159.77,82.23 160.09,81.92 160.09,81.46 159.85,81.22 159.69,81.22 159.57,81.33 159.57,81.57 UC1.AN2
  BOTTOM w0.173: v2(250.04,83.56) 250.21,83.39 250.21,83.24 250.05,83.08 248.88,83.08 248.29,83.66 246.79,83.66 246.67,83.78 JDIMM1.221 ; v2(236.03,86.75) 236.18,86.59 236.18,86.23 235.83,85.87 235.33,85.87 233.12,83.66 232.79,83.66 232.67,83.78 JDIMM3.221
DDR_A_DQS7: length 121
  IN2 w0.165: v2(237.82,90.49) 237.82,90.71 237.71,90.83 237.49,90.83 236.99,91.33 236.32,91.33 236.19,91.2 229.75,91.2 228.86,90.3 219.83,90.3 219.73,90.19 210.28,90.19 210.17,90.3 202.75,90.3 202.51,90.54 186.06,90.54 185.36,91.24 174.44,91.24 174.12,90.91 174.12,90.17 173.95,90 173.45,90 173.29,90.17 173.29,90.91 172.96,91.24 172.23,91.24 171.91,90.91 171.91,90.13 171.74,89.96 171.25,89.96 171.08,90.13 171.08,90.91 170.75,91.24 170.02,91.24 169.7,90.91 169.7,90.13 169.53,89.96 169.04,89.96 168.87,90.13 168.87,90.91 168.54,91.24 160.39,91.24 158.24,89.09 157.81,89.09 v2(157.61,89.29)
  IN3 w0.165: v2(237.82,90.49) 237.74,90.4 237.74,90.15 238.05,89.84 239.64,89.84 239.8,90.01 239.8,90.88 240.34,91.42 244.56,91.42 244.64,91.34 245.42,91.34 245.5,91.42 246.99,91.42 247.13,91.29 249.68,91.29 250.01,90.96 250.01,90.38 v2(250.19,90.2)
  BOTTOM w0.102: UC1.AJ2 156.06,82.06 155.73,82.4 155.73,82.86 155.65,82.93 155.65,83.31 156.17,83.83 156.22,83.83 156.61,84.22 156.61,88.72 156.57,88.76 156.57,88.79
  BOTTOM w0.173: JDIMM3.242 238.73,89.03 238.61,88.91 238.47,88.91 238.3,89.08 238.3,89.6 237.69,90.21 237.69,90.35 v2(237.82,90.49) ; v2(157.61,89.29) 157.43,89.11 156.78,89.11 156.57,88.9 156.57,88.79 ; JDIMM1.242 253.06,89.03 252.95,88.91 252.19,88.91 251.99,89.11 251.03,89.11 250.83,88.91 250.18,88.91 250.01,89.09 250.01,90.02 v2(250.19,90.2)
DDR_A_DQS#0: length 119.3
  IN2 w0.102: v2(153.75,41.06) 153.65,41.06 153.57,41.14 153.58,41.5 153.68,41.6 153.92,41.6 154.09,41.78 154.26,41.78 154.48,41.55 154.48,40.21 154.79,39.9 155.49,39.49 156.88,38.57 156.89,38.52 156.91,38.5
  IN2 w0.165: v2(233.91,28.08) 234.02,28.19 234.02,28.43 233.9,28.55 232.86,28.55 228.69,29.53 227.8,29.53 224.3,30.99 219.3,30.99 210.45,33.4 200.13,33.4 193.03,34.36 192.48,34.36 177.05,34.36 176.72,34.69 176.72,35.84 176.55,36 175.71,36 175.55,35.84 175.55,34.69 175.22,34.36 166.05,34.36 164.37,35.06 164.24,35.14 158.22,37.64 156.91,38.5
  IN4 w0.147: v2(233.91,28.08) 234.07,28.24 234.07,28.26 234.32,28.51 234.46,28.51 234.85,28.9 235.46,28.9 235.78,28.58 235.78,27.5 236.24,27.04 236.86,27.04 237.01,27.19 237.01,27.61 237.36,27.96 240.61,27.96 240.87,27.71 240.87,27.64 241.01,27.49 242.56,27.49 242.71,27.64 242.71,27.78 243,28.07 243.65,28.07 243.94,27.78 243.94,27.64 244.09,27.49 244.53,27.49 244.68,27.64 244.68,27.78 244.97,28.07 245.62,28.07 245.91,27.78 245.91,27.64 246.06,27.49 247.91,27.49 247.98,27.56 247.98,27.68 247.9,27.76 247.9,27.79 v2(247.75,27.94)
  BOTTOM w0.102: UC1.AF39 154.6,45.32 154.6,44.34 154.65,44.29 154.65,43.98 154.47,43.8 154.47,41.82 154.21,41.55 154.09,41.55 153.75,41.22 v2(153.75,41.06)
  BOTTOM w0.173: v2(247.75,27.94) 247.75,28.04 247.91,28.2 247.91,28.56 246.97,29.5 246.6,29.5 246.37,29.28 JDIMM1.11 ; v2(233.91,28.08) 233.76,28.24 233.76,28.47 233.86,28.57 234.11,28.57 234.22,28.68 234.22,28.81 233.81,29.23 232.83,29.23 232.66,29.39 232.49,29.39 232.38,29.28 JDIMM3.11
DDR_A_DQS#1: length 115.6
  IN1 w0.147: v2(236.54,33.55) 236.5,33.51 236.5,32.99 236.27,32.77 232.62,32.77 231.77,32.41 226.67,32.41 226.11,32.97 219.31,32.97 218.91,33.37 212.01,33.37 211.64,33.01 205.16,33.01 204.54,33.62 191.1,33.62 190.95,33.77 166.28,33.77 166.28,33.77 165.75,33.77 164.29,34.53 158.72,40.09 158.53,40.09 157.08,41.54 157.08,42.12 157.4,42.44 157.89,42.44 v2(157.92,42.48)
  IN3 w0.165: v2(236.54,33.55) 236.44,33.45 236.44,33.24 236.44,33.2 236.59,33.05 239.78,33.05 240.26,32.57 243.63,32.57 244.3,33.24 249.57,33.24 251.06,34.73 251.06,34.97 v2(250.87,35.15)
  BOTTOM w0.102: UC1.AK39 157.89,45.83 157.98,45.91 158.21,45.91 158.27,45.85 158.27,45.37 158.07,45.17 157.78,45.17 157.55,44.94 157.55,44.3 157.51,44.26 157.51,43.95 157.9,43.56 158.03,43.56 158.52,43.08 158.52,42.37 158.39,42.24 158.16,42.24 v2(157.92,42.48)
  BOTTOM w0.173: v2(236.54,33.55) 236.54,33.89 236.66,34.01 237.81,34.01 238.32,34.53 JDIMM3.32 ; JDIMM1.32 252.51,34.53 252.27,34.29 251.38,34.29 251.02,34.65 251.02,35 v2(250.87,35.15)
DDR_A_DQS#2: length 110.3
  IN1 w0.147: v2(236.51,39.48) 236.51,39.51 236.84,39.84 236.84,40.1 236.66,40.28 236.07,40.28 234.93,39.15 231.35,39.15 230.79,38.59 220.03,38.59 219.02,39.6 199.15,39.6 195.98,42.77 165.79,42.77 165.32,43.24 165.04,43.24 v2(164.89,43.09)
  IN3 w0.165: v2(236.51,39.48) 236.69,39.29 236.69,39.06 237.12,38.63 241.62,38.63 242.34,39.35 248.54,39.35 250.08,40.89 v2(250.28,40.89)
  BOTTOM w0.102: UC1.AP39 161.55,45.99 161.64,46.08 161.78,46.08 161.93,45.93 161.93,45.44 161.66,45.17 161.31,45.17 161.21,45.07 161.21,44.42 161.12,44.34 161.12,44 161.58,43.54 161.6,43.54 161.81,43.33 162.43,43.33 162.77,42.99 163.88,42.99 164.13,43.25 164.73,43.25 v2(164.89,43.09)
  BOTTOM w0.173: JDIMM3.53 232.67,39.78 232.79,39.89 233.85,39.89 233.94,39.98 236.58,39.98 236.66,39.9 236.66,39.63 v2(236.51,39.48) ; v2(250.28,40.89) 250.21,40.86 250.15,40.71 250.15,39.63 249.84,39.31 247.47,39.31 246.89,39.89 246.76,39.89 246.65,39.78 JDIMM1.53
DDR_A_DQS#3: length 100.4
  IN1 w0.147: v2(170.46,47.72) 170.65,47.91 170.65,48.17 170.95,48.46 187.64,48.46 188.35,47.74 198.84,47.74 200.25,46.33 203.58,46.33 203.72,46.48 203.72,46.59 204.02,46.89 205.09,46.89 205.38,46.59 205.38,46.48 205.53,46.33 214.23,46.33 214.86,45.7 225.48,45.7 225.7,45.92 233.56,45.92 234,45.48 236.29,45.48 236.75,45.95 v2(236.75,46.2)
  IN3 w0.165: v2(250.14,45.62) 250.14,46.2 249.81,46.53 248.39,46.53 247.83,45.97 245.55,45.97 245.38,46.15 239.87,46.15 239.16,45.44 237.53,45.44 237.26,45.71 237.24,45.71 v2(236.75,46.2)
  BOTTOM w0.102: UC1.AU36 164.8,47.92 166.38,47.92 166.39,47.9 167.77,47.9 168.25,48.38 170.63,48.38 170.73,48.28 170.73,48.28
  BOTTOM w0.109: v2(170.46,47.72) 170.73,47.99 170.73,48.28
  BOTTOM w0.147: JDIMM3.74 238.64,45.03 238.54,44.92 237.24,44.92 236.84,45.32 236.84,45.89 236.75,45.98 v2(236.75,46.2)
  BOTTOM w0.173: JDIMM1.74 252.17,45.03 251.8,44.66 250.47,44.66 250.14,44.99 v2(250.14,45.62)
DDR_A_DQS#4: length 104.9
  IN1 w0.147: v2(235.3,75.26) 235.25,75.31 235.25,75.77 235.01,76.02 230.96,76.02 230.12,76.86 226.21,76.86 225.79,77.28 223.95,77.28 223.65,76.97 214.16,76.97 212.2,77.45 209.48,77.45 209.04,77.01 192.39,77.01 190.94,78.45 173.36,78.45 172.17,79.63 169.73,79.63 168.65,79.34 167.9,78.59 167.9,78.19 v2(168.59,77.5)
  IN3 w0.165: v2(248.99,73.34) 249.01,73.34 249.25,73.1 249.25,72.87 249.15,72.77 244.74,72.77 244.34,73.18 239.55,73.18 238.69,74.04 236.34,74.04 236.18,73.89 235.24,73.89 234.99,74.14 234.99,74.32 235.13,74.46 235.67,74.46 235.79,74.57 235.79,74.73 235.3,75.22 v2(235.3,75.26)
  BOTTOM w0.102: v2(168.59,77.5) 168.59,77.8 168.26,78.13 167.97,78.13 167.41,77.57 166.56,77.57 166.49,77.5 164.84,77.5 164.72,77.38 164.72,77.19 164.76,77.14 UC1.AW7
  BOTTOM w0.173: JDIMM3.177 233.65,72.78 234.7,73.83 234.95,73.83 235.3,74.18 v2(235.3,75.26) ; JDIMM1.177 246.49,72.78 246.71,73 247.37,73 247.63,73.26 247.63,73.47 248.15,73.99 249,73.99 249.25,73.73 249.25,73.6 v2(248.99,73.34)
DDR_A_DQS#5: length 108.9
  IN1 w0.147: v2(242.36,79.06) 242.36,78.15 241.96,77.75 241.07,77.75 237.95,80.87 232.44,80.87 230.1,83.21 212.7,83.21 212.67,83.18 206.23,83.18 206.12,83.29 198.6,83.29 198.31,83.58 198.31,83.8 198.16,83.94 197.72,83.94 197.57,83.8 197.57,83.58 197.28,83.29 196.83,83.29 196.17,83.94 182.83,83.94 182.11,84.67 179.52,84.67 179.26,84.4 179.26,83.58 178.96,83.29 177.98,83.29 176.07,85.2 169.18,85.2 168.5,84.52 168.5,84.02 167.54,83.06 167.05,83.06 v2(166.52,83.59)
  IN3 w0.165: v2(242.36,79.06) 242.24,79.19 242.24,79.48 242.32,79.56 244.41,79.56 245.26,78.71 246.51,78.71 246.8,78.99 247.77,78.99 248.58,78.18 249.05,78.18 249.59,78.72 249.59,79.23 250.05,79.69 250.55,79.69 250.99,79.24 250.99,79.01 250.88,78.89 250.53,78.89 250.36,78.73 250.36,78.49 250.59,78.39 v2(250.65,78.42)
  BOTTOM w0.102: UC1.AU3 163.38,81.14 163.77,81.54 163.77,81.92 164.02,82.17 164.49,82.17 165.22,82.9 165.22,83.2
  BOTTOM w0.109: 165.22,83.2 165.22,83.3 165.7,83.78 166.41,83.78 166.52,83.67 v2(166.52,83.59)
  BOTTOM w0.173: v2(242.36,79.06) 242.26,78.96 242.26,78.52 241.88,78.14 240.96,78.14 240.85,78.03 JDIMM3.198 ; v2(250.65,78.42) 250.65,78.11 250.76,78 250.91,78 251.31,77.61 252.08,77.61 252.61,78.14 252.8,78.14 252.91,78.03 JDIMM1.198
DDR_A_DQS#6: length 120
  IN1 w0.147: v2(161.33,87.1) 162.17,86.26 162.92,86.26 163.5,86.84 163.5,86.89 167.58,90.97 168.64,90.97 168.93,90.68 168.93,90.32 169.08,90.17 169.52,90.17 169.67,90.32 169.67,90.68 169.96,90.97 170.61,90.97 170.9,90.68 170.9,90.32 171.05,90.17 171.49,90.17 171.64,90.32 171.64,90.68 171.93,90.97 172.64,90.97 172.94,90.68 172.94,90.34 173.08,90.19 173.52,90.19 173.67,90.34 173.67,90.59 174.05,90.97 174.51,90.97 174.8,90.68 174.8,90.53 174.95,90.38 175.39,90.38 175.54,90.53 175.54,90.68 175.83,90.97 201.93,90.97 202.61,90.3 226.23,90.3 227.48,89.05 229.08,89.05 229.43,89.4 231.29,89.4 233.17,87.52 236.15,87.52 236.48,87.18 236.48,86.88 v2(236.61,86.75)
  IN3 w0.165: v2(236.61,86.75) 236.48,86.61 236.48,86.2 236.7,85.98 239.46,85.98 240.25,85.19 247.69,85.19 248.2,84.68 250.17,84.68 250.49,84.35 250.49,83.76 v2(250.7,83.56)
  BOTTOM w0.102: v2(161.33,87.1) 161.44,86.99 161.44,86.09 159.88,84.53 159.88,83.73 160.15,83.47 160.15,83.12 160.06,83.03 160.06,82.23 160.29,82 160.29,81.37 UC1.AN3
  BOTTOM w0.173: v2(250.7,83.56) 250.49,83.35 250.49,83.13 250.16,82.8 248.77,82.8 248.18,83.39 246.79,83.39 246.67,83.28 JDIMM1.219 ; JDIMM3.219 232.67,83.28 232.79,83.39 233.23,83.39 235.44,85.6 235.94,85.6 236.46,86.12 236.46,86.59 v2(236.61,86.75)
DDR_A_DQS#7: length 121.4
  IN2 w0.102: v2(157.58,88.61) 157.75,88.79
  IN2 w0.165: 157.75,88.79 157.78,88.81 158.36,88.81 160.51,90.96 168.43,90.96 168.59,90.8 168.59,90.01 168.92,89.68 169.65,89.68 169.98,90.01 169.98,90.8 170.14,90.96 170.64,90.96 170.8,90.8 170.8,90.01 171.13,89.68 171.86,89.68 172.18,90.01 172.18,90.8 172.35,90.96 172.85,90.96 173.01,90.8 173.01,90.05 173.34,89.72 174.07,89.72 174.39,90.05 174.39,90.8 174.56,90.96 185.25,90.96 185.95,90.26 202.4,90.26 202.64,90.02 210.06,90.02 210.16,89.91 219.84,89.91 219.95,90.02 228.97,90.02 229.87,90.92 236.31,90.92 236.44,91.05 236.88,91.05 237.21,90.71 v2(237.21,90.49)
  IN3 w0.165: v2(237.21,90.49) 237.46,90.24 237.46,90.04 237.93,89.56 239.75,89.56 240.08,89.89 240.08,90.76 240.46,91.14 244.44,91.14 244.52,91.06 245.54,91.06 245.62,91.14 246.88,91.14 247.01,91.01 249.57,91.01 249.73,90.84 249.73,90.33 v2(249.6,90.2)
  BOTTOM w0.102: UC1.AJ3 156.43,81.17 156.43,82.89 156.45,82.9 156.45,83.35 156.4,83.4 156.4,83.72 156.81,84.14 156.81,88.72 156.85,88.76 156.85,88.79
  BOTTOM w0.173: JDIMM3.240 238.73,88.53 238.61,88.64 238.36,88.64 238.03,88.97 238.03,89.48 237.41,90.1 237.41,90.29 v2(237.21,90.49) ; JDIMM1.240 252.92,88.53 252.81,88.64 252.08,88.64 251.88,88.84 251.15,88.84 250.95,88.64 250.07,88.64 249.73,88.97 249.73,90.07 v2(249.6,90.2) ; v2(157.58,88.61) 157.36,88.84 156.9,88.84 156.85,88.79
DDR_A_DRAMRST#: length 17
  TOP w0.112: RD52.1 252.59,53.36 v2(252.56,53.33) ; v1(241.96,52.54) v2(241.96,53.36) 242.11,53.52 CD134.1
  IN1 w0.084: v2(252.56,53.33) 252.04,53.85 242.44,53.85 v2(241.96,53.36)
  BOTTOM w0.112: v2(252.56,53.33) 252.76,53.53 JDIMM1.108 ; JDIMM3.108 240.72,53.53 241.07,53.87 241.45,53.87 v2(241.96,53.36)
DDR_A_MA0: length 105.4
  IN1 w0.102: 175.62,68.89 175.16,68.43 172.77,68.43 v2(172.23,68.97)
  IN1 w0.173: 175.62,68.89 186.68,68.89 191.64,63.93 191.91,63.93 192.08,64.1 192.08,64.95 192.26,65.12 192.6,65.12 192.78,64.95 192.78,64.1 192.95,63.93 193.29,63.93 193.47,64.1 193.47,64.95 193.64,65.12 193.98,65.12 194.16,64.95 194.16,64.1 194.33,63.93 194.68,63.93 194.85,64.1 194.85,64.95 195.02,65.12 195.37,65.12 195.54,64.95 195.54,64.1 195.71,63.93 196.06,63.93 196.23,64.1 196.23,64.95 196.4,65.12 196.75,65.12 196.92,64.95 196.92,64.1 197.09,63.93 211.96,63.93 212.64,64.6 236.92,64.6 237.18,64.87 v2(237.18,65.09)
  IN3 w0.216: v2(237.18,65.09) 237.18,64.67 238,63.85 248.21,63.85 249.17,62.89 251.54,62.89 252.12,62.31 v2(252.12,62)
  BOTTOM w0.102: v2(172.23,68.97) 171.77,68.52 168.02,68.52 167.46,67.97 166.8,67.97 166.46,67.63 166.13,67.63 UC1.AW15
  BOTTOM w0.224: JDIMM3.144 238.64,62.53 237.18,63.98 v2(237.18,65.09) ; JDIMM1.144 252.64,62.53 v2(252.12,62)
DDR_A_MA1: length 105
  IN1 w0.102: 175.62,63.53 175.28,63.53 175.17,63.65 172.37,63.65 172.17,63.85 172.17,64.05 172.44,64.32 v2(172.53,64.32)
  IN1 w0.173: 175.62,63.53 182.9,63.53 183.07,63.36 183.07,61.74 183.25,61.57 183.59,61.57 183.77,61.74 183.77,63.36 183.94,63.53 184.28,63.53 184.46,63.36 184.46,61.74 184.63,61.57 184.97,61.57 185.15,61.74 185.15,63.36 185.24,63.45 185.68,63.45 185.85,63.27 185.85,61.72 186.01,61.57 186.46,61.57 186.56,61.67 186.56,62 186.69,62.13 187,62.13 190.03,59.09 205.04,59.09 205.21,58.92 205.21,58.62 205.38,58.45 205.73,58.45 205.9,58.62 205.9,58.92 206.07,59.09 207.78,59.09 208.1,58.77 208.45,58.77 208.77,59.09 211.38,59.09 211.8,58.67 212.14,58.67 212.56,59.09 212.88,59.09 213.05,58.92 213.05,58.62 213.23,58.45 213.57,58.45 213.74,58.62 213.74,58.92 213.92,59.09 215.9,59.09 216.14,58.85 216.47,58.85 216.71,59.09 217.76,59.09 217.93,58.92 217.93,58.62 218.1,58.45 218.45,58.45 218.62,58.62 218.62,58.92 218.79,59.09 230.63,59.09 231.12,59.59 231.45,59.59 231.62,59.42 231.62,59.27 231.79,59.09 232.14,59.09 232.31,59.27 232.31,59.42 232.49,59.59 232.86,59.59 v2(233.07,59.38)
  IN3 w0.216: v2(233.07,59.38) 233.07,59.08 233.35,58.8 235.31,58.8 237.48,60.97 245.45,60.97 246.39,60.04 v2(246.89,60.04)
  BOTTOM w0.102: 170.86,65.22 169.88,65.22 168.23,63.58 166.86,63.58 166.35,64.08 165.71,64.08 165.5,64.29 165.5,64.29 165.49,64.31 164.87,64.31 UC1.AU18
  BOTTOM w0.163: 170.86,65.22 171.76,65.22 172.53,64.44 v2(172.53,64.32)
  BOTTOM w0.224: JDIMM1.133 246.63,59.78 v2(246.89,60.04) ; JDIMM3.133 232.68,59.78 v2(233.07,59.38)
DDR_A_MA2: length 106.6
  IN1 w0.102: v2(173.8,64.35) 173.8,64.32 174.16,63.96 175.62,63.96
  IN1 w0.173: v2(242.09,62.02) 241.87,62.02 239.77,59.92 230.99,59.92 230.49,59.42 190.16,59.42 185.62,63.96 175.62,63.96
  IN3 w0.216: v2(252.48,59.53) 254.24,59.53 254.51,59.79 254.51,61.09 254.23,61.36 252.3,61.36 251.97,61.03 246.73,61.03 245.26,62.51 242.58,62.51 v2(242.09,62.02)
  BOTTOM w0.102: UC1.AU17 164.8,65.29 164.8,64.77 165.02,64.55 165.57,64.55 165.8,64.31 166.41,64.31 166.91,63.81 168.16,63.81 170.04,65.7 170.86,65.7
  BOTTOM w0.163: 170.86,65.7 172.68,65.7 173.8,64.57 v2(173.8,64.35)
  BOTTOM w0.224: v2(242.09,62.02) 242.39,61.71 242.39,60.12 241.8,59.53 JDIMM3.132 ; JDIMM1.132 v2(252.48,59.53)
DDR_A_MA3: length 107.1
  IN1 w0.102: v2(171.26,64.32) 171.12,64.32 170.81,64.02 170.81,63.79 171.16,63.44 174.73,63.44 175.08,63.1 175.52,63.1 175.62,63.19
  IN1 w0.173: v2(234.34,59.38) 234.34,59.52 234.42,59.59 235.67,59.59 235.84,59.42 235.84,58.94 235.67,58.77 219.53,58.77 218.88,58.12 205.25,58.12 204.6,58.77 189.89,58.77 187.42,61.24 182.9,61.24 182.75,61.39 182.75,63.04 182.59,63.2 182.07,63.2 181.9,63.03 181.9,61.41 181.73,61.24 181.38,61.24 181.21,61.41 181.21,63.03 181.04,63.2 180.69,63.2 180.52,63.03 180.52,61.63 180.34,61.46 180,61.46 179.83,61.63 179.83,63.03 179.65,63.2 175.63,63.2 175.62,63.19
  IN3 w0.216: v2(248.06,60.04) 248.06,60.29 247.78,60.58 246.53,60.58 245.64,61.47 236.42,61.47 v2(234.34,59.38)
  BOTTOM w0.102: 170.86,64.76 170.64,64.98 169.97,64.98 168.32,63.34 166.81,63.34 166.28,63.87 165.52,63.87 165.48,63.91 165.27,63.91 UC1.AV19
  BOTTOM w0.163: v2(171.26,64.32) 171.26,64.36 170.86,64.76
  BOTTOM w0.224: JDIMM1.131 247.41,59.28 248.06,59.92 v2(248.06,60.04) ; v2(234.34,59.38) 234.34,59.28 233.88,58.82 232.94,58.82 232.49,59.28 JDIMM3.131
DDR_A_MA4: length 108.4
  IN1 w0.102: 175.62,62.68 175.09,62.68 174.52,63.24 171.08,63.24 v2(169.99,64.32)
  IN1 w0.173: v2(236.87,58.56) 236.75,58.44 219.66,58.44 219.02,57.8 205.11,57.8 204.47,58.44 189.76,58.44 188.62,59.58 187.96,59.58 187.58,59.97 187.58,60.62 187.42,60.78 186.97,60.78 186.84,60.65 186.84,59.75 186.67,59.58 186.32,59.58 186.15,59.75 186.15,60.74 185.98,60.91 185.63,60.91 185.46,60.74 185.46,59.86 185.29,59.69 184.94,59.69 184.77,59.86 184.77,60.74 184.6,60.91 184.25,60.91 184.08,60.74 184.08,59.75 183.91,59.58 183.56,59.58 183.39,59.75 183.39,60.74 183.22,60.91 182.87,60.91 182.7,60.74 182.7,59.75 182.52,59.58 182.18,59.58 182.01,59.75 182.01,60.74 181.83,60.91 180.08,60.91 178.32,62.68 175.62,62.68
  IN3 w0.216: v2(236.87,58.56) 236.87,58.76 237.71,59.6 245.07,59.6 245.77,58.9 251.71,58.9 252.03,58.59 v2(252.03,58.36)
  BOTTOM w0.102: v2(169.99,64.32) 169.64,64.32 168.41,63.1 166.76,63.1 166.25,63.61 164.96,63.61 164.7,63.87 164.7,64.09 164.45,64.35 163.75,64.35 UC1.AT19
  BOTTOM w0.224: JDIMM3.128 239.01,58.53 238.48,59.05 237.29,59.05 236.87,58.64 v2(236.87,58.56) ; v2(252.03,58.36) 252.19,58.53 JDIMM1.128
DDR_A_MA5: length 106.4
  IN1 w0.102: 175.62,62.35 175.01,62.35 174.65,62.71 174.04,62.71 v2(173.8,62.47)
  IN1 w0.173: 175.62,62.35 178.19,62.35 180.44,60.09 180.62,60.09 181.11,60.59 181.35,60.59 181.6,60.34 181.6,60.1 181.08,59.58 181.08,59.46 181.99,58.54 182.35,58.54 182.45,58.65 182.45,59.15 182.55,59.26 183.03,59.26 183.2,59.08 183.2,58.29 183.38,58.12 183.72,58.12 183.89,58.29 183.89,58.91 184.07,59.08 184.41,59.08 184.58,58.91 184.58,58.29 184.76,58.12 185.1,58.12 185.28,58.29 185.28,59.09 185.45,59.26 185.79,59.26 185.97,59.09 185.97,58.29 186.14,58.12 186.48,58.12 186.66,58.29 186.66,59.08 186.83,59.26 187.18,59.26 187.35,59.08 187.35,58.29 187.52,58.12 187.87,58.12 188.04,58.29 188.04,59.08 188.21,59.26 188.49,59.26 188.72,59.02 188.72,58.24 188.84,58.12 204.33,58.12 204.98,57.47 219.15,57.47 219.8,58.12 237.66,58.12 v2(238.1,58.56)
  IN3 w0.216: v2(238.1,58.56) 238.71,59.17 244.82,59.17 245.6,58.39 v2(250.78,58.39)
  BOTTOM w0.102: 170.86,63.77 169.46,63.77 168.55,62.85 166.72,62.85 166.18,63.39 164.93,63.39 164.83,63.3 164.6,63.06 UC1.AU20
  BOTTOM w0.163: 170.86,63.77 172.51,63.77 v2(173.8,62.47)
  BOTTOM w0.224: v2(250.78,58.39) 250.78,58.28 251.18,57.88 252.27,57.88 252.41,58.03 JDIMM1.126 ; v2(238.1,58.56) 238.64,58.03 JDIMM3.126
DDR_A_MA6: length 107.4
  IN1 w0.102: 174.85,62.03 172.98,62.03 v2(172.53,62.47)
  IN1 w0.173: v2(234.09,57.08) 234.2,56.97 240.15,56.97 240.23,57.05 240.23,57.68 240.12,57.79 219.93,57.79 219.29,57.15 211.9,57.15 211.34,56.58 208.79,56.58 208.23,57.15 204.84,57.15 204.2,57.79 182.28,57.79 178.05,62.03 174.85,62.03
  IN3 w0.216: v2(248.34,57.84) 248.34,57.74 247.83,57.22 245.42,57.22 244.35,58.3 239.86,58.3 238.89,57.33 234.33,57.33 v2(234.09,57.08)
  BOTTOM w0.102: UC1.AV20 166.21,63.06 166.66,62.61 168.69,62.61 169.39,63.32 170.86,63.32
  BOTTOM w0.163: 170.86,63.32 171.72,63.32 172.39,62.65 172.39,62.62 v2(172.53,62.47)
  BOTTOM w0.224: v2(248.34,57.84) 247.84,58.34 246.66,58.34 246.59,58.28 JDIMM1.127 ; JDIMM3.127 233.16,58.28 234.09,57.35 v2(234.09,57.08)
DDR_A_MA7: length 111.6
  IN1 w0.102: 175.62,61.33 170.14,61.33 169.97,61.5 v2(169.97,62.47)
  IN1 w0.173: v2(235.06,55.01) 235.06,55.42 235.27,55.62 238.33,55.62 238.51,55.8 238.51,56.49 238.35,56.64 230.34,56.64 230.16,56.46 213.89,56.46 213.32,55.89 211.78,55.89 211.57,55.69 207.77,55.69 207.57,55.89 204.63,55.89 204.45,56.06 204.45,56.62 204.28,56.79 203.94,56.79 203.76,56.62 203.76,56.06 203.59,55.89 200.39,55.89 199.13,57.14 182.01,57.14 178.81,60.35 178.63,60.35 177.79,59.51 177.57,59.51 175.75,61.33 175.62,61.33
  IN3 w0.216: v2(235.06,55.01) 235.06,55.13 235.91,55.98 239.75,55.98 239.95,56.18 244.62,56.18 245.06,55.75 247.73,55.75 249.28,57.3 251.48,57.3 251.77,57.01 v2(251.77,56.76)
  BOTTOM w0.102: UC1.AU21 164.66,62.14 164.99,62.48 165.58,62.48 165.67,62.57 166.02,62.57 166.02,62.57 166.03,62.57 166.47,62.13 169.1,62.13 169.44,62.47 v2(169.97,62.47)
  BOTTOM w0.224: JDIMM3.122 236.96,57.03 235.06,55.13 v2(235.06,55.01) ; JDIMM1.122 253.8,57.03 252.04,57.03 v2(251.77,56.76)
DDR_A_MA8: length 105
  IN1 w0.102: 175.62,61.7 171.43,61.7 171.26,61.87 v2(171.26,62.47)
  IN1 w0.173: v2(232.92,57.08) 232.92,57.35 232.8,57.47 230.51,57.47 230.33,57.3 230.33,57.08 230.16,56.91 229.82,56.91 229.64,57.08 229.64,57.3 229.47,57.47 229.12,57.47 228.95,57.3 228.95,56.95 228.78,56.78 228.43,56.78 228.26,56.95 228.26,57.3 228.09,57.47 227.74,57.47 227.57,57.3 227.57,56.95 227.4,56.78 227.05,56.78 226.88,56.95 226.88,57.3 226.71,57.47 226.21,57.47 226.07,57.33 226.07,56.86 225.99,56.78 223.85,56.78 223.68,56.95 223.68,57.3 223.51,57.47 223.16,57.47 222.99,57.3 222.99,56.95 222.82,56.78 213.53,56.78 213.36,56.61 213.36,56.39 213.18,56.22 212.84,56.22 212.67,56.39 212.67,56.61 212.49,56.78 212,56.78 211.47,56.26 208.66,56.26 208.13,56.78 206.25,56.78 206.08,56.61 206.08,56.39 205.9,56.22 205.56,56.22 205.39,56.39 205.39,56.61 205.21,56.78 204.75,56.78 204.06,57.47 203.79,57.47 203.61,57.3 203.61,56.95 203.44,56.78 203.1,56.78 202.92,56.95 202.92,57.3 202.75,57.47 202.4,57.47 202.23,57.3 202.23,56.95 202.06,56.78 201.71,56.78 201.54,56.95 201.54,57.3 201.37,57.47 201.02,57.47 200.85,57.3 200.85,56.58 200.68,56.4 200.33,56.4 200.16,56.58 200.16,57.3 199.99,57.47 182.15,57.47 178.84,60.77 178.6,60.77 177.8,59.98 177.56,59.98 177.32,60.22 177.32,60.47 178.11,61.26 178.11,61.51 177.92,61.7 177.58,61.7 176.81,60.93 176.61,60.93 175.84,61.7 175.62,61.7
  IN3 w0.216: v2(246.99,57.84) 245.51,57.84 244.61,58.73 239.63,58.73 238.67,57.78 233.22,57.78 232.92,57.48 v2(232.92,57.08)
  BOTTOM w0.102: 170.86,62.88 170.67,63.06 169.6,63.06 168.91,62.37 166.55,62.37 166.1,62.82 165.58,62.82 165.49,62.72 164.75,62.72 164.66,62.63 163.81,62.63 UC1.AT20
  BOTTOM w0.163: 170.86,62.88 v2(171.26,62.47)
  BOTTOM w0.224: v2(246.99,57.84) 246.93,57.78 JDIMM1.125 ; JDIMM3.125 232.44,57.78 232.92,57.3 v2(232.92,57.08)
DDR_A_MA9: length 108.8
  IN1 w0.102: 175.62,60.19 174.89,60.92 172.5,60.92 172.38,60.8 v2(172.38,60.44)
  IN1 w0.173: v2(234.26,55.89) 234.48,55.89 234.62,55.75 234.62,55.03 234.46,54.87 233.76,54.87 233.58,55.06 233.58,55.29 233.4,55.46 233.06,55.46 232.88,55.29 232.88,55.21 232.7,55.03 219.67,55.03 219.53,55.17 219.53,55.67 219.4,55.81 218.98,55.81 218.82,55.65 218.82,54.84 218.7,54.72 218.17,54.72 218.01,54.88 218.01,55.18 217.89,55.3 215.72,55.3 215.55,55.13 215.55,54.89 215.37,54.72 215.03,54.72 214.86,54.89 214.86,55.13 214.68,55.3 213.65,55.3 213.58,55.24 212.24,55.24 212.07,55.07 212.07,54.89 211.9,54.72 211.27,54.72 210.96,55.04 207.5,55.04 207.3,55.24 199.29,55.24 199.16,55.37 199.16,56.19 198.86,56.49 198.49,56.49 198.29,56.3 198.29,55.41 198.12,55.24 197.77,55.24 197.6,55.41 197.6,56.3 197.43,56.47 197.08,56.47 196.91,56.3 196.91,55.41 196.73,55.24 196.39,55.24 196.22,55.41 196.22,56.3 196.04,56.47 195.7,56.47 195.53,56.3 195.53,55.41 195.35,55.24 195.01,55.24 194.83,55.41 194.83,56.3 194.66,56.47 194.32,56.47 194.14,56.3 194.14,55.41 193.97,55.24 193.63,55.24 193.45,55.41 193.45,56.3 193.25,56.49 179.31,56.49 175.62,60.19
  IN3 w0.216: v2(234.26,55.89) 234.26,55.6 234.39,55.47 234.79,55.47 235.73,56.42 239.28,56.42 240.14,57.27 240.46,57.27 241.12,56.62 241.81,56.62 242.05,56.85 242.56,56.85 242.8,56.62 243.53,56.62 243.77,56.85 244.57,56.85 245.24,56.19 245.65,56.19 246.25,56.79 246.76,56.79 246.95,56.6 v2(246.95,56.4)
  BOTTOM w0.102: 170.86,61.54 170.47,61.54 170.32,61.68 166.36,61.68 166.12,61.45 165.54,61.45 165.41,61.58 165.01,61.58 164.72,61.29 164.72,61.09 164.52,60.89 164.08,60.89 163.74,61.23 UC1.AT22
  BOTTOM w0.163: 170.86,61.54 171.28,61.54 v2(172.38,60.44)
  BOTTOM w0.224: JDIMM1.121 246.58,56.78 v2(246.95,56.4) ; JDIMM3.121 232.5,56.78 232.87,56.41 233.86,56.41 234.26,56.01 v2(234.26,55.89)
DDR_A_MA10: length 106.1
  IN1 w0.102: 175.62,70.62 175.42,70.62 174.59,69.78 169.96,69.78 v2(169.81,69.94)
  IN1 w0.173: 175.62,70.62 187.29,70.62 190.47,67.43 201.63,67.43 202.65,66.42 203.86,66.42 204.03,66.59 204.03,67.26 204.2,67.43 204.55,67.43 204.72,67.26 204.72,66.59 204.89,66.42 205.74,66.42 206.17,65.98 212.11,65.98 212.28,66.16 212.28,66.46 212.45,66.63 212.8,66.63 212.97,66.46 212.97,66.16 213.14,65.98 213.42,65.98 214.07,66.63 233.1,66.63 233.87,65.86 237.29,65.86 237.42,65.99 237.42,66.75 237.32,66.85 235.43,66.85 235.32,66.97 235.32,67.34 v2(235.23,67.43)
  IN3 w0.216: v2(235.23,67.43) 235.32,67.34 235.32,67.22 236.48,66.06 238.76,66.06 239.07,65.75 246.27,65.75 246.52,65.5 247.67,65.5 248.13,65.05 v2(248.13,64.88)
  BOTTOM w0.102: UC1.AY14 167.72,69.23 169.1,69.23 v2(169.81,69.94)
  BOTTOM w0.224: JDIMM1.146 250.42,65.03 249.68,64.29 248.46,64.29 248.13,64.62 v2(248.13,64.88) ; v2(235.23,67.43) 235.32,67.34 235.32,67.02 236.6,65.73 237.9,65.73 238.6,65.03 JDIMM3.146
DDR_A_MA11: length 109
  IN1 w0.102: 175.62,59.48 174.66,60.44 v2(173.65,60.44)
  IN1 w0.173: v2(236.23,55.01) 236.23,54.93 235.85,54.55 220.33,54.55 220.18,54.39 216.96,54.39 216.78,54.57 216.78,54.81 216.61,54.98 216.27,54.98 216.09,54.81 216.09,54.57 215.92,54.39 211.14,54.39 210.82,54.71 207.37,54.71 207.16,54.91 193.13,54.91 192.95,55.09 192.95,56 192.78,56.17 192.44,56.17 192.26,56 192.26,55.09 192.09,54.91 191.75,54.91 191.57,55.09 191.57,56 191.4,56.17 191.05,56.17 190.88,56 190.88,55.09 190.71,54.91 190.36,54.91 190.19,55.09 190.19,56 190.02,56.17 189.67,56.17 189.5,56 189.5,55.09 189.33,54.91 188.98,54.91 188.81,55.09 188.81,56 188.64,56.17 188.29,56.17 188.12,56 188.12,55.09 187.95,54.91 187.6,54.91 187.43,55.09 187.43,56 187.25,56.17 178.93,56.17 175.62,59.48
  IN3 w0.216: v2(236.23,55.01) 236.23,55.3 236.47,55.55 239.98,55.55 240.18,55.75 244.44,55.75 244.92,55.28 248.06,55.28 249.55,56.76 v2(250.48,56.76)
  BOTTOM w0.102: UC1.AU22 164.41,61.34 164.41,61.59 164.61,61.79 165.6,61.79 165.67,61.72 166.02,61.72 166.21,61.91 170.86,61.91
  BOTTOM w0.163: 170.86,61.91 172.18,61.91 v2(173.65,60.44)
  BOTTOM w0.224: JDIMM1.120 252.34,56.53 252.04,56.23 251.01,56.23 v2(250.48,56.76) ; JDIMM3.120 237.63,56.53 236.23,55.13 v2(236.23,55.01)
DDR_A_MA12: length 103.6
  IN1 w0.102: v2(171.09,60.44) 171.09,60.93 171.28,61.12 175.15,61.12 175.62,60.65
  IN1 w0.173: v2(232.95,55.89) 232.95,56.16 232.8,56.31 232.33,56.31 232.16,56.14 232.16,55.53 231.99,55.35 231.64,55.35 231.47,55.53 231.47,56.14 231.29,56.31 230.87,56.31 230.72,56.17 230.72,55.48 230.59,55.35 229.85,55.35 229.67,55.53 229.67,55.96 229.5,56.13 229.15,56.13 228.98,55.96 228.98,55.53 228.81,55.35 227.67,55.35 227.5,55.53 227.5,55.96 227.33,56.13 226.98,56.13 226.81,55.96 226.81,55.53 226.64,55.35 223.67,55.35 223.49,55.53 223.49,55.96 223.32,56.13 222.97,56.13 222.8,55.96 222.8,55.53 222.63,55.35 220.31,55.35 219.53,56.13 218.09,56.13 217.92,55.96 217.92,55.8 217.75,55.63 217.4,55.63 217.23,55.8 217.23,55.96 217.06,56.13 216.71,56.13 216.54,55.96 216.54,55.8 216.37,55.63 216.02,55.63 215.85,55.8 215.85,55.96 215.68,56.13 215.33,56.13 215.16,55.96 215.16,55.8 214.99,55.63 214.64,55.63 214.47,55.8 214.47,55.96 214.29,56.13 214.02,56.13 213.45,55.57 211.91,55.57 211.71,55.36 207.64,55.36 207.43,55.57 200.25,55.57 199,56.82 181.37,56.82 181.16,57.02 181.16,57.53 180.88,57.82 180.63,57.82 179.66,56.85 179.42,56.85 179.17,57.09 179.17,57.34 180.14,58.31 180.14,58.55 179.9,58.8 179.66,58.8 178.68,57.82 178.44,57.82 178.2,58.07 178.2,58.31 179.17,59.28 179.17,59.53 178.81,59.89 178.64,59.89 177.65,58.9 177.36,58.9 175.62,60.65
  IN3 w0.216: v2(243.69,57.35) 243.69,57.63 243.45,57.87 242.22,57.87 241.99,57.63 241.55,57.63 241.32,57.87 240.11,57.87 239.1,56.85 235.36,56.85 235.08,56.56 232.92,56.56 232.74,56.39 232.74,56.11 v2(232.95,55.89)
  BOTTOM w0.102: 170.86,60.67 170.1,61.43 166.46,61.43 166.2,61.17 165.35,61.17 165.28,61.23 UC1.AV22
  BOTTOM w0.163: 170.86,60.67 v2(171.09,60.44)
  BOTTOM w0.224: JDIMM1.119 244.76,56.28 244.51,56.53 244.39,56.53 243.69,57.22 v2(243.69,57.35) ; v2(232.95,55.89) 232.72,55.89 232.34,56.28 JDIMM3.119
DDR_A_MA13: length 102.5
  IN1 w0.102: 175.62,74 172.4,74 172.06,74.34 168.33,74.34 v2(167.38,73.39)
  IN1 w0.173: 175.62,74 189.64,74 191.65,72 199.74,72 200.41,71.33 233,71.33 233.49,70.83 238.54,70.83 238.66,70.71 238.66,69.28 238.82,69.12 239.35,69.12 239.52,69.3 239.52,69.88 239.7,70.05 240.04,70.05 240.21,69.88 240.21,69.3 240.39,69.12 241.38,69.12 241.62,68.88 v2(241.62,68.4)
  IN3 w0.216: v2(241.62,68.4) 241.62,68.64 241.93,68.96 246.38,68.96 246.58,68.76 250.58,68.76 250.95,69.12 250.95,70.15 251.17,70.37 252.08,70.37 252.25,70.2 252.25,69.11 251.96,68.83 251.95,68.83 v2(251.78,68.66)
  BOTTOM w0.102: v2(167.38,73.39) 167.22,73.39 165.99,72.16 165.99,71.8 165.6,71.41 165.6,70.77 UC1.AV12
  BOTTOM w0.224: v2(241.62,68.4) 241.64,68.38 241.64,68.05 241.48,67.89 240.87,67.89 240.73,68.03 JDIMM3.158 ; JDIMM1.158 252.41,68.03 v2(251.78,68.66)
DDR_A_ODT0: length 83
  IN1 w0.102: v2(168.65,73.39) 169.32,74.06 171.75,74.06 172.27,73.55 175.62,73.55
  IN1 w0.135: 175.62,73.55 188.32,73.55 190.33,71.54 199.55,71.54 200.22,70.87 232.81,70.87 233.3,70.37 237.7,70.37 237.82,70.25 237.82,69.8 237.71,69.69 236.95,69.69 236.88,69.62 236.88,69.27 v2(236.88,69.26)
  BOTTOM w0.102: v2(168.65,73.39) 168.15,72.9 167.06,72.9 166.22,72.06 166.22,71.38 UC1.AW11
  BOTTOM w0.175: JDIMM3.155 232.57,67.28 233.39,68.1 236.18,68.1 236.88,68.8 v2(236.88,69.26)
DDR_A_ODT1: length 85.1
  IN1 w0.102: 175.62,72.87 174.32,72.87 174.01,72.57 171.4,72.57 171.19,72.78 v2(171.19,73.42)
  IN1 w0.135: 175.62,72.87 188.04,72.87 190.05,70.86 199.27,70.86 199.94,70.19 213.56,70.19 214.2,69.56 229.31,69.56 229.44,69.42 229.44,69.35 229.58,69.22 229.85,69.22 229.98,69.35 229.98,69.51 230.12,69.64 230.39,69.64 230.52,69.51 230.52,69.35 230.66,69.22 230.92,69.22 231.06,69.35 231.06,70.06 231.19,70.19 231.46,70.19 231.6,70.06 231.6,69.35 231.73,69.22 232,69.22 232.14,69.35 232.14,70.03 232.26,70.15 232.57,70.15 233.03,69.69 234.45,69.69 234.54,69.59 v2(234.54,69.26)
  BOTTOM w0.102: 170.86,73.75 170.25,74.36 166.77,74.36 163.82,71.41 163.82,69.02 UC1.AU14
  BOTTOM w0.163: 170.86,73.75 v2(171.19,73.42)
  BOTTOM w0.175: v2(234.54,69.26) 234.54,69.41 234.19,69.77 233.25,69.77 232.74,69.26 232.74,69.06 232.45,68.78 JDIMM3.161

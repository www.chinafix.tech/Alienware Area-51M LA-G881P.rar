# Allegro board Alienware Area-51M LA-G881P.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB20_N6: length 187.1
  TOP w0.094: v2(289.13,45.44) UH1.K7
  TOP w0.112: v2(185.04,137.48) 184.86,137.65 184.86,137.66 184.67,137.84 183.39,137.84 182.78,138.45 175.94,138.45 175.63,138.14 175.63,137.95 v2(176,137.59)
  IN1 w0.084: v2(289.13,45.44) 289.33,45.44 289.57,45.68 289.64,45.71 289.65,45.71 289.72,45.74 289.95,45.96 291.03,45.96 291.11,46.05 291.11,53.97 291.55,54.42 291.55,56.38 290.52,57.4 290.52,58.9 289.54,59.88 289.54,60.55 288.67,61.42 288.67,64.36 288.99,64.68 288.99,78.6 288.24,79.35 288.24,85.81 264.25,109.79 263.83,109.79 263.82,109.8 237.53,109.8 236.95,110.39 223.82,110.39 222.97,111.23 216.54,111.23 215.8,111.98 206.28,111.98 189.95,128.3 188.37,128.3 185.51,131.17 185.51,134.35 184.51,135.35 184.51,136.49 184.79,136.77 185.76,136.77 185.99,137 185.99,137.52 185.99,137.66 185.77,137.88 185.44,137.88 v2(185.04,137.48)
  BOTTOM w0.112: JDGFF1.H4 176.07,136.68 175.79,136.96 175.79,137.39 v2(176,137.59)
USB20_N7: length 185.1
  TOP w0.089: v2(292.92,47.87) 292.7,47.65 292.44,47.65 292.25,47.46 292.25,47.24 291.92,46.91 291.22,46.91 UH1.L4
  TOP w0.112: v2(174.24,137.18) 174.07,137.01 174.07,136.73 174.18,136.61 178.89,136.61 180.23,137.96 182.57,137.96 183.61,136.92 183.61,136.41 184.06,135.96 184.88,135.96 v2(185.08,136.16)
  IN1 w0.084: v2(292.92,47.87) 292.67,47.63 292.21,47.63 291.94,47.9 291.94,53.67 292.35,54.08 292.35,56.5 292.35,56.71 291.33,57.73 291.33,61.07 290.67,61.73 290.67,61.73 290.44,61.96 290.44,62.31 290.47,62.34 290.47,62.87 289.89,63.45 289.89,79.21 289.04,80.06 289.04,86.14 264.58,110.6 237.92,110.6 237.33,111.19 224.27,111.19 222.68,112.78 206.61,112.78 190.39,129 190.39,133.23 187.66,135.95 185.29,135.95 v2(185.08,136.16)
  BOTTOM w0.112: JDGFF1.H7 174.27,136.7 174.09,136.88 174.09,137.03 v2(174.24,137.18)
USB20_N8: length 114.8
  TOP w0.089: UH1.G4 290.77,44.29 290.66,44.39 290.66,44.56 290.79,44.69 290.87,44.69 291.11,44.45 291.67,44.45 291.73,44.51 291.75,44.51 292.06,44.51 292.08,44.53 292.08,44.54 292.22,44.68 292.48,44.68 292.58,44.58 292.72,44.58 293.01,44.3 293.43,44.3 v2(293.56,44.17)
  IN1 w0.084: v2(293.56,44.17) 293.61,44.22 294.09,44.22 294.38,44.51 297.48,44.51 297.82,44.86 300.12,44.86 301.09,43.89 301.09,38.85 301.61,38.32 301.61,34.07 301.99,33.7 301.99,30.26 302.24,30.01 302.24,29.43 302.46,29.21 302.46,25.67 303.02,25.11 303.02,24.24 304.13,23.13 304.13,19.36 308.14,15.35 310.21,15.35 310.67,14.89 319.52,14.89 321.18,13.23 328.25,13.23 329.23,12.24 333.49,12.24 336.39,15.14 338.67,15.14 339.43,15.9 343.91,15.9 346.32,18.3 348.24,18.3 349.4,17.14 353.37,17.14 358.7,22.47 369.6,22.47 v2(369.93,22.15)
  BOTTOM w0.112: v2(369.93,22.15) 370.12,22.34 372.39,22.34 372.6,22.13 LU5.1 372.66,22.07 RU125.1
USB20_N8_R: length 12.8
  BOTTOM w0.112: RU125.2 373.26,22.12 LU5.2 373.42,22.28 373.84,22.28 CU105.1 374.22,22.26 375.33,22.26 375.44,22.15 375.44,21.7 DU11.2 376.01,21.69 376.01,22.14 376.13,22.26 376.34,22.26 377.65,23.58 378.45,23.58 378.47,23.56 379.01,23.56 379.03,23.58 379.51,23.58 v4(380.02,23.08) 380.7,22.39 382.54,22.39 382.65,22.28 JUSB3.2
USB20_N9: length 25.2
  TOP w0.094: v2(289.62,46.64) 289.83,46.85 UH1.M6
  BOTTOM w0.112: v2(289.62,46.64) 290,46.64 290.11,46.53 290.11,45.98 291.17,44.92 291.17,41.93 290.54,41.3 v4(290.54,39.84) 290.54,38.12 290.98,37.68 295.17,37.68 295.62,38.12 296,38.12 296.14,37.98 296.14,37.95 296.53,37.57 296.56,37.57 296.73,37.39 298,37.39 299.11,38.51 299.11,41.1 298.41,41.8 298.41,42.16 298.17,42.4 297.81,42.4 RE647.1 LE3.1
USB20_N9_R: length 2.4
  BOTTOM w0.112: LE3.2 RE647.2 296.44,42.72 296.23,42.52 295.83,42.52 295.34,43 JTOBII.4
USB20_N10: length 91.9
  TOP w0.089: UH1.H3 291.46,45.2 291.89,45.2 291.94,45.25 291.96,45.25 291.99,45.28 292.55,45.28 292.72,45.45 294.23,45.45 297.22,42.46 297.22,39.63 297.43,39.43 297.43,39.19 297.44,39.17
  TOP w0.112: 297.44,39.17 297.44,39.17 297.44,39.12 v2(297.63,38.94)
  IN1 w0.084: v2(235.41,12.94) 235.64,13.17 236.06,13.17 246.11,23.22 250.72,23.22 255.5,28 261.04,28 261.16,27.88 269.9,27.88 270.34,27.45 272.43,27.45 273.85,26.02 277.79,26.02 278.2,25.61 283.41,25.61 284.91,24.12 285.97,24.12 287.47,25.61 290.29,25.61 291.85,27.17 291.85,30.86 296.76,35.77 296.76,37.08 297.5,37.82 297.5,38.81 v2(297.63,38.94)
  BOTTOM w0.112: v2(235.41,12.94) 235.23,13.12 234.66,13.12 LE7.4 234.51,12.97 RE200.1
USB20_N10_R: length 5.4
  BOTTOM w0.112: JPK.10 231.45,11.92 231.31,12.06 231.31,12.36 DK1.2 231.41,13.24 231.41,13.4 231.52,13.51 231.91,13.51 232.28,13.14 232.53,13.14 232.55,13.12 233.37,13.12 233.39,13.14 233.76,13.14 LE7.3 233.93,12.97 RE200.2
USB20_N11: length 345.3
  TOP w0.094: v2(287.52,48.54) 287.52,48.3 UH1.R10
  TOP w0.112: v2(40.47,41.46) 40.1,41.82 40.1,42.11 39.46,42.75 39.46,44.83 38.33,45.96 36.81,45.96 36.58,46.2 36.58,47.44 36.82,47.68 36.82,48.81 37.28,49.28 37.28,51.79 37.39,51.9 39.05,51.9 39.06,51.88 39.61,51.88 39.63,51.9 41.23,51.9 41.44,51.69 RT114.1
  IN1 w0.084: v2(40.47,41.46) 40.05,41.05 40.05,40.83 36,36.78 32.99,36.78 32.13,35.91 32.13,32.28 34.89,29.53 34.89,25.26 35.44,24.7 37.12,24.7 38,23.82 38,21.3 40.63,18.68 48.46,18.68 50.31,20.52 52.37,20.52 53.17,19.72 56.32,19.72 57.91,18.13 60.19,18.13 60.87,18.82 72.55,18.82 74.92,21.19 75.7,21.19 76.16,20.72 76.16,16.97 79.13,13.99 87.09,13.99 88.71,15.61 93.46,15.61 93.62,15.46 106.36,15.46 107.56,14.26 110.31,14.26 112.36,12.21 122.74,12.21 123.86,11.09 132.53,11.09 132.53,11.1 142,11.1 142.77,10.33 159.78,10.33 173.61,24.15 205.71,24.15 206.15,24.6 209.71,24.6 209.95,24.83 213.75,24.83 216.24,27.33 218.21,27.33 218.4,27.14 227.44,27.14 230.06,24.52 238,24.52 239.78,26.3 239.78,28.3 240.35,28.88 243.68,28.88 246.51,31.71 252.88,31.71 253.75,32.58 258.8,32.58 259.83,31.55 262.53,31.55 262.87,31.21 271.29,31.21 271.72,30.78 273.81,30.78 275.23,29.35 279.17,29.35 279.45,29.08 282.57,29.08 286.37,32.88 286.37,34.09 283.99,36.46 283.99,38.32 284,38.33 284,39.58 284.17,39.76 284.17,42.7 284.26,42.78 284.26,43.41 283.29,44.37 283.29,46.34 285.5,48.54 286.69,48.54 287.23,47.99 287.53,47.99 287.93,48.39 287.93,48.66 287.78,48.81 287.66,48.81 287.52,48.66 v2(287.52,48.54)
USB20_N11_R: length 9.2
  TOP w0.112: RT112.2 48.34,52.42 48.34,52.5 48.28,52.56 47.63,52.56 47.61,52.54 47.07,52.54 47.05,52.56 46.83,52.56 44.56,50.29 43.73,50.29 v2(43.51,50.09) 43.28,50.32 42.81,50.32 42.57,50.57 42.09,50.57 RT114.2
  BOTTOM w0.076: UT4.K5 43.29,49.09 43.54,49.34 43.54,49.73 43.46,49.81 43.46,49.88 43.43,49.9 43.43,50.01 v2(43.51,50.09)
USB20_N14: length 102.7
  TOP w0.089: v2(290.6,43.81) 290.55,43.76 290.43,43.76 UH1.E5
  IN1 w0.084: v2(345.63,32.16) 345.77,32.03 346.32,32.03 347.3,31.05 347.3,26.55 346.91,26.16 346.91,23.03 347.47,22.47 347.47,21.24 343.39,17.16 338.91,17.16 338.15,16.4 335.86,16.4 332.97,13.51 329.76,13.51 328.77,14.5 325.1,14.5 323.44,16.16 311.23,16.16 306.18,21.21 306.18,23.48 305.02,24.64 305.02,25.42 304.4,26.04 304.4,33.08 302.88,34.6 302.88,38.85 302.35,39.37 302.35,44.41 300.65,46.12 295.48,46.12 295.16,45.8 294.06,45.8 294.06,45.8 293.6,45.8 292.5,45.8 290.6,43.9 v2(290.6,43.81)
  BOTTOM w0.112: JWLAN.5 343.44,33.85 343.58,33.71 343.91,33.71 344.12,33.5 344.29,33.33 344.29,32.83 344.96,32.16 v2(345.63,32.16)
USB20_P1: length 303.8
  TOP w0.089: UH1.J2 291.78,45.63 291.81,45.66 291.83,45.66 291.86,45.69 292.34,45.69 292.47,45.82 294.68,45.82 297.59,42.9 297.59,40.13 297.65,40.07 297.73,40.07 v2(297.8,40.13)
  TOP w0.112: UU1.3 37.34,16 37.48,15.86 38.25,15.86 38.33,15.78 39.23,15.78 39.25,15.76 39.54,15.76 40.37,14.93 40.37,14.29 40.39,14.27 v4(40.39,13.99) 40.39,13.72 40.37,13.7 40.37,13.22 v2(40.58,13.02)
  IN1 w0.084: v2(297.8,40.13) 297.72,40.05 297.51,40.05 297.43,39.97 297.43,39.8 297.34,39.72 297.14,39.72 296.93,39.92 296.21,39.92 295.66,39.37 293.39,39.37 292.44,38.42 290.47,38.42 289.04,36.99 289.04,31.97 283.48,26.41 278.53,26.41 278.12,26.82 274.18,26.82 272.76,28.25 270.67,28.25 270.24,28.68 261.49,28.68 261.37,28.8 256.43,28.8 255.87,29.35 255.05,29.35 253.89,28.19 253.89,27.52 250.39,24.02 243.17,24.02 240.33,21.18 228.66,21.18 227.57,22.27 213.95,22.27 213.31,21.62 190.83,21.62 184.39,15.18 168.6,15.18 161.21,7.8 131.33,7.8 130.74,8.38 122.99,8.38 121.69,9.68 115.95,9.68 115.42,9.14 111.66,9.14 109.07,11.73 106.51,11.73 105.34,12.89 99.52,12.89 98.44,11.81 97.28,11.81 93.14,7.67 88.14,7.67 85.1,10.72 69.02,10.72 66.03,13.71 62.62,13.71 61.89,12.97 48.3,12.97 47.24,14.03 45.17,14.03 43.45,12.32 40.28,12.32 40.16,12.43 40.16,12.61 40.25,12.7 40.55,12.7 40.63,12.78 40.63,12.97 v2(40.58,13.02)
USB20_P2: length 138.8
  TOP w0.094: v2(285.46,46.76) UH1.N15
  IN1 w0.084: v2(285.46,46.76) 285.54,46.76 285.63,46.68 285.63,46.37 285.79,46.21 285.99,46.21 286.02,46.19 286.98,46.19 287.78,45.38 287.78,44.99 287.97,44.8 287.97,44.23 289.85,42.35 290.92,42.35 291.14,42.12 294.14,42.12 295.01,42.99 298.66,42.99 300.46,41.19 300.46,38.58 300.98,38.06 300.98,33.81 301.27,33.52 301.27,29.91 300.95,29.58 300.95,26.29 302.39,24.84 302.39,23.72 303.17,22.94 303.17,18.31 304.54,16.94 305.43,16.94 307.66,14.71 309.64,14.71 310.7,13.66 319.01,13.66 321.05,11.61 333.76,11.61 336.61,14.46 338.95,14.46 339.75,15.26 344.27,15.26 346.61,17.6 348.05,17.6 349.14,16.51 353.63,16.51 357.66,20.54 366.94,20.54 367.82,21.42 370,21.42 370.68,22.1 370.68,38.2 370.5,38.38 370.17,38.38 v2(369.96,38.59)
  BOTTOM w0.112: v2(369.96,38.59) 370.14,38.41 370.45,38.41 371.36,39.31 371.89,39.31 LU4.4 372.03,39.51 RU124.1
USB20_P2_R: length 13.9
  BOTTOM w0.112: RU124.2 372.62,39.46 LU4.3 372.73,39.35 373.48,39.35 CU104.2 373.96,39.53 374.1,39.39 374.36,39.39 374.5,39.25 374.94,39.25 375.06,39.36 375.06,39.9 DU10.3 375.5,39.86 375.5,39.35 375.61,39.23 375.85,39.23 377.82,41.2 377.82,41.23 378.24,41.65 378.27,41.65 378.9,42.28 379.23,42.61 v4(379.51,42.61) 382.54,42.61 382.65,42.72 JUSB2.3
USB20_P3: length 252.1
  TOP w0.089: UH1.K3 291,45.99 290.92,46.07 290.92,46.16 290.99,46.22 291.4,46.22 291.55,46.07 292.2,46.07 292.61,46.49 293.09,46.49 293.33,46.73 293.76,46.73 v2(293.99,46.96)
  TOP w0.112: v2(176.89,186.29) 176.7,186.11 175.19,186.11 173.79,187.51 169.08,187.51 167.14,185.57 164.88,185.57 164.08,186.36 163.29,186.36 163.04,186.62 163.04,186.93 163.15,187.04 163.39,187.04 163.49,187.15 163.49,187.34 LM1.4
  IN1 w0.084: v2(293.99,46.96) 293.81,46.78 293.62,46.78 293.51,46.89 293.51,47.13 294.29,47.91 294.29,49.36 294.78,49.85 294.78,51.31 294.5,51.59 294.5,53.28 293.62,54.17 293.62,55.43 294.41,56.22 294.92,56.22 295.17,56.47 295.17,57.11 294.32,57.96 294.32,59 294.23,59.09 294.23,59.18 292.61,60.79 292.61,63.17 291.25,64.53 291.25,70.13 292,70.88 292,75.96 291.23,76.72 291.23,79.65 290.3,80.59 290.3,86.67 265.1,111.87 238.72,111.87 236.52,114.07 207.11,114.07 191.69,129.49 191.69,133.86 188.75,136.8 188.75,141.21 184.97,144.99 184.97,145.62 184.2,146.39 184.2,146.86 183.66,147.4 183.66,154.63 181.19,157.09 181.19,159.26 175.71,164.74 175.71,166.27 175.69,166.29 175.69,168.15 176.32,168.78 179.26,168.78 181.09,170.61 181.09,175.69 180.23,176.54 180.23,177.23 180.12,177.35 180.12,179.16 180.3,179.34 180.3,181.99 179.48,182.81 179.48,184.75 178.14,186.09 177.09,186.09 v2(176.89,186.29)
USB20_P3_R: length 4.8
  TOP w0.112: LM1.3 163.18,188.25 163.18,188.71 163.2,188.73 163.2,189.27 163.18,189.29 163.18,189.52 v4(163.83,190.17) 164.46,190.8 164.46,191.38 164.55,191.47 JCDRA.39
USB20_P4: length 112.6
  TOP w0.089: v2(288.04,46.6) 288.19,46.6 UH1.L9
  TOP w0.112: UE1.33 359.82,29.31 359.66,29.16 359.66,28.68 v2(359.84,28.51)
  IN1 w0.084: v2(288.04,46.6) 288.35,46.57 288.43,46.48 288.43,45.36 288.63,45.16 288.63,44.54 289.84,43.34 290.28,43.34 290.37,43.25 291.13,43.25 293.05,45.17 293.94,45.17 295.42,45.17 295.74,45.49 300.39,45.49 301.72,44.15 301.72,39.11 302.25,38.58 302.25,34.34 302.63,33.96 302.63,30.52 302.87,30.28 302.87,29.69 303.09,29.47 303.09,26.14 304.38,24.85 304.38,24.38 305.11,23.65 305.11,21.34 310.93,15.52 323.17,15.52 324.83,13.86 328.51,13.86 329.49,12.88 333.23,12.88 336.12,15.77 338.41,15.77 339.17,16.53 343.65,16.53 346.05,18.93 348.51,18.93 349.67,17.77 353.1,17.77 357.48,22.15 357.48,27.05 358.33,27.9 359.44,27.9 359.63,28.09 359.63,28.3 v2(359.84,28.51)
USB20_P6: length 187.2
  TOP w0.094: v2(289.67,45.2) 289.67,45.5 UH1.K6
  TOP w0.112: v2(185.04,138.06) 183.48,138.06 182.87,138.67 175.85,138.67 175.41,138.23 v2(175.41,137.59)
  IN1 w0.084: v2(185.04,138.06) 185.05,138.05 185.84,138.05 186.16,137.73 186.16,137.45 186.16,136.93 185.83,136.6 184.86,136.6 184.68,136.42 184.68,135.42 185.67,134.42 185.67,131.24 188.44,128.47 190.02,128.47 206.35,112.15 215.87,112.15 216.61,111.4 223.04,111.4 223.89,110.56 237.01,110.56 237.6,109.97 263.89,109.97 263.9,109.96 264.32,109.96 288.4,85.88 288.4,79.42 289.16,78.67 289.16,64.61 288.84,64.29 288.84,61.49 289.71,60.62 289.71,59.95 290.69,58.97 290.69,57.47 291.72,56.45 291.72,54.35 291.28,53.9 291.28,45.98 291.09,45.79 290.02,45.79 289.82,45.6 289.71,45.55 289.71,45.54 289.64,45.51 289.64,45.23 v2(289.67,45.2)
  BOTTOM w0.112: JDGFF1.H5 175.47,136.67 175.57,136.77 175.57,137.43 v2(175.41,137.59)
USB20_P7: length 185.2
  TOP w0.089: v2(292.92,47.29) 292.73,47.47 292.52,47.47 292.43,47.38 292.43,47.17 292,46.73 291.3,46.73 291.25,46.69 291.25,46.56 UH1.L3
  TOP w0.112: v2(173.66,137.18) 173.84,137 173.84,136.63 174.09,136.39 178.98,136.39 180.32,137.74 182.48,137.74 183.39,136.83 183.39,136.32 183.97,135.74 184.92,135.74 v2(185.08,135.58)
  IN1 w0.084: v2(292.92,47.29) 292.75,47.46 292.14,47.46 291.77,47.83 291.77,53.74 292.18,54.15 292.18,56.57 292.18,56.64 291.16,57.66 291.16,61 290.5,61.66 290.5,61.66 290.27,61.89 290.27,62.38 290.3,62.41 290.3,62.8 289.72,63.38 289.72,79.14 288.87,79.99 288.87,86.07 264.51,110.43 237.85,110.43 237.27,111.02 224.2,111.02 222.61,112.61 206.54,112.61 190.22,128.93 190.22,133.16 187.6,135.79 185.29,135.79 v2(185.08,135.58)
  BOTTOM w0.112: v2(173.66,137.18) 173.85,136.99 173.85,136.83 173.67,136.65 JDGFF1.H8
USB20_P8: length 114.8
  TOP w0.089: UH1.G5 290.71,44.88 290.94,44.88 291.19,44.63 291.59,44.63 291.66,44.69 291.68,44.69 291.98,44.69 292.15,44.86 292.55,44.86 292.65,44.76 292.79,44.76 293.08,44.47 293.27,44.47 293.37,44.57 v2(293.56,44.76)
  IN1 w0.084: v2(369.93,22.73) 369.84,22.64 358.63,22.64 353.3,17.31 349.47,17.31 348.31,18.47 346.25,18.47 343.84,16.06 339.37,16.06 338.61,15.3 336.32,15.3 333.43,12.41 329.3,12.41 328.32,13.4 321.25,13.4 319.59,15.06 310.74,15.06 310.28,15.51 308.21,15.51 304.3,19.43 304.3,23.2 303.19,24.31 303.19,25.18 302.62,25.74 302.62,29.28 302.4,29.5 302.4,30.08 302.16,30.33 302.16,33.77 301.78,34.14 301.78,38.39 301.26,38.92 301.26,43.96 300.19,45.02 297.75,45.02 297.41,44.68 294.31,44.68 294.02,44.39 293.93,44.39 v2(293.56,44.76)
  BOTTOM w0.112: RU126.1 372.66,22.68 LU5.4 372.6,22.56 370.1,22.56 v2(369.93,22.73)
USB20_P8_R: length 12.8
  BOTTOM w0.112: JUSB3.3 382.65,22.72 382.54,22.61 380.79,22.61 380.38,23.03 380.38,23.05 379.99,23.44 379.97,23.44 379.6,23.8 v4(378.74,23.8) 377.56,23.8 376.25,22.49 376.06,22.49 375.94,22.6 375.94,23.12 DU11.3 375.5,23.11 375.5,22.6 375.39,22.49 374.22,22.49 CU105.2 373.87,22.5 373.39,22.5 LU5.3 373.26,22.63 RU126.2
USB20_P9: length 25.2
  TOP w0.094: v2(289.04,46.74) UH1.N8
  BOTTOM w0.112: LE3.4 297.35,42.06 RE648.1 297.73,42.18 298.08,42.18 298.19,42.07 298.19,41.71 298.89,41.01 298.89,38.6 297.9,37.62 296.82,37.62 v4(296.51,37.93) 296.09,38.34 295.53,38.34 295.08,37.9 291.07,37.9 290.76,38.22 290.76,39.55 290.78,39.57 290.78,40.11 290.76,40.13 290.76,41.21 291.39,41.84 291.39,45.01 290.33,46.07 290.33,46.62 290.09,46.86 289.98,46.86 289.79,47.05 289.36,47.05 v2(289.04,46.74)
USB20_P9_R: length 2.4
  BOTTOM w0.112: LE3.3 296.6,41.93 RE648.2 296.51,41.93 296.15,42.3 295.78,42.3 295.49,42 JTOBII.3
USB20_P10: length 91.8
  TOP w0.089: 297.22,39.17 297.22,39.18 297.25,39.21 297.25,39.36 297.05,39.56 297.05,42.39 294.16,45.27 292.8,45.27 292.62,45.1 292.06,45.1 291.97,45.01 291.77,45.01 UH1.H2
  TOP w0.112: v2(297.04,38.94) 297.22,39.12 297.22,39.17
  IN1 w0.084: v2(235.3,13.73) 235.23,13.67 235.23,13.42 235.32,13.34 235.99,13.34 246.04,23.39 250.65,23.39 255.43,28.16 261.11,28.16 261.23,28.05 269.97,28.05 270.41,27.61 272.5,27.61 273.92,26.19 277.86,26.19 278.27,25.78 283.48,25.78 284.98,24.28 285.9,24.28 287.4,25.78 290.22,25.78 291.68,27.24 291.68,30.93 296.59,35.84 296.59,37.15 297.34,37.89 297.34,38.38 297.25,38.47 296.91,38.47 296.83,38.55 296.83,38.72 v2(297.04,38.94)
  BOTTOM w0.112: v2(235.3,13.73) 235.3,13.45 235.19,13.34 234.66,13.34 LE7.1 234.51,13.49 RE202.1
USB20_P10_R: length 5.6
  BOTTOM w0.112: JPK.11 230.95,11.92 231.09,12.06 231.09,12.56 DK1.3 231.19,13.24 231.19,13.49 231.43,13.73 232,13.73 232.37,13.36 v4(232.95,13.36) 233.79,13.36 LE7.2 233.93,13.49 RE202.2
USB20_P11: length 345.3
  TOP w0.094: UH1.P9 288.45,48.13 v2(288.31,48.27)
  TOP w0.112: v2(39.88,41.46) 39.88,42.02 39.24,42.66 39.24,44.74 38.23,45.74 36.72,45.74 36.35,46.11 36.35,47.53 36.6,47.77 36.6,48.91 37.06,49.37 37.06,51.88 37.3,52.12 v4(39.34,52.12) 41.32,52.12 41.6,51.84 RT115.1
  IN1 w0.084: v2(39.88,41.46) 39.88,40.9 35.93,36.94 32.92,36.94 31.96,35.98 31.96,32.21 34.72,29.46 34.72,25.19 35.37,24.53 37.05,24.53 37.83,23.75 37.83,21.23 40.56,18.51 48.53,18.51 50.38,20.35 52.3,20.35 53.1,19.55 56.25,19.55 57.84,17.97 60.26,17.97 60.94,18.65 72.62,18.65 74.99,21.02 75.63,21.02 75.99,20.66 75.99,16.9 79.06,13.83 87.16,13.83 88.78,15.44 93.39,15.44 93.55,15.29 106.29,15.29 107.49,14.09 110.24,14.09 112.29,12.04 122.67,12.04 123.79,10.93 132.6,10.93 132.6,10.93 141.93,10.93 142.7,10.16 159.85,10.16 173.68,23.98 205.78,23.98 206.22,24.43 209.78,24.43 210.02,24.67 213.82,24.67 216.31,27.16 218.14,27.16 218.33,26.97 227.37,26.97 229.99,24.36 238.07,24.36 239.94,26.23 239.94,28.23 240.42,28.71 243.75,28.71 246.58,31.54 252.95,31.54 253.82,32.41 258.73,32.41 259.76,31.38 262.46,31.38 262.8,31.04 271.22,31.04 271.65,30.61 273.74,30.61 275.16,29.19 279.1,29.19 279.38,28.91 282.64,28.91 286.53,32.81 286.53,34.15 284.16,36.53 284.16,38.25 284.16,38.26 284.16,39.51 284.34,39.69 284.34,42.63 284.42,42.71 284.42,43.48 283.46,44.44 283.46,46.27 285.57,48.37 286.62,48.37 287.16,47.83 287.6,47.83 288.04,48.27 v2(288.31,48.27)
USB20_P11_R: length 9
  TOP w0.112: 42.72,51.19 42.72,51.19 42.72,50.72 42.9,50.54 43.36,50.54 v2(43.54,50.72) 43.73,50.51 44.47,50.51 46.74,52.78 v4(47.34,52.78) 48.43,52.78 RT113.2
  BOTTOM w0.076: UT4.L5 43.29,49.74 43.29,49.75 43.29,49.81 43.16,49.94 43.16,50.29 43.54,50.67 v2(43.54,50.72)
USB20_P14: length 102.7
  TOP w0.089: UH1.F6 290.02,44.05 v2(290.12,44.14)
  IN1 w0.084: v2(290.12,44.14) 290.37,44.14 290.44,44.21 290.68,44.21 292.44,45.97 293.53,45.97 293.53,45.97 294.13,45.97 295.09,45.97 295.41,46.29 300.72,46.29 302.52,44.48 302.52,39.44 303.05,38.92 303.05,34.67 304.57,33.15 304.57,26.11 305.18,25.49 305.18,24.71 306.35,23.55 306.35,21.28 311.3,16.32 323.51,16.32 325.17,14.66 328.84,14.66 329.83,13.68 332.9,13.68 335.79,16.57 338.08,16.57 338.84,17.33 343.32,17.33 347.3,21.31 347.3,22.4 346.74,22.96 346.74,26.23 347.13,26.62 347.13,30.98 346.25,31.86 345.92,31.86 v2(345.63,31.58)
  BOTTOM w0.112: v2(345.63,31.58) 345.27,31.94 344.87,31.94 344.07,32.74 344.07,33.24 343.82,33.49 343.6,33.49 343.46,33.35 JWLAN.3
USB_OC0#: length 305
  TOP w0.089: v2(263.45,56.89) 263.42,56.89 263.36,56.83 RPH6.4 262.55,56.83 262.2,57.17 260.7,57.17 260.32,56.79 260.32,56.61 260.2,56.49 ; UH1.AH36 274.82,54.77 274.42,55.17 274.42,56.24 275.15,56.98 275.15,57.06 275.66,57.57 v2(275.78,57.57)
  TOP w0.112: v2(34.36,8.99) 34.36,13.35 34.68,13.68 UU1.13 ; 260.2,56.49 v1(259.27,55.56) 258.6,54.89 v2(258.6,54.84)
  IN3 w0.127: v2(275.78,57.57) 275.28,58.07 273.92,58.07 273.42,57.57 264.13,57.57 v2(263.45,56.89)
  IN4 w0.084: v2(56.1,19.15) 56.1,19.15 57.79,19.15 58.54,18.41 82.38,18.41 83.16,17.63 86.88,17.63 88.1,18.85 90.84,18.85 91.15,18.55 96.9,18.55 99.19,16.26 106.69,16.26 107.43,17.01 107.72,17.01 108.74,15.99 110.18,15.99 112.62,13.55 117.34,13.55 118.19,12.7 122.68,12.7 124.7,10.67 132.05,10.67 132.62,10.1 134.82,10.1 135.1,10.38 135.1,10.74 135.29,10.93 140.45,10.93 141.05,10.33 142.77,10.33 143.3,9.79 168.77,9.79 169.1,9.46 181.88,9.46 188.33,15.92 200.72,15.92 200.83,15.81 239.96,15.81 245.47,21.32 250.47,21.32 253.41,24.25 256.34,24.25 256.53,24.45 256.53,26.34 256.8,26.62 256.8,47.31 259.02,49.53 259.02,54.41 v2(258.6,54.84)
  BOTTOM w0.112: v2(56.1,19.15) 55.09,19.15 54.77,18.82 54.77,9.1 54.35,8.69 34.66,8.69 v2(34.36,8.99)
USB_OC1#: length 207.6
  TOP w0.089: RPH6.3 263.66,56.33 264.06,56.73 264.06,56.73 ; 264.06,56.73 v2(264.06,56.73) ; 264.06,56.73 v1(264.69,56.73) ; UH1.AL40 273.36,56.16 273.21,56.31 v2(273.21,56.76)
  TOP w0.112: CU17.1 377.52,41 UU3.3 375.45,41 v2(375.08,41.37)
  IN3 w0.104: v2(347.94,25) 347.56,24.63 347.56,21.04 346.55,20.04 339.03,20.04 337.89,21.18 337.89,22.44 336.88,23.44 333.92,23.44 331.25,20.77 330.48,20.77 329.16,20.77 328.07,19.68 314.31,19.68 311.19,22.81 310.57,22.81 309.79,23.59 309.79,23.64 309.01,24.42 306.96,24.42 304.6,26.78 303.57,26.78 302.18,28.17 301.15,28.17 300.31,29.01 299.84,29.01 299.81,29.04 296.98,31.87 295.65,31.87 295.65,31.87 294.88,31.87 293.11,33.64 291.39,33.64 288.18,36.86 288.18,42.23 287.34,43.07 287.34,47.46 286.34,48.46 286.34,50.36 288.02,52.04 288.02,53.79 289.86,55.63 289.86,55.97 289.47,56.36 289.28,56.36 288.23,57.41 288.23,58.37 286.7,59.91 286.7,59.94 285.3,61.34 284.55,61.34 283.82,60.6 282.23,60.6 282.09,60.74 281.4,60.74 280.65,59.99 280.65,57.39 279.68,56.42 274.97,56.42 274.28,57.11 273.56,57.11 v2(273.21,56.76) ; v2(375.08,41.37) 374.2,42.25 374.2,43.93 372.97,45.16 372.97,50.09 373.96,51.08 373.96,52.93 371.91,54.99 354.96,54.99 353.21,53.24 353.21,48.15 350.32,45.26 348.12,45.26 344.81,41.95 344.81,40.61 343.34,39.14 343.34,30.11 342.29,29.06 v2(342.16,29.06)
  IN3 w0.127: v2(264.06,56.73) 264.06,56.73 264.64,57.32 272.65,57.32 v2(273.21,56.76)
  IN4 w0.084: v2(342.16,29.06) 342.75,28.47 343.96,28.47 347.07,25.36 347.58,25.36 v2(347.94,25)
USB_OC2#: length 13.1
  TOP w0.089: v1(260.23,54.72) 260.47,54.96 262.16,54.96 262.54,55.33 RPH6.1 263.26,55.33 v2(263.45,55.14) ; UH1.AJ44 v2(271.53,55.73)
  IN3 w0.127: v2(263.45,55.14) 263.63,55.32 265.04,55.32 265.61,55.89 267.46,55.89 267.85,55.5 269.43,55.5 270.01,56.08 271.3,56.08 271.53,55.85 v2(271.53,55.73)
USB_OC3#: length 15.1
  TOP w0.089: UH1.AL41 273.13,55.75 v2(273.13,55.4) ; RPH6.2 263.41,55.83 263.5,55.74 v2(263.5,55.72) 263.8,55.72 263.98,55.9 265.52,55.9 v1(265.9,56.28)
  IN3 w0.127: v2(273.13,55.4) 272.19,56.34 269.91,56.34 269.32,55.75 267.96,55.75 267.57,56.15 265.5,56.15 265.11,55.75 263.53,55.75 v2(263.5,55.72)
USB_PWR_EN1: length 103.3
  TOP w0.112: v2(369.22,37.33) 370.15,37.33 370.59,37.77 370.59,38.21 CU16.1 373.38,41 UU3.4 ; UE5.51 300.34,9.02 300.6,8.76 v2(300.6,8.59) 300.6,8 301.03,7.57 RE645.1 v1(301.03,5.88)
  IN1 w0.084: v2(317.25,3.5) 313.7,7.05 301.95,7.05 301.62,7.38 301.62,8.46 301.49,8.59 v2(300.6,8.59)
  BOTTOM w0.112: v2(369.22,37.33) 363.27,37.33 361.22,35.27 361.22,33.93 357.46,30.17 349.84,30.17 342.85,23.18 342.85,14.24 340.72,12.11 340.72,10.15 334.07,3.5 v2(317.25,3.5)
USBCHG_DET#: length 38.1
  TOP w0.254: DU6.2 12.62,32.64 13.06,32.21 CU28.1 13.94,31.75 RU4.2 14.25,31.7 14.88,31.06 16.28,31.06 16.81,31.6 v2(16.81,32.03) ; CU27.2 v2(18.36,35.58)
  IN4 w0.254: v2(16.81,32.03) 17.11,32.32 17.94,32.32 19.22,31.04 19.22,27.44 22.83,23.84 22.83,17.52 22.43,17.12 15.09,17.12 JUSB1.10
  BOTTOM w0.254: v2(16.81,32.03) 18.36,33.58 v1(18.36,34.25) v2(18.36,35.58)
USBCHG_DET_D: length 356.7
  TOP w0.112: UU5.4 13.88,35.04 13.54,35.38 13.54,36.44 13.43,36.55 12.01,36.55 RU6.1 15.04,37.23 v2(15.6,36.68) ; v2(321.38,13.83) 321.68,13.83 322.27,14.42 PD301.3
  IN3 w0.104: v2(15.6,36.68) 15.9,36.37 15.9,35.1 19.73,31.27 19.73,27.24 20.59,26.38 20.59,21.55 23.59,18.55 23.59,14.83 26.12,12.29 36.1,12.29 37.29,13.48 37.29,13.94 37.7,14.35 43.1,14.35 47.07,10.38 49.51,10.38 50.33,11.21 60.2,11.21 61.24,10.17 63.08,10.17 66.28,6.97 76.4,6.97 77.27,7.84 77.89,7.84 78.08,7.84 78.71,7.2 80.04,7.2 81.35,8.51 81.74,8.51 81.74,8.51 88.03,8.51 88.8,7.75 93.46,7.75 95.92,10.2 108.98,10.2 111.98,7.2 119.8,7.2 120.73,6.27 123.75,6.27 124.44,6.96 139.82,6.96 140.09,6.7 166.58,6.7 167.26,6.01 185.87,6.01 190.49,10.63 195.73,10.63 196.87,9.48 223.42,9.48 224.21,8.69 240.08,8.69 244.72,13.32 245.8,13.32 246.16,12.96 248.91,12.96 249.66,12.22 250.1,12.22 250.55,12.66 251.68,12.66 252.58,13.56 255.6,13.56 256.35,12.81 260.81,12.81 268.72,20.72 282.19,20.72 287.88,15.03 291.88,15.03 292.29,15.44 294.35,15.44 295.13,14.66 320.55,14.66 v2(321.38,13.83)
USBCHG_DET_EC#: length 338.4
  TOP w0.112: DU6.1 11.36,35.54 CU29.1 RU6.2 v2(10.44,36.32) ; UE5.75 v2(305.44,15.48)
  IN3 w0.104: v2(305.44,15.48) 304.85,14.89 295.23,14.89 294.44,15.67 292.2,15.67 291.78,15.26 287.98,15.26 282.28,20.95 268.62,20.95 260.72,13.04 256.44,13.04 255.68,13.8 252.46,13.8 251.55,12.89 250.24,12.89 249.81,13.32 249.47,13.32 249.34,13.19 246.26,13.19 245.9,13.55 244.62,13.55 239.99,8.92 224.31,8.92 223.51,9.71 196.97,9.71 195.83,10.86 190.39,10.86 185.78,6.24 167.36,6.24 166.67,6.93 140.18,6.93 139.92,7.19 124.34,7.19 123.65,6.5 120.83,6.5 119.89,7.43 112.08,7.43 109.08,10.43 95.82,10.43 93.37,7.98 88.89,7.98 88.13,8.74 81.83,8.74 81.26,8.74 79.95,7.43 78.81,7.43 78.31,7.93 78.17,8.07 77.17,8.07 77.04,7.93 76.31,7.2 66.51,7.2 62.28,11.44 47.76,11.44 47.14,12.06 45.72,12.06 43.2,14.58 37.61,14.58 37.06,14.03 37.06,13.58 36,12.52 26.22,12.52 23.82,14.92 23.82,18.65 20.82,21.64 20.82,26.5 19.98,27.34 19.98,31.99 v2(16.38,35.59)
  BOTTOM w0.112: v2(10.44,36.32) 10.52,36.24 v1(12.6,36.24) 15.72,36.24 v2(16.38,35.59)
VCIN0_PH1: length 214.7
  TOP w0.112: v2(300.73,24.15) 300.74,24.16 UE5.109 ; v2(305.68,23.33) 305.68,23.35 306.08,23.76 306.08,24.28 308.51,26.71 308.51,27.26 309.1,27.85 PR24.1
  TOP w0.254: PH1.1 155.21,55.66 155.74,55.13 156.5,55.13 156.8,54.83 156.8,53.12 156.98,52.94 156.98,46.4 158.08,45.3 164.24,45.3 165.75,46.81 166.84,46.81 167.11,46.54 167.11,46.41 v1(174.8,38.72) 179.48,34.05 179.48,30.95 v2(179.03,30.5)
  IN3 w0.104: v2(177.44,12.41) 178.21,11.64 186.27,11.64 188.89,14.25 226.43,14.25 227.65,15.47 231.29,15.47 231.95,16.12 236.53,16.12 238.57,18.16 258.48,18.16 267.45,27.13 284.81,27.13 285.3,26.64 286.75,26.64 287.51,25.88 289.73,25.88 290.99,24.63 292.73,24.63 294.01,23.34 295.27,23.34 295.6,23.67 295.6,24.35 296.04,24.79 299.35,24.79 299.59,24.56 300.24,24.56 300.64,24.15 v2(300.73,24.15) 301.35,24.15 302.59,25.39 303.85,25.39 305.7,23.55 305.7,23.4 305.68,23.38 v2(305.68,23.33)
  BOTTOM w0.112: v2(300.73,24.15) 300.86,24.29 PR25.1 ; v2(179.03,30.5) 178.52,31.01 176.67,31.01 175.05,29.39 175.05,14.8 v2(177.44,12.41)
VCIN1_AC_IN: length 448.2
  TOP w0.112: v2(269.8,75.06) v3(269.8,74.43) 269.8,73.35 270.05,73.09 DH1.1 ; v2(301.84,29.85) 302.01,29.68 302.01,28.27 CE40.2 301.53,27.46 300.84,26.77 300.74,26.77 300.34,26.37 UE5.110
  TOP w0.127: QE3.5 351.33,38.27 v2(351.5,38.44)
  TOP w0.203: PU703.2 209.87,138.98 v2(209.92,138.92) 209.92,138.61 210.22,138.32 PR731.1
  TOP w0.254: PQS29.5 122.54,153.07 122.78,153.32 v2(122.78,153.54) ; PQS30.5 156.99,146.57 157.24,146.31 161.97,146.31 165.62,149.97 165.62,155.03 162.69,157.96 159.02,157.96 v2(157.92,156.86)
  IN1 w0.084: v2(269.8,75.06) 270.05,74.81 270.84,74.81 270.84,74.82 275.43,74.82 275.87,74.38 275.87,69.49 277.03,68.33 277.03,64.29 276.38,63.63 276.38,61.5 275.76,60.88 275.76,59.09 v2(275.36,58.7)
  IN2 w0.104: v2(122.78,153.54) 120.35,153.54 119.7,154.19 119.7,156.57 120.59,157.46 148.88,157.46 151.87,154.47 157.43,154.47 158.7,155.74 158.7,156.16 158,156.86 v2(157.92,156.86)
  IN3 w0.104: v2(270.07,78.45) 271.65,80.02 274.85,80.02 276.62,81.79 277.43,81.79 278.17,82.53 278.17,85.5 276.16,87.52 276.16,97.07 275.52,97.7 275.52,102.56 269.84,108.23 263.34,108.23 259.54,112.04 237.72,112.04 236.8,111.11 233.51,111.11 232.71,110.31 220.01,110.31 219.55,110.77 215.76,110.77 214.78,111.75 209.72,111.75 207.82,109.85 205.48,109.85 204.19,111.14 204.19,114.8 204.92,115.53 204.92,125.64 208.23,128.96 208.23,132.23 208.91,132.9 208.91,135.73 209.92,136.75 v2(209.92,138.92) 209.92,141.55 207.39,144.09 198,144.09 193.46,148.62 185.41,148.62 184.86,149.17 183.14,149.17 178.88,153.42 177.75,153.42 177.28,152.96 177.28,152 177.03,151.75 165.86,151.75 160.75,156.86 v2(157.92,156.86) ; v2(275.36,58.7) 275.46,58.59 275.61,58.59 276.93,58.59 277.14,58.8 277.14,59.59 277.75,60.2 278.71,60.2 278.95,60.44 278.95,60.78 278.56,61.16 278.56,62.91 278.7,63.04 288.18,63.04 288.67,62.56 288.67,61.44 290.35,59.75 290.35,57.61 291.54,56.42 291.54,53.49 290.9,52.85 290.04,52 290.04,51.52 291.33,50.23 291.33,35.77 292.3,34.8 293.59,34.8 293.73,34.66 295.36,33.03 299.44,33.03 301.17,31.29 301.17,30.51 v2(301.84,29.85) 303.98,27.71 304.98,27.71 306.76,25.93 309.59,25.93 312.22,23.3 312.22,23.08 314.69,20.61 327.68,20.61 328.77,21.7 330.87,21.7 333.4,24.23 333.4,24.23 333.53,24.37 337.27,24.37 339.04,22.59 343.27,22.59 344.9,20.96 346.17,20.96 346.63,21.43 346.63,24.12 346.43,24.33 346.43,25.57 347.91,27.05 347.91,28.5 348.78,29.38 348.78,31.31 349.28,31.81 349.28,33.32 348.98,33.61 348.98,37.05 349.6,37.67 350.73,37.67 v2(351.5,38.44)
  BOTTOM w0.112: v2(270.07,78.45) 269.8,78.17 v2(269.8,75.06)
  BOTTOM w0.203: PRS99.1 210.52,138.13 PR741.2 209.92,138.73 v2(209.92,138.92)
VCIN1_ADP_PROCHOT: length 36.1
  TOP w0.112: v2(303.74,22.96) 303.54,22.96 303.05,23.45 303.05,24.03 303.54,24.52 UE5.102
  TOP w0.254: v2(309.9,3.45) 308.2,5.16 PR23.2 308.14,6.6 308.14,6.6 PC13.1 307.31,7.44 PR26.1
  BOTTOM w0.112: v2(309.9,3.45) 309.9,3.63 v1(312.07,5.79) 314,7.73 314,12.4 312.82,13.58 311.15,13.58 310.09,14.64 310.09,16.28 305.65,20.72 304.57,20.72 304.19,21.1 304.19,22.5 v2(303.74,22.96)
VCIN_ BATT_TEMP: length 534.4
  TOP w0.112: v2(304.22,12.38) 304.22,11.49 304.72,10.99 304.92,10.91 305.14,10.69 UE5.63 305.14,8.98 305.97,8.15 305.97,7.64 305.59,7.26 CE35.2
  TOP w0.254: PR764.1 PR756.1 206.82,145.74 PC753.2 v2(207.73,147.34)
  IN3 w0.104: v2(207.73,147.34) 207.95,147.12 207.95,144.85 210.15,142.64 212.31,142.64 213.19,141.76 213.19,139.04 210.3,136.14 210.3,134.41 209.6,133.71 209.6,129.35 205.61,125.36 205.61,115.24 204.88,114.51 204.88,111.42 205.76,110.54 207.53,110.54 209.43,112.44 215.07,112.44 216.05,111.46 219.84,111.46 220.29,111.01 232.43,111.01 233.23,111.8 236.51,111.8 237.43,112.73 259.83,112.73 263.63,108.93 270.13,108.93 276.22,102.84 276.22,97.99 276.85,97.35 276.85,90.55 277.55,89.85 277.55,87.1 278.86,85.79 278.86,82.25 277.71,81.1 276.9,81.1 275.14,79.33 272.19,79.33 269.61,76.75 263.5,76.75 v2(263.24,76.49) ; v2(77.63,7.2) 77.97,7.2 78.43,6.74 80.23,6.74 81.55,8.05 87.5,8.05 88.27,7.28 93.65,7.28 96.11,9.74 108.79,9.74 111.79,6.74 119.6,6.74 120.54,5.81 124.11,5.81 124.43,6.12 126.62,6.12 126.93,5.81 138.23,5.81 138.43,6.01 139.58,6.01 139.74,5.85 166.23,5.85 166.91,5.17 178.35,5.17 179.18,4.34 182.21,4.34 182.81,4.94 186.32,4.94 190.94,9.55 195.28,9.55 196.43,8.41 222.97,8.41 223.77,7.61 241.23,7.61 244.39,10.77 248.93,10.77 251.36,8.34 258.72,8.34 258.94,8.12 259.97,8.12 260.77,8.93 261.1,8.93 261.72,9.55 263.01,9.55 263.69,10.23 263.69,10.48 264.07,10.85 264.07,11.9 267.1,14.93 267.72,14.93 270.52,17.73 270.52,18.55 270.78,18.82 275.41,18.82 276.77,17.45 276.77,14.5 280.38,10.9 288.76,10.9 290,12.14 303.98,12.14 v2(304.22,12.38)
  BOTTOM w0.112: v2(263.24,76.49) 263.79,75.94 263.79,68.62 264.9,67.51 264.9,62.15 264.6,61.86 264.6,59.3 262.49,57.19 262.49,54.25 262,53.76 262,52.83 261.8,52.63 261.8,48.57 261.18,47.95 261.18,39.37 263.77,36.78 263.77,34.6 268.31,30.06 270.16,30.06 277.13,23.09 284.45,23.09 286.19,21.34 287.01,21.34 289.74,18.61 290.18,18.61 290.91,17.89 290.91,17.07 290.37,16.53 289.22,16.53 288.4,15.71 288.4,13.88 287.64,13.11 287.64,9.15 286.16,7.67 286.16,5.13 286.27,5.02 289.25,5.02 291.02,6.79 291.02,8.54 293.63,11.15 302.99,11.15 v2(304.22,12.38)
  vias: v1(77.63,8.34)
VCLK_5V: length 4.4
  TOP w0.112: PR307.1 330.24,34.96 330,34.72 v1(330,33.11)
  TOP w0.203: PU301.19 329.43,36.33 330.45,35.3 330.45,34.96 PR307.1
VCORE_VCC_SEN: length 94.3
  TOP w0.203: RC197.2 128.6,26.13 v2(128.6,26.72) 128.93,27.05 128.93,32.17 125.72,35.38 125.72,42.24 130.53,47.06 v1(132.93,47.06) v2(133.66,47.06)
  TOP w0.254: v2(73.62,31.39) 73.37,31.39 PCZ25.1
  GND3 w0.203: v2(128.6,26.72) 126.86,26.72 125.56,25.41 114.35,25.41 111.29,22.35 109.79,22.35 107.4,19.96 101.68,19.96 97.62,24.03 89.5,24.03 86.93,26.59 82.72,26.59 81.78,27.53 79.78,27.53 77.72,29.59 76.91,29.59 75.57,30.94 74.08,30.94 v2(73.62,31.39)
  BOTTOM w0.203: UC1.C38 v2(133.66,47.06)
  BOTTOM w0.254: PRZ42.1 73.3,31.07 v2(73.62,31.39)
VCORE_VSS_SEN: length 98.1
  TOP w0.203: v2(68.99,31.45) 68.99,31.45 68.99,31.46 68.95,31.42 PUZ01.18 ; RC686.1 v2(129.39,26.69) 129.26,26.82 129.26,32.31 126.05,35.52 126.05,42.1 130.12,46.17 v1(130.46,46.17) v2(133.66,46.17)
  GND3 w0.203: v2(68.99,31.45) 69.05,31.39 70.49,31.39 71.27,30.6 75.43,30.6 76.77,29.26 77.59,29.26 79.65,27.2 81.64,27.2 82.58,26.26 86.8,26.26 89.36,23.7 97.48,23.7 101.55,19.63 107.54,19.63 109.93,22.02 111.43,22.02 114.49,25.08 125.79,25.08 126.9,26.19 128.88,26.19 v2(129.39,26.69)
  BOTTOM w0.203: v2(133.66,46.17) 134.08,46.6 UC1.D38
  BOTTOM w0.254: v2(68.99,31.45) 68.06,32.38 PCZ26.1
VCOUT0_MAIN_PWR_ON#: length 40.6
  TOP w0.112: v2(299.44,16.25) 299.44,17.83 297.85,19.42 297.85,21.65 298.68,22.48 301.14,22.48 302.74,24.08 UE5.104
  TOP w0.254: PR315.1 324.58,13.36 v1(323.75,13.36) 323.32,13.79 v2(323.32,14.12)
  IN3 w0.104: v2(323.32,14.12) 323.19,14.25 321.35,14.25 320.53,15.07 307.08,15.07 306.26,15.88 301.08,15.88 300.83,15.64 300.06,15.64 v2(299.44,16.25)
VCOUT1_PROCHOT#: length 4.2
  TOP w0.112: v1(304.89,28.03) 304.6,27.73 RE84.2 RE85.2 303.14,27.67 UE5.103
VD0_VCCSA: length 3
  BOTTOM w0.254: PUA01.3 v2(126.74,116.21) PRA02.1 126.98,115.68 127,115.71 PUA01.2
VDOP_CHG:
  vias: v1(203.42,140.29)
VGA_EN: length 2.6
  BOTTOM w0.112: RM87.1 RM14.2 163.84,182.51 164.62,182.51 v1(164.68,182.45) 164.84,182.3 UM8.26
VL: length 2.8
  TOP w0.112: PC318.1 326.03,39.08 v1(325.59,39.52)
  TOP w0.203: PC318.1 326.26,38.27 326.97,38.27 327.03,38.33 PU301.13
VO_VCCSA: length 10.3
  BOTTOM w0.254: PRA13.2 135.53,115.92 v1(135.16,116.3) 134.26,117.19 134.26,119.01 133.32,119.95 130.18,119.95 129.92,119.7 PUA01.10
VOUT_ISL95338_1: length 1.8
  BOTTOM w0.203: PRS19.1 129.79,143.85 129.29,144.35 128.78,144.35 128.72,144.28 PUS1.31
VOUT_ISL95338_2: length 4
  BOTTOM w0.112: PRS39.1 152.42,141.39 152.81,140.99 v1(152.81,139.47)
  BOTTOM w0.203: PRS39.1 152,141.39 151.61,141.77 PUS2.31
VOUTS_ISL95338_1: length 3.3
  TOP w0.112: v2(127.28,142.14) v1(127.92,142.14)
  TOP w0.254: v2(127.28,142.14) 127.28,142.45 126.81,142.92 PRS13.1
  BOTTOM w0.203: v2(127.28,142.14) 127.28,142.31 126.79,142.8 PUS1.3
VOUTS_ISL95338_2: length 5.6
  TOP w0.254: PRS33.1 149.26,140.19 149.61,139.85 150.63,139.85 v2(150.95,139.53)
  BOTTOM w0.112: v2(150.95,139.53) 150.95,139.49 v1(151.35,139.09)
  BOTTOM w0.203: v2(150.95,139.53) 150.86,139.62 149.83,139.62 149.17,140.29 PUS2.3
VR_PWRGD: length 277.3
  TOP w0.112: UE5.101 303.94,24.34 v2(303.83,24.23)
  IN3 w0.104: v2(303.83,24.23) 303.65,24.41 303.01,24.41 302.11,23.51 297.19,23.51 296.77,23.08 292.21,23.08 289.64,25.65 287.42,25.65 286.78,26.29 285.33,26.29 284.72,26.9 270.6,26.9 269.59,25.89 266.71,25.89 258.76,17.93 238.66,17.93 236.63,15.89 232.04,15.89 231.38,15.23 227.74,15.23 226.53,14.02 188.98,14.02 186.31,11.34 179.14,11.34 178.43,10.63 156.21,10.63 155.49,9.91 141.7,9.91 141.25,10.36 133.33,10.36 132.9,9.93 126.14,9.93 125.47,10.6 123.32,10.6 123.05,10.87 118.79,10.87 118.17,11.48 115.61,11.48 114.84,10.71 112.35,10.71 109.9,13.16 109.71,13.16 109.71,13.15 106.4,13.15 105.61,13.95 95.26,13.95 93.31,15.9 89.53,15.9 87.5,13.87 83.29,13.87 81.58,12.16 66.73,12.16 65.33,13.56 62.82,13.56 v2(62.14,14.24)
  BOTTOM w0.112: v2(62.14,14.24) 61.89,14.49 61.89,19.12 v1(62.36,19.58) 63.12,20.35 63.12,21.18 60.97,23.33 59.27,23.33 57.43,25.17 57.43,27.09 58.15,27.81 58.79,27.81 PRZ21.1
VR_SVID_ALRT#: length 94.3
  TOP w0.112: R396.1 135.22,27.84 v2(135.12,27.74) ; PRZ09.2 56.86,30.45 v2(56.27,30.45) 55.83,30.45 v1(55.66,30.63)
  IN4 w0.084: v2(135.12,27.74) 135,27.74 134.2,26.95 133.19,26.95 132.81,26.57 132.81,26.1 131.5,24.79 130.71,24.79 129.85,25.65 113.57,25.65 110.78,22.86 108.45,22.86 107.74,22.15 103.47,22.15 102.95,21.64 99.92,21.64 99.12,22.44 88.75,22.44 86.31,24.87 80.57,24.87 79.6,23.9 71.91,23.9 71.09,24.72 71.07,24.72 70.03,25.76 70.03,27.22 69.65,27.6 68.46,27.6 68.41,27.56 68.4,27.56 67.62,26.78 66.87,26.78 64.73,24.64 62.51,24.64 59.72,27.43 59.72,28.13 58.86,29 58.25,29 58.14,29.11 57.33,29.11 57.04,28.81 56.24,28.81 56,29.06 55.86,29.2 55.86,30.04 v2(56.27,30.45)
VR_SVID_ALRT#_L: length 3.2
  TOP w0.112: RC16.2 R396.2 136.57,27.84 136.11,27.37 136.07,27.37 RC19.1 135.78,26.49 v1(135.35,26.06)
VR_SVID_CLK: length 99.9
  TOP w0.112: PRZ07.2 57.03,29.86 v2(56.29,29.86) ; R397.1 v2(131.2,25.2)
  IN4 w0.084: v2(131.2,25.2) 130.36,26.04 120.66,26.04 120.58,26.12 120.58,26.71 120.49,26.79 120.33,26.79 120.24,26.71 120.24,26.12 120.16,26.04 119.99,26.04 119.91,26.12 119.91,26.71 119.82,26.79 119.66,26.79 119.57,26.71 119.57,26.12 119.49,26.04 119.32,26.04 119.24,26.12 119.24,26.71 119.15,26.79 118.99,26.79 118.9,26.71 118.9,26.12 118.82,26.04 118.65,26.04 118.57,26.12 118.57,26.71 118.48,26.79 118.31,26.79 118.23,26.71 118.23,26.12 118.15,26.04 117.98,26.04 117.9,26.12 117.9,26.71 117.81,26.79 117.64,26.79 117.56,26.71 117.56,26.12 117.48,26.04 117.31,26.04 117.22,26.12 117.22,26.71 117.14,26.79 116.97,26.79 116.89,26.71 116.89,26.12 116.81,26.04 116.64,26.04 116.55,26.12 116.55,26.71 116.47,26.79 116.3,26.79 116.22,26.71 116.22,26.12 116.14,26.04 115.97,26.04 115.88,26.12 115.88,26.71 115.8,26.79 115.63,26.79 115.55,26.71 115.55,26.12 115.46,26.04 115.3,26.04 115.21,26.12 115.21,26.71 115.13,26.79 114.96,26.79 114.88,26.71 114.88,26.12 114.79,26.04 114.63,26.04 114.54,26.12 114.54,26.84 114.46,26.92 114.29,26.92 114.21,26.84 114.21,26.12 114.12,26.04 113.41,26.04 110.62,23.25 108.28,23.25 107.75,22.71 103.48,22.71 102.79,22.03 100.08,22.03 99.28,22.82 88.91,22.82 86.47,25.26 80.41,25.26 80.18,25.03 80.18,25.03 79.43,24.29 72.07,24.29 71.25,25.11 71.24,25.11 70.45,25.89 70.45,27.31 70.42,27.34 70.42,27.39 69.81,27.99 68.3,27.99 68.25,27.94 68.24,27.94 67.46,27.17 66.71,27.17 64.57,25.03 62.67,25.03 60.11,27.59 60.11,27.97 60.11,27.97 60.11,28.29 59.02,29.38 58.41,29.38 58.3,29.49 56.72,29.49 56.58,29.63 56.52,29.63 v2(56.29,29.86)
VR_SVID_CLK_R: length 24.3
  TOP w0.112: v2(130.08,26.85) 130.08,26.2 R397.2
  IN1 w0.084: v2(130.08,26.85) 130.08,31.97 131.11,32.99 131.11,33.11 134.68,36.69 134.68,38.5
  IN1 w0.102: 134.68,38.5 134.88,38.7 134.88,42.18 133.22,43.83 133.22,45.44 133.58,45.79 134.23,45.79 v2(134.56,46.12)
  BOTTOM w0.102: UC1.E38 v2(134.56,46.12)
VR_SVID_OUT: length 100.8
  TOP w0.112: v2(133.95,31.47) 133.95,31.34 133.96,31.34 R398.1 ; PRZ12.2 v2(56.16,31.39) v1(56.16,32.34)
  IN4 w0.084: v2(133.95,31.47) 133.95,29.61 135.54,28.02 135.54,27.57 134.67,26.69 133.42,26.69 133.06,26.34 133.06,25.99 131.73,24.66 131.67,24.66 131.59,24.58 130.61,24.58 129.76,25.44 113.66,25.44 110.87,22.65 108.53,22.65 107.82,21.94 103.55,21.94 103.04,21.43 99.83,21.43 99.03,22.22 88.66,22.22 86.22,24.66 80.66,24.66 79.68,23.69 71.81,23.69 70.99,24.51 70.64,24.86 70.64,24.86 69.82,25.68 69.82,25.85 69.82,27.14 69.56,27.39 68.55,27.39 68.5,27.34 68.49,27.34 67.71,26.57 66.96,26.57 64.82,24.43 62.36,24.43 59.47,27.33 59.47,27.54 59.47,28.03 58.75,28.74 58.15,28.74 58.04,28.85 57.43,28.85 57.14,28.56 56.14,28.56 55.82,28.88 55.69,29.01 55.61,29.09 55.61,30.84 v2(56.16,31.39)
VR_SVID_OUT_R: length 24.8
  TOP w0.112: RC17.2 R398.2 133.22,30.71 v2(133.22,31.39)
  IN1 w0.133: v2(133.22,31.39) 133.22,34.28 133.53,34.59 133.72,34.59 134.99,33.32 135.18,33.32 135.37,33.51 135.37,33.7 134.1,34.96 134.1,35.15 134.29,35.34 134.48,35.34 135.75,34.07 135.93,34.07 136.12,34.26 136.12,34.45 134.85,35.72 134.85,35.91 135.36,36.41 135.36,43.5 v2(134.56,44.3)
  BOTTOM w0.102: UC1.E40 v2(134.56,44.3)
VROM_SEL: length 15.9
  TOP w0.089: UH1.AW26 279.77,60.1 279.65,60.22 v2(279.65,60.48)
  IN2 w0.104: v2(279.65,60.48) 279.53,60.6 279.53,60.7 278.99,61.24 278.99,68.88 281.2,71.09 281.2,71.35 v2(281.29,71.44)
  BOTTOM w0.112: RH589.2 281.29,71.39 v2(281.29,71.44)
  BOTTOM w0.127: v2(281.29,71.44) 281.66,71.81 v1(282.13,71.81) 282.6,72.28 RH588.2
VSB_N_001: length 4.2
  BOTTOM w0.112: v1(56.41,24.4) PR16.2
  BOTTOM w0.254: PQ8.3 53.49,23.4 PC18.2 54.65,23.42 PR19.2 55.71,23.47 PR16.2
VSB_N_002: length 1.1
  BOTTOM w0.112: PR34.1 v1(60.93,21.15)
VSB_N_003: length 3.3
  BOTTOM w0.112: v1(57.66,23.87) 56.41,22.63 PR16.1
  BOTTOM w0.254: PR16.1 56.8,22.56 57.27,22.09 PQ9.1
VTTREF_1.2V: length 2.9
  TOP w0.254: PU201.4 216.67,116.48 216.66,116.47 215.97,116.33 215.65,116.33 v1(215.61,116.29) 215.05,116.29 214.58,116.76 PC210.1
WAKE#: length 12.9
  TOP w0.089: UH1.BB47 269.14,61.99 268.98,61.99 268.9,61.91 268.44,61.91 268.19,62.16 267.63,62.16 266.13,63.66 266.13,65.24
  TOP w0.112: 266.13,65.24 266.13,66.2 v1(264.97,67.35) 264.75,67.57 264.06,67.57 263.41,68.23 263.41,68.67 263.4,68.68 263.4,68.88 263.07,69.21 RH453.1 RH4.2 262.89,70.79 RH1018.2
WAKE_PCH#: length 6.2
  TOP w0.089: UH1.BG44 271.14,64.6 270.5,65.24
  TOP w0.112: 270.5,65.24 270.5,68.33 270.29,68.54 v1(270.29,68.73) 270.79,69.23 RH545.1
WL_OFF#: length 165.6
  TOP w0.089: UH1.AP24 v2(281.66,57.82)
  TOP w0.112: RH707.2 v2(350.61,51.59) 350.7,51.67 DN1.1 v1(352.01,52.6)
  IN2 w0.104: v2(284.15,69.93) 284.04,69.82 282.74,69.82 281.97,69.05 281.97,66.74 281.24,66.02 281.24,61.08 280.83,60.67 280.83,58.65 v2(281.66,57.82)
  IN3 w0.104: v2(349.21,25.03) 349.58,24.66 349.58,20.91 348.01,19.35 338.74,19.35 337.19,20.89 337.19,22.15 336.6,22.75 334.2,22.75 331.53,20.08 329.44,20.08 326.69,17.33 315.68,17.33 310.9,22.11 310.29,22.11 309.1,23.3 309.1,23.35 308.72,23.73 306.67,23.73 304.54,25.86 303.51,25.86 301.89,27.48 300.86,27.48 300.02,28.31 298.12,28.31 297.33,29.11 296.51,29.11 295.91,29.11 294.74,30.28 294.74,30.56 292.58,32.72 291.01,32.72 287.25,36.47 287.25,38.04 286.9,38.4 286.9,39.57 284.59,41.88 284.59,43.8 283.93,44.46 283.93,45.46 284,45.53 284,48.96 285.42,50.38 285.42,50.75 285.88,51.21 285.88,53.01 286.51,53.63 286.51,54.22 284.76,55.97 284.76,59.59 284.44,59.91 282.96,59.91 282.37,59.32 282.37,58.53 v2(281.66,57.82) ; v2(342.29,29.63) 343.11,30.46 343.11,40.58 348.02,45.49 350.22,45.49 351.16,46.43 351.16,51.04 v2(350.61,51.59)
  IN4 w0.084: v2(342.29,29.63) 343.1,29.63 347.16,25.57 347.93,25.57 348.47,25.03 v2(349.21,25.03)
  BOTTOM w0.112: v2(284.15,69.93) 284.15,70.54 RH520.2
WL_OFF#_R: length 16.9
  TOP w0.112: DN1.2 v1(347.31,52.6) 344.15,49.44 341.99,49.44 v2(341.6,49.05)
  BOTTOM w0.112: JWLAN.56 340.23,46.6 340.77,47.14 340.77,48.22 v2(341.6,49.05)
XCLK_BIASREF: length 7.1
  TOP w0.089: v1(295.9,46.04) RH71.2 RH590.2 295.46,47.8 295.3,47.64 294.73,47.64 293.52,48.85 292.69,48.85 292.49,48.65 292.42,48.65 292.23,48.45 291.7,48.45 291.52,48.63 291.38,48.63 UH1.T3
XDP_HOOK0: length 6
  TOP w0.112: v1(55.27,40.34) RC355.1 55.52,41.7 56.67,41.7 57.64,42.67 58.44,42.67 58.83,43.05 58.98,43.05 59.34,43.41 JPCMC.27
XDP_ITP_PMODE: length 310.7
  TOP w0.089: v2(294.43,56.88) 294.12,56.88 293.06,55.82 291.95,55.82 291.87,55.91 291.46,55.91 UH1.AL3
  TOP w0.112: JPCMC.26 59.25,42.87 v2(58.83,42.44) 58.78,42.39 58.24,42.39 57.56,41.7 RC353.2
  IN1 w0.084: v2(59.48,25.1) 59.09,24.71 59.09,24.13 59.49,23.73 61.74,23.73 62.37,24.36 65.13,24.36 66.4,23.09 76.91,23.09 78.8,21.2 79.69,21.2 81.29,19.6 86.72,19.6 87.86,20.74 88.3,20.74 88.54,20.98 89.79,20.98 92.26,18.51 107.4,18.51 109.44,16.47 110.99,16.47 112.95,14.51 117.78,14.51 120.97,17.7 120.97,20.15 120.24,20.89 v2(118.75,20.89)
  IN2 w0.104: v2(281.25,36.76) 281.25,36.75 288.37,36.75 290.67,39.05 291.71,39.05 293.61,40.95 293.61,43.22 293.03,43.79 292.9,43.93 292.9,46.69 293.33,47.12 293.33,48.28 293.33,48.29 293.33,48.62 293.33,48.63 293.33,48.92 291.61,50.63 291.61,54.22 291.75,54.36 294.27,56.88 v2(294.43,56.88)
  IN3 w0.104: v2(59.48,25.1) 59.07,25.51 59.07,26 59.27,26.2 59.27,32.29 59.21,32.36 59.21,36.06 58.88,36.4 57.94,36.4 57.15,37.18 57.15,41.53 58.07,42.44 v2(58.83,42.44) ; v2(118.75,20.89) 118.75,21.71 119.5,22.46 131.63,22.46 133.74,24.56 160.27,24.56 160.88,23.96 170.08,23.96 170.68,24.56 185.77,24.56 187.88,22.45 204.25,22.45 205.39,21.32 215.73,21.32 216.31,20.74 217.85,20.74 218.67,21.56 227.43,21.56 230.05,24.18 237.13,24.18 237.58,24.63 248.58,24.63 249.03,24.18 252.66,24.18 256.55,28.07 258.75,28.07 263.76,33.08 278.51,33.08 280.22,34.79 280.22,35.73 v2(281.25,36.76)
XDP_PRDY#: length 327
  TOP w0.089: v2(297.3,57.21) 297.3,57.66 v1(296.89,58.06) 296.26,58.06 295.64,57.45 294.14,57.45 292.9,56.2 292.12,56.2 291.94,56.38 291.66,56.38 291.63,56.41 290.94,56.41 290.83,56.52 290.72,56.52 290.69,56.55 UH1.AM5
  TOP w0.112: v2(58.77,46.73) 58.77,46.34 58.88,46.23 JPCMC.34
  IN1 w0.084: v2(130.5,86.7) 128.19,86.7 127.3,87.59 125.74,87.59 122.06,91.27 121.93,91.39 111.48,91.39 110.85,91.39 109.38,89.93 109.38,83.04 103.58,77.24 103.58,77.24 103.53,77.18 103.53,68.23 98.09,62.78 96.66,62.78 83.18,49.31 82.49,49.31 82.49,49.31 67.38,49.31 67.25,49.19 65.56,47.5 63.77,47.5 63,48.27 60.98,48.27 60.95,48.3 59.75,48.3 58.77,47.32 v2(58.77,46.73)
  IN4 w0.084: 130.5,84.99 v2(130.5,86.7) 130.5,87.63 134.9,92.02 151.58,92.02 157.13,97.57 162.49,97.57 164.48,99.56 179.25,99.56 180.81,101.11 193.11,101.11 193.78,100.44 202.98,100.44 203.65,101.11 210.61,101.11 211.29,100.43 228.59,100.43 229.19,101.02 247.58,101.02 248.06,100.54 259.38,100.54 261.28,98.64 269.06,98.64 275,92.69 275,89.02 279.01,85.02 281.75,85.02 282.35,84.41 283.31,84.41 293.41,74.31 293.41,71.8 293.53,71.68 296.42,68.8 296.42,63.98 297.03,63.36 297.03,57.47 v2(297.3,57.21)
  IN4 w0.102: v2(131.85,74.8) 131.85,75.02 130.5,76.36 130.5,84.99
  BOTTOM w0.102: UC1.B10 131.78,74.8 v2(131.85,74.8)
XDP_PREQ#: length 326.9
  TOP w0.089: UH1.AL2 291.9,56.14 292.03,56.01 292.98,56.01 294.22,57.26 296.43,57.26 296.97,56.71 v1(297.12,56.71) v2(297.6,56.71)
  TOP w0.112: JPCMC.33 58.86,45.71 58.69,45.88 58.47,45.88 v2(58.46,45.89)
  IN1 w0.084: v2(129.63,87.17) 129.44,87.36 127.83,87.36 126.52,88.67 124.95,88.67 122.27,91.36 122.02,91.6 111.57,91.6 111.57,91.6 111.05,91.6 111.05,91.6 110.76,91.6 109.17,90.01 109.17,83.13 103.37,77.33 103.37,77.32 103.32,77.27 103.32,68.31 98,62.99 96.57,62.99 83.1,49.52 82.57,49.52 82.57,49.52 60.67,49.52 58.27,47.11 58.27,46.09 v2(58.46,45.89)
  IN4 w0.084: v2(297.6,56.71) 297.9,57.01 297.9,63.38 296.63,64.65 296.63,68.88 293.62,71.89 293.62,74.4 282.32,85.7 278.62,85.7 275.55,88.77 275.55,92.47 269.17,98.85 261.37,98.85 259.47,100.76 248.23,100.76 247.75,101.23 229.1,101.23 228.51,100.64 211.38,100.64 210.68,101.34 199.2,101.34 198.52,100.65 193.86,100.65 193.18,101.34 180.74,101.34 179.18,99.78 164.4,99.78 162.42,97.8 157.06,97.8 151.51,92.25 134.8,92.25 131.63,89.08 131.63,89.07
  IN4 w0.102: v2(131.1,74.86) 131.1,75.19 129.63,76.67 v2(129.63,87.17) 129.73,87.17 131.63,89.07
  BOTTOM w0.102: v2(131.1,74.86) 131.38,75.13 UC1.B9
XDP_SPI_IO2: length 5
  TOP w0.112: RC354.1 59.22,38.81 59.34,38.7 v2(59.34,38.6) ; JPCMC.24 59.99,42.06 v2(59.74,41.81)
  BOTTOM w0.112: v2(59.74,41.81) 59.34,41.41 v1(59.34,40.22) v2(59.34,38.6)
XDP_SPI_SI: length 273
  TOP w0.112: JPCMC.25 59.88,42.78 v2(59.4,42.3) ; v2(259.69,59.54) 259.16,60.07 RH1.1 ; v2(55.66,38.41) 55.66,38.55 55.92,38.81 RC9.2
  IN4 w0.084: v2(259.69,59.54) 259.36,59.87 257.08,59.87 255.8,58.6 254.94,58.6 254.35,58 254.35,26.39 250.17,22.21 244.15,22.21 239.8,17.86 188.07,17.86 181.01,10.8 169.22,10.8 169.01,10.6 144,10.6 143.16,11.44 141.22,11.44 140.77,11.88 130.67,11.88 130.51,12.05 124.51,12.05 123.23,13.33 118.46,13.33 117.6,14.19 112.97,14.19 109.54,17.62 108.71,17.62 108.55,17.46 100.31,17.46 98.81,18.97 91.32,18.97 91.02,19.27 87.92,19.27 87.62,18.97 87.27,18.97 63.15,18.97 62.97,18.97 62.62,18.97 59.13,22.46 58.53,22.46 56.26,24.73 56.26,26.97 53.88,29.36 53.88,30.7 53.31,31.27 53.31,31.98 v2(53.36,32.03)
  BOTTOM w0.112: v2(53.36,32.03) 53.39,32.06 53.39,32.61 53.69,32.91 53.69,33.07 55.66,35.04 v2(55.66,38.41) v1(56.94,39.69) 59.11,41.85 59.11,42.01 v2(59.4,42.3)
XDP_TCK1: length 315.7
  TOP w0.089: UH1.AJ3 291.22,55.06 293.37,55.06 294.1,55.79 295.21,55.79 v2(295.26,55.74) ; v2(281.63,36.24) v3(282.22,36.24)
  TOP w0.112: JPCMC.31 58.32,44.92 v2(58.31,44.92) 58.19,44.8 56.13,44.8 54.15,46.78 RC348.1
  IN1 w0.084: v2(119.16,21.49) 119.48,21.17 120.25,21.17 121.18,20.24 121.18,17.61 117.87,14.3 112.72,14.3 110.77,16.26 109.35,16.26 107.31,18.3 92.18,18.3 89.75,20.72 88.86,20.72 86.1,17.96 81.74,17.96 76.82,22.88 66.31,22.88 65.53,23.66 64.51,23.66 64.03,23.18 62.16,23.18 61.82,23.52 59.4,23.52 58.88,24.04 v2(58.88,25.11)
  IN2 w0.104: v2(295.26,55.74) 293.46,55.74 291.85,54.13 291.85,50.72 293.56,49.01 293.56,48.73 293.56,48.72 293.56,48.19 293.56,48.18 293.56,47.02 293.13,46.59 293.13,44.03 293.84,43.31 293.84,40.85 291.81,38.82 290.77,38.82 288.47,36.52 281.91,36.52 v2(281.63,36.24)
  IN3 w0.104: v2(58.31,44.92) 58.31,44.51 58.72,44.09 58.72,43.74 56.92,41.93 56.92,37.09 57.84,36.17 58.78,36.17 58.98,35.97 58.98,32.26 59.04,32.2 59.04,26.43 58.7,26.09 58.7,25.28 v2(58.88,25.11) ; v2(281.63,36.24) 280.45,35.06 280.45,34.69 278.61,32.85 263.86,32.85 258.84,27.84 256.65,27.84 252.65,23.84 249.04,23.84 248.48,24.4 237.67,24.4 237.23,23.95 230.14,23.95 227.52,21.33 218.77,21.33 217.94,20.51 216.22,20.51 215.64,21.09 188.92,21.09 185.68,24.33 170.78,24.33 170.17,23.72 160.78,23.72 160.18,24.33 133.83,24.33 131.73,22.22 119.59,22.22 119.34,21.97 119.34,21.67 v2(119.16,21.49)
XDP_TDI: length 344.8
  TOP w0.089: v2(294.31,55.19) 294.2,55.19 293.68,54.67 292.22,54.67 292.18,54.62 UH1.AH2
  TOP w0.112: v2(58.06,43.85) 58.35,43.85 58.5,43.99 58.62,43.99 58.62,43.99 58.91,43.99 JPCMC.29 ; v2(126.87,86.41) 126.87,85.46 v3(125.95,84.55) 125.69,84.29 124.17,84.29 RH495.2
  IN1 w0.084: v2(118.67,92.42) 110.69,92.42 108.54,90.27 108.54,83.39 102.74,77.59 102.74,77.59 102.69,77.53 102.69,68.58 97.74,63.62 96.31,63.62 82.83,50.15 60.06,50.15 59.93,50.03 59.93,50.03 57.29,47.38 57.29,44.18 57.62,43.85 v2(58.06,43.85)
  IN2 w0.102: v2(138.23,72.27) 138.37,72.27 139.59,73.48 139.59,80.62 138.84,81.37 138.27,81.37 134.65,84.99
  IN2 w0.104: 134.65,84.99 133.93,85.71 127.57,85.71 127.05,86.23 127.04,86.23 v2(126.87,86.41) 126.26,87.01 124.64,87.01 123.11,88.54 122.55,88.54 v2(118.67,92.42)
  IN4 w0.102: v2(294.31,55.19) 294.31,55.44 294.16,55.59 294.16,55.84 293.96,56.04 293.96,56.65 293.74,56.87 293.74,57.58 294.16,58 294.16,58.4 292.76,59.8 292.76,63.53 292.89,63.65 292.89,64.73 292.13,65.49 292.12,65.49 291.73,65.88 291.73,67.65 290.17,69.2 290.17,72.42 285.09,77.51 284.05,77.51 283.31,78.24 283.31,79.31 283.02,79.6 281.04,79.6 280.64,80.01 278.75,80.01 275.17,83.59 274.29,83.59 274.03,83.85 274.03,84.73 271.56,87.2 271.56,89.87 265.58,95.84 260.13,95.84 258.22,97.75 246.66,97.75 246.19,98.22 230.34,98.22 229.75,97.64 210.13,97.64 209.46,98.31 204.8,98.31 204.14,97.65 185.72,97.65 185.06,98.31 181.98,98.31 180.42,96.75 165.69,96.75 163.64,94.7 158.2,94.7 152.74,89.23 141.54,89.23 137.69,85.38 137.69,81.24 137.77,81.16 137.77,72.73 v2(138.23,72.27)
  BOTTOM w0.102: UC1.G12 136.4,73.03 137.84,73.03 138.23,72.64 v2(138.23,72.27)

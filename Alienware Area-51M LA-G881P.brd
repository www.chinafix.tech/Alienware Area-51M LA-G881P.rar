# Allegro board Alienware Area-51M LA-G881P.brd (continued)
## Nets (continued)
EC_SSD: JSSD1.8 JSSD2.8 RE702.2
EC_TX: RN30.1 RN118.2 UE5.30
ECAGND: CE35.1 CE172.2 LE2.2 PH1.2 UE5.69
EDICLK: JDBG.2 UE5.60
EDICS: JDBG.1 UE5.59
EDIDI: JDBG.3 UE5.61
EDIDO: JDBG.4 UE5.62
EDP_RCOMP: RC10.2 UC1.M9
ELC_BOOT_MODE: RE5.1 RE657.2 UE1.44 UH1.BD29
ELC_EC#: QE13.5 QE21.5 QE22.5 UE10.6
ELC_RESET: QE59.3 RE690.2 UH1.BD30
EN_0.6VSP: PC214.1 PR209.1 PR211.1 PU201.7
EN_1.2V: PC213.1 PR208.2 PU201.8
EN_+1VALWP: PC108.1 PR104.2 PU101.3
EN_INVPWR: JDGFF1.F4 UE5.47
EN_TPLED: C2509.1 Q2409.3 Q2410.1 R179.1 R180.1
EN_VCCIO: PCF12.1 PRF01.2 PRF06.1 PUF01.11
EN_VCCSA: PCA26.1 PRA23.1 PUA01.13
EN_WOL#: CL119.1 UE10.7 UL14.4
ENVDD: JDGFF2.E1 RV4.2 UV64.4
EQA0: RM81.2 RM84.2 UM8.20
EQA1: RM70.2 RM76.2 UM8.19
EQB0: RM82.2 RM85.2 UM8.46
EQB1: RM23.2 RM26.2 UM8.47
ESPI_FRAME#: TC22.1(TP-1) UE5.4 UH1.BE38
ESPI_IO0: TC23.1(TP-1) UE5.10 UH1.BB39
ESPI_IO1: TC24.1(TP-1) UE5.8 UH1.AW37
ESPI_IO2: TC25.1(TP-1) UE5.7 UH1.AV37
ESPI_IO3: TC26.1(TP-1) UE5.5 UH1.BA38
ESPI_KB_RST#: RE646.1 RH518.1 UH1.BE39
ESPI_RST#: UE5.14 UH1.BF38
ESPI_SERIRQ: RH111.1 TC21.1(TP-1) UE5.3 UH1.AW35
FB_1.2V: PR205.1 PR207.1 PR213.1 PR215.1 PU201.6
FB_3V: PR301.2 PR303.2 PU301.4
FB_5V: PR302.1 PR304.1 PU301.2
FB_+1VALWP: PR107.1 PR108.1 PU101.4
FB_VCCIO: PCF11.2 PRF07.2 PRF10.1 PUF01.14
FB_VCCSA: PRA07.1 PRA08.2 PUA01.8
FCCM_GT: PRG05.1 PRG17.1 PUZ01.11
FCCM_VCORE: PRI15.1 PRI31.1 PRI56.1 PRI71.1 PRI96.1 PRI111.1 PUZ01.24
FFS_INT1: RP10.2 UH1.BE18 US1.11
FFS_INT2: QS3.3 RP9.2 UH1.BF18 US1.9
FFS_INT2_CONN: DS1.2 JHDD.12 RS1.2
FSEL_VCCSA: PRA14.2 PRA16.1 PUA01.11
FSET_CHG: PR755.2 PU703.12
FWPG_ISL95338_1: PQ6.5 PRS53.1 PRS54.2 PUS1.24 UE5.36
FWPG_ISL95338_2: PQ10.5 PRS55.1 PRS56.2 PUS2.24 UE5.91
GC6_EVENT#: JDGFF2.D2 UH1.BB26
GC6_FB_EN: JDGFF2.C10 UH1.BF29
GPD_7: RH11.1 RH594.2 UH1.BE41
GPIO8: RT124.2 RT125.1 UT4.H6
GPP_H12: RH100.2 UH1.AB47
GPP_H15: RH99.1 UH1.AC47
GPP_J9: RH218.1 UH1.AU9
GPPJ_RCOMP_1P8: RH216.1 UH1.BD1 UH1.BE1 UH1.BE2
GPU_FAN_FB: DF2.2 RF4.1 UE5.29
GPU_FAN_PWM: JFAN2.3 RF5.1 UE5.27
GPU_OVERT#: JDGFF1.F1 UE5.85
GPU_STRAP5_EC: JDGFF1.F10 RE689.2 UE5.53
GSYNC_ID: RH29.1 RH30.1
GT_V1N: PLG01.3 PRG11.2 PRG23.1
GT_V1P: PLG01.2 PRG08.2 PRG09.1
GT_V2N: PLG02.3 PRG12.1 PRG22.2
GT_V2P: PLG02.2 PRG20.2 PRG21.1
GYRO_ADD: RS10.1 US2.1
GYRO_INT2: RH1015.1 US2.9
H_CATERR#: RC693.2 UC1.D13
H_CPU_SVIDALRT#: RC19.2 UC1.E39
H_CPUPWRGD: CC4.1 UC1.F8 UH1.AE3
H_DRAMRST#: CD125.1 RD51.2 RD52.2 RD62.2 UH1.BB46
H_PECI: RC11.2 UH1.AF2
H_PM_DOWN: RC5.2 RH14.1 UH1.AE2
H_PM_SYNC: RH15.1 UH1.AF3
H_PM_SYNC_R: CC3.1 RH15.2 UC1.E8
H_PROCHOT#: PCZ02.1 PQ7.1 PR27.1 PR42.1 PR777.1 PRZ02.1 QE2.1 RC3.2 RC4.1
H_PROCHOT#_R: RC4.2 UC1.C39
H_THERMTRIP#: R395.1 RC2.2 RH79.2
H_THERMTRIP#_R: RH79.1 UH1.AD3
H_VCCST_PWRGD: Q7.3 RC12.2 RC13.1 UE5.123
HDA_BIT_CLK: RT707.2 UH1.BD11
HDA_BIT_CLK_R: CH243.1 JAUDIO.28 RT707.1
HDA_RST#: RP7.2 UH1.BE10
HDA_SDIN: JAUDIO.24 UH1.BE11
HDA_SDOUT: RH16.2 RP2.2 UH1.BF12
HDA_SDOUT_R: JAUDIO.25 RP2.1
HDA_SPKR: JAUDIO.22 RH600.1 UH1.AW29
HDA_SYNC: RP6.2 UH1.BG13
HDA_SYNC_R: JAUDIO.23 RP6.1
HDMI_HPD_PCH: JDGFF1.F2 UH1.BD21
HEAD_LED_B_DRV#: JFC.4 UE3.5
HEAD_LED_G_DRV#: JFC.3 UE3.4
HEAD_LED_R_DRV#: JFC.2 UE3.3
HT_EN: JDBG.5 UE5.42
I2C0_SCL_EC: JAUDIO.13 RE668.2
I2C0_SDA_EC: JAUDIO.12 RE669.2
I2C2_SCL: RH31.1 RPC7.4 UH1.BF17
I2C2_SDA: RH32.1 RPC7.3 UH1.BE17
I2C3_SCL: RH617.2 US2.13
I2C3_SDA: RH618.2 US2.14
I2C_0_SCL: RE71.1 RPC7.2 UH1.BC22
I2C_0_SCL_R: JTP.2 RE71.2 RE659.2
I2C_0_SDA: RE653.1 RPC7.1 UH1.BF23
I2C_0_SDA_R: JTP.1 RE653.2 RE660.2
I2C_CLK: RE2.2 RM1.2 UE1.42 UE3.25
I2C_DAT: RE1.2 RM2.2 UE1.43 UE3.26
I2C_INT: DK3.2 JPK.15 RE656.2 UE5.98
ILIM_VCCIO: PRF09.1 PRF11.2 PUF01.13
IMVP_VR_ON: CE38.2 PRA23.2 PRZ24.1 Q7.6 UE5.121
INTRUDER#: RH531.1 UH1.BB44
ISEN1_GT: PCZ20.2 PRG09.2 PRG12.2 PUZ01.9
ISEN1_VCORE: PCZ19.1 PRI19.2 PRI22.2 PRI23.2 PRI34.2 PRI37.2 PRI38.2 PUZ01.21
ISEN1N_CHG: PR765.3 PR776.2
ISEN1P_CHG: PR742.2 PR765.2
ISEN2_GT: PCZ17.2 PRG21.2 PRG23.2 PUZ01.10
ISEN2_VCORE: PCZ18.1 PRI60.2 PRI62.2 PRI63.2 PRI75.2 PRI77.2 PRI78.2 PUZ01.22
ISEN3_VCORE: PCZ16.1 PRI100.2 PRI102.2 PRI103.2 PRI115.2 PRI117.2 PRI118.2 PUZ01.23
ISH_GP1: UE5.1 UH1.BD34
ISH_I2C0_SCL: RH617.1 RS18.1 UH1.AG45
ISH_I2C0_SDA: RH618.1 RS19.1 UH1.AH46
ISH_I2C1_SCL: RH620.1 UH1.AH47
ISH_I2C1_SCL_R: RH31.2 RH620.2 US3.1
ISH_I2C1_SDA: RH621.1 UH1.AH48
ISH_I2C1_SDA_R: RH32.2 RH621.2 US3.4
ISL95338_N001: PDS01.1 PRS08.1
ISL95338_N003: PCS29.1 PRS20.2
ISL95338_N004: PDS02.1 PRS41.1
ISL95338_N006: PCS58.1 PRS40.1
ISOLATE#: RL9.2 RL10.2 UL1.49
IST_TRIG: TC13.1(TP-1) UC1.L8
ISUMN_GT: PCZ12.2 PCZ13.2 PCZ15.1 PCZ17.1 PCZ20.1 PHZ02.2 PRG11.1 PRG22.1 PRZ30.2 PRZ31.1 PRZ32.1
ISUMN_VCORE: PCZ16.2 PCZ18.2 PCZ19.2 PCZ21.1 PCZ22.1 PCZ23.1 PHZ03.1 PRI20.1 PRI36.1 PRI61.1 PRI76.1 PRI101.1 PRI116.1 PRZ33.2 PRZ34.1 PRZ35.2
ISUMP_GT: PCZ12.1 PCZ13.1 PRG08.1 PRG10.2 PRG20.1 PRZ29.1 PRZ30.1 PUZ01.7
ISUMP_VCORE: PCZ22.2 PCZ23.2 PRI18.1 PRI33.1 PRI59.1 PRI74.1 PRI99.1 PRI114.1 PRZ34.2 PRZ36.2 PRZ45.2 PUZ01.19
JRTC1: PD5.2 PR18.2
LAN_ACTIVITY#: CL107.1 JLAN.10 T364.1(TP-1) UL1.31
LAN_GPI: RL5.2 T361.1(TP-1) UL1.48
LAN_GPIO0: RL51.2 RL52.2 T368.1(TP-1) UL1.29
LAN_GPIO1: RL53.2 RL54.2 T369.1(TP-1) UL1.30
LAN_GPIO4: T362.1(TP-1) UL1.36 UL4.1
LAN_GPIO8: T371.1(TP-1) UL1.40
LAN_MDIN0: UL1.88 UL2.2
LAN_MDIN1: UL1.9 UL2.5
LAN_MDIN2: UL1.16 UL2.8
LAN_MDIN3: UL1.25 UL2.11
LAN_MDIP0: UL1.87 UL2.3
LAN_MDIP1: UL1.8 UL2.6
LAN_MDIP2: UL1.15 UL2.9
LAN_MDIP3: UL1.24 UL2.12
LAN_SPICS#: T370.1(TP-1) UL1.37
LAN_SPISCK: RL68.2 T365.1(TP-1) UL1.32 UL4.2
LAN_SPISI: RL60.2 T367.1(TP-1) UL1.39 UL4.3
LAN_SPISO: RL67.2 T366.1(TP-1) UL1.38 UL4.4
LCD_TEST: JDGFF1.F7 UE10.9
LDO_EN: DK3.3 JPK.18 UE10.15
LG1_ISL95338_1: PQS02.4 PUS1.9
LG1_ISL95338_2: PQS06.4 PUS2.9
LG2_ISL95338_1: PQS04.4 PUS1.7
LG2_ISL95338_2: PQS08.4 PUS2.7
LG_3V: PQ302.4 PU301.11
LG_5V: PQ304.4 PU301.15
LG_+1VALWP: PQ102.4 PU101.6
LG_CHG: PQ708.4 PU703.21
LG_VCCSA: PQA01.6 PUA01.19
LID_SW#: CE43.1 DE1.1 JAUDIO.10 RE70.2 UE5.115
LX1_ISL95338_1: PLS02.1 PQS01.1 PQS01.2 PQS01.3 PQS02.5 PQS03.1 PQS03.2 PQS03.3 PRS04.1 PRS83.1 PUS1.10
LX1_ISL95338_2: PLS04.1 PQS06.5 PQS07.1 PQS07.2 PQS07.3 PQS09.1 PQS09.2 PQS09.3 PRS24.1 PRS85.1 PUS2.10
LX2_ISL95338_1: PLS02.2 PQS04.5 PQS05.1 PQS05.2 PQS05.3 PRS11.2 PUS1.6
LX2_ISL95338_2: PLS04.2 PQS08.5 PQS11.1 PQS11.2 PQS11.3 PRS31.2 PUS2.6
LX_3V: PC310.1 PL301.2 PQ301.1 PQ301.2 PQ301.3 PQ302.5 PR310.1 PU301.8
LX_5V: PC311.2 PL302.1 PQ303.1 PQ303.2 PQ303.3 PQ304.5 PR311.1 PU301.18
LX_CHG: PC721.2 PL700.1 PQ704.1 PQ704.2 PQ704.3 PQ708.5 PR766.1 PU703.22
LX_VCCIO: PCF06.2 PLF01.1 PRF04.1 PUF01.6 PUF01.19 PUF01.20
LX_VCCSA: PCA10.1 PLA01.1 PQA01.7 PRA04.1 PUA01.14
ME_EN: RH16.1 UE5.99
ME_SUS_PWR_ACK: RH506.1 UH1.BC37
MIC_CLK: JAUDIO.30 JDGFF1.H1
MIC_DATA12: JAUDIO.29 JDGFF1.H2
N17_ID0: RH27.1 RH28.1 UH1.AR18
N17_ID1: RH25.1 RH26.1 UH1.BF14
NC_B4: RT45.1 RT86.2 UT1.B4
NC_B5: RT46.1 UT1.B5
NC_G2: RT47.1 UT1.G2
NRB_BIT: RH524.2 UH1.BE30
NRST: CE8.1 JELC.10 QE59.1 RE4.1 RE691.2 UE1.7
NTC_CHG: PR757.2 PU703.17
OCSET_VCCSA: PCA11.2 PCA14.2 PRA06.1 PUA01.9
OCSET_VCCSA_C: PCA11.1 PCA14.1 PLA01.3 PRA13.1
OCSET_VCCSA_R: PLA01.2 PRA06.2
OFF_FWEN_1: PQS18.2 PRS77.1 UE5.48
OFF_FWEN_2: PQS19.2 PRS78.1 UE10.16
OFF_PMOS_1: PRS92.1 UE6.2
OFF_PMOS_2: PRS93.1 UE6.5
ON/OFF#: C1.1 C5360.1 JPWR.9 JPWR.10 RE63.2 SW2.1 SW2.2 SW3.1 SW3.2 UE5.114
OPCN_CHG: PC750.2 PU703.28
OSC24M_IN: RE18.2 UE1.5
OSC24M_IN_R: CE2.1 RE3.1 RE18.1 YE1.1
OSC24M_OUT: RE19.2 UE1.6
OSC24M_OUT_R: CE5.1 RE3.2 RE19.1 YE1.3
P1: PD704.3 PD706.2 PDS01.2 PQS10.5 PRS01.1 PRS06.1 PRS75.1
P2: PDS03.1 PJPS01.1 PJPS02.1 PLS01.1 PRS01.4
P3: PD704.2 PD706.3 PDS02.2 PQS15.5 PRS21.1 PRS26.2 PRS80.1
P4: PDS04.1 PJPS03.1 PJPS04.1 PLS10.1 PRS21.4
P_SYS: PR792.1 PRZ26.1
PA_USB2_RBIAS: RT43.1 UT1.H19
PB_USB2_RBIAS: RT44.1 UT1.F19
PBTN_OUT#: CH174.1 RH2.2 UE5.106 UH1.BE46
PCH_ACC1_INT1: RH619.2 RH622.2 RS11.1 UH1.AV34
PCH_BATLOW#: RH515.1 RT14.2 UH1.BF44
PCH_CPU_BCLK_N: UC1.W4 UH1.C8
PCH_CPU_BCLK_P: UC1.W5 UH1.B8
PCH_CPU_PCIBCLK_N: UC1.W2 UH1.B6
PCH_CPU_PCIBCLK_P: UC1.W1 UH1.A6
PCH_DP3_CTRL_DATA: RH601.2 UH1.AR3
PCH_DP4_CTRL_DATA: RH602.2 UH1.AN40
PCH_DPWROK: RH1017.1 UH1.AW41
PCH_GYRO_INT2: RH623.2 RH1015.2 RS12.1 UH1.AW32
PCH_JTAG_TCK: JPCMC.32 RC35.1 UC1.F11 UH1.AH4
PCH_PLTRST#: JDGFF1.D1 RH1024.1 UH1.AV29 UH3.1 UH3.2 UM3.2
PCH_PWR_EN: C268.1 JDGFF1.G6 PR104.1 PR1801.2 QH1.1 RE74.1 RH1016.1 RH1026.2 U18.4
PCH_PWROK: CE44.1 DE3.2 RE75.1 UE5.32 UH1.AY42
PCH_RTCRST#: CH53.1 CLRP1.1 QE5.6 RH84.2 UH1.BE47
PCH_RTCX1: CH45.1 RH70.1 UH1.BA49 YH1.1
PCH_RTCX2: CH46.1 RH70.2 UH1.BA48 YH1.2
PCH_SATADET#: RH512.1 RS17.1 UH1.AK48
PCH_SMBCLK: JDIMM1.253 JDIMM2.253 JDIMM3.253 JDIMM4.253 RE659.1 RH463.2 UH1.BE26 US1.4
PCH_SMBDATA: JDIMM1.254 JDIMM2.254 JDIMM3.254 JDIMM4.254 RE660.1 RH462.2 UH1.BF26 US1.6
PCH_SML1ALERT#: RH63.2 UH1.BD33
PCH_SPI_0_CLK: RH104.1 RH636.2 UH1.AW47
PCH_SPI_0_CLK_R: CH246.1 RH104.2 RH591.1 UH4.6
PCH_SPI_0_CS#: RH635.2 UH1.AY47 UH4.1
PCH_SPI_0_HOLD#: RH634.2 RPH5.4 UH1.BA46
PCH_SPI_0_HOLD#_R: RPH5.5 UH4.7
PCH_SPI_0_SI: RH1.2 RH631.2 RPH5.2 UH1.AU41
PCH_SPI_0_SI_R: RPH5.7 UH4.5
PCH_SPI_0_SO: RH632.2 RPH5.3 UH1.BA45
PCH_SPI_0_SO_R: RPH5.6 UH4.2
PCH_SPI_0_WP#: RC354.2 RH633.2 RPH5.1 UH1.AY48
PCH_SPI_0_WP#_R: RPH5.8 UH4.3
PCH_SRTCRST#: CH52.1 QE5.3 RH83.2 UH1.BD46
PCH_TRIGGER: RC692.1 UH1.AK3
PCH_XDP_CLK_N: T49.1(TP-1) UH1.Y3
PCH_XDP_CLK_P: T50.1(TP-1) UH1.Y4
PCIE_CRX_C_RD_TTX_N21: CT16.2 UT1.V22
PCIE_CRX_C_RD_TTX_N22: CT2.2 UT1.P22
PCIE_CRX_C_RD_TTX_N23: CT108.2 UT1.K22
PCIE_CRX_C_RD_TTX_N24: CT110.2 UT1.F22
PCIE_CRX_C_RD_TTX_P21: CT14.2 UT1.V23
PCIE_CRX_C_RD_TTX_P22: CT12.2 UT1.P23
PCIE_CRX_C_RD_TTX_P23: CT109.2 UT1.K23
PCIE_CRX_C_RD_TTX_P24: CT111.2 UT1.F23
PCIE_CRX_C_TTX_N21: CH262.1 UH1.T43
PCIE_CRX_C_TTX_N22: CH258.1 UH1.U40
PCIE_CRX_C_TTX_N23: CH254.1 UH1.W43
PCIE_CRX_C_TTX_N24: CH250.1 UH1.Y40
PCIE_CRX_C_TTX_P21: CH261.1 UH1.R44
PCIE_CRX_C_TTX_P22: CH257.1 UH1.U41
PCIE_CRX_C_TTX_P23: CH253.1 UH1.W44
PCIE_CRX_C_TTX_P24: CH249.1 UH1.Y41
PCIE_CRX_RD_TTX_N21: CT16.1 UT6.44
PCIE_CRX_RD_TTX_N22: CT2.1 UT6.42
PCIE_CRX_RD_TTX_N23: CT108.1 UT6.39
PCIE_CRX_RD_TTX_N24: CT110.1 UT6.37
PCIE_CRX_RD_TTX_P21: CT14.1 UT6.45
PCIE_CRX_RD_TTX_P22: CT12.1 UT6.43
PCIE_CRX_RD_TTX_P23: CT109.1 UT6.40
PCIE_CRX_RD_TTX_P24: CT111.1 UT6.38
PCIE_CRX_TTX_N21: CH262.2 UT6.2
PCIE_CRX_TTX_N22: CH258.2 UT6.4
PCIE_CRX_TTX_N23: CH254.2 UT6.6
PCIE_CRX_TTX_N24: CH250.2 UT6.8
PCIE_CRX_TTX_P21: CH261.2 UT6.1
PCIE_CRX_TTX_P22: CH257.2 UT6.3
PCIE_CRX_TTX_P23: CH253.2 UT6.5
PCIE_CRX_TTX_P24: CH249.2 UT6.7
PCIE_CTX_C_RD_TRX_N21: CT15.2 UT1.Y22
PCIE_CTX_C_RD_TRX_N22: CT13.2 UT1.T22
PCIE_CTX_C_RD_TRX_N23: CT18.2 UT1.M22
PCIE_CTX_C_RD_TRX_N24: CT21.2 UT1.H22
PCIE_CTX_C_RD_TRX_P21: CT3.2 UT1.Y23
PCIE_CTX_C_RD_TRX_P22: CT1.2 UT1.T23
PCIE_CTX_C_RD_TRX_P23: CT4.2 UT1.M23
PCIE_CTX_C_RD_TRX_P24: CT5.2 UT1.H23
PCIE_CTX_C_TRX_N21: CH260.1 UH1.G47
PCIE_CTX_C_TRX_N22: CH256.1 UH1.H47
PCIE_CTX_C_TRX_N23: CH252.1 UH1.G49
PCIE_CTX_C_TRX_N24: CH248.1 UH1.G46
PCIE_CTX_C_TRX_P21: CH259.1 UH1.F46
PCIE_CTX_C_TRX_P22: CH255.1 UH1.H48
PCIE_CTX_C_TRX_P23: CH251.1 UH1.G48
PCIE_CTX_C_TRX_P24: CH247.1 UH1.G45
PCIE_CTX_RD_TRX_N21: CT15.1 UT6.34
PCIE_CTX_RD_TRX_N22: CT13.1 UT6.32
PCIE_CTX_RD_TRX_N23: CT18.1 UT6.30
PCIE_CTX_RD_TRX_N24: CT21.1 UT6.28
PCIE_CTX_RD_TRX_P21: CT3.1 UT6.35
PCIE_CTX_RD_TRX_P22: CT1.1 UT6.33
PCIE_CTX_RD_TRX_P23: CT4.1 UT6.31
PCIE_CTX_RD_TRX_P24: CT5.1 UT6.29
PCIE_CTX_TRX_N21: CH260.2 UT6.11
PCIE_CTX_TRX_N22: CH256.2 UT6.13
PCIE_CTX_TRX_N23: CH252.2 UT6.16
PCIE_CTX_TRX_N24: CH248.2 UT6.18
PCIE_CTX_TRX_P21: CH259.2 UT6.10
PCIE_CTX_TRX_P22: CH255.2 UT6.12
PCIE_CTX_TRX_P23: CH251.2 UT6.15
PCIE_CTX_TRX_P24: CH247.2 UT6.17
PCIE_PRX_C_DTX_N15: CL6.1 UL1.56
PCIE_PRX_C_DTX_P15: CL5.1 UL1.57
PCIE_PRX_DTX_N9: JSSD2.5 UH1.G36
PCIE_PRX_DTX_N10: JSSD2.17 UH1.K37
PCIE_PRX_DTX_N11: JSSD2.29 UH1.G38
PCIE_PRX_DTX_N12: JSSD2.43 UH1.H42
PCIE_PRX_DTX_N15: CL6.2 UH1.F44
PCIE_PRX_DTX_N16: JWLAN.43 UH1.L41
PCIE_PRX_DTX_N17: JSSD1.43 UH1.K43
PCIE_PRX_DTX_N18: JSSD1.29 UH1.P41
PCIE_PRX_DTX_N19: JSSD1.17 UH1.M44
PCIE_PRX_DTX_N20: JSSD1.5 UH1.R35
PCIE_PRX_DTX_P9: JSSD2.7 UH1.F36
PCIE_PRX_DTX_P10: JSSD2.19 UH1.J37
PCIE_PRX_DTX_P11: JSSD2.31 UH1.F39
PCIE_PRX_DTX_P12: JSSD2.41 UH1.J41
PCIE_PRX_DTX_P15: CL5.2 UH1.E45
PCIE_PRX_DTX_P16: JWLAN.41 UH1.M40
PCIE_PRX_DTX_P17: JSSD1.41 UH1.K44
PCIE_PRX_DTX_P18: JSSD1.31 UH1.R40
PCIE_PRX_DTX_P19: JSSD1.19 UH1.N42
PCIE_PRX_DTX_P20: JSSD1.7 UH1.R37
PCIE_PTX_C_DRX_N9: CH202.1 JSSD2.13
PCIE_PTX_C_DRX_N10: CH204.1 JSSD2.25
PCIE_PTX_C_DRX_N11: CH207.2 JSSD2.35
PCIE_PTX_C_DRX_N12: CH209.2 JSSD2.47
PCIE_PTX_C_DRX_N15: CL8.1 UL1.62
PCIE_PTX_C_DRX_N16: CN7.1 JWLAN.37
PCIE_PTX_C_DRX_N17: CH210.1 JSSD1.47
PCIE_PTX_C_DRX_N18: CH212.1 JSSD1.35
PCIE_PTX_C_DRX_N19: CH214.2 JSSD1.23
PCIE_PTX_C_DRX_N20: CH216.2 JSSD1.11
PCIE_PTX_C_DRX_P9: CH203.1 JSSD2.11
PCIE_PTX_C_DRX_P10: CH205.1 JSSD2.23
PCIE_PTX_C_DRX_P11: CH206.2 JSSD2.37
PCIE_PTX_C_DRX_P12: CH208.2 JSSD2.49
PCIE_PTX_C_DRX_P15: CL7.1 UL1.61
PCIE_PTX_C_DRX_P16: CN6.1 JWLAN.35
PCIE_PTX_C_DRX_P17: CH211.1 JSSD1.49
PCIE_PTX_C_DRX_P18: CH213.1 JSSD1.37
PCIE_PTX_C_DRX_P19: CH215.2 JSSD1.25
PCIE_PTX_C_DRX_P20: CH217.2 JSSD1.13
PCIE_PTX_DRX_N9: CH202.2 UH1.C34
PCIE_PTX_DRX_N10: CH204.2 UH1.C35
PCIE_PTX_DRX_N11: CH207.1 UH1.B36
PCIE_PTX_DRX_N12: CH209.1 UH1.D38
PCIE_PTX_DRX_N15: CL8.2 UH1.B40
PCIE_PTX_DRX_N16: CN7.2 UH1.B41
PCIE_PTX_DRX_N17: CH210.2 UH1.A42
PCIE_PTX_DRX_N18: CH212.2 UH1.C42
PCIE_PTX_DRX_N19: CH214.1 UH1.C44
PCIE_PTX_DRX_N20: CH216.1 UH1.A44
PCIE_PTX_DRX_P9: CH203.2 UH1.D34
PCIE_PTX_DRX_P10: CH205.2 UH1.B35
PCIE_PTX_DRX_P11: CH206.1 UH1.C36
PCIE_PTX_DRX_P12: CH208.1 UH1.E37
PCIE_PTX_DRX_P15: CL7.2 UH1.C40
PCIE_PTX_DRX_P16: CN6.2 UH1.C41
PCIE_PTX_DRX_P17: CH211.2 UH1.B42
PCIE_PTX_DRX_P18: CH213.2 UH1.D42
PCIE_PTX_DRX_P19: CH215.1 UH1.D43
PCIE_PTX_DRX_P20: CH217.1 UH1.B44
PCIE_RBIAS: RT3.1 UT1.N16
PCIE_RCOMPN: RH193.1 UH1.B12
PCIE_RCOMPP: RH193.2 UH1.A13
PCIE_WAKE#: RH4.1 RL6.2 UE5.64 UL1.43
PCIRST#: JSSD1.50 JSSD2.50 JWLAN.52 RE681.1 RH199.1 RL8.2 RT1.2 UH3.4 UL1.45 UT3.1
PCIRST_R#: CE34.1 RE681.2 UE5.13
PD_EE_CLK: RT101.2 UT4.A3
PD_EE_CS_N: RT100.2 UT4.B3
PD_EE_DI: RT98.2 UT4.B4
PD_EE_DO: RT99.2 UT4.A4
PD_IRQ#: RT107.2 RT732.2 UE5.89 UT4.B6
PD_RESET: RT109.1 UE10.8
PD_UART: RT62.1 UT4.E2 UT4.F2
PEG_CRX_C_GTX_N0: CV1100.2 JDGFF2.F8
PEG_CRX_C_GTX_N1: CV1096.2 JDGFF2.G9
PEG_CRX_C_GTX_N2: CV1098.2 JDGFF2.F5
PEG_CRX_C_GTX_N3: CV1094.2 JDGFF2.G6
PEG_CRX_C_GTX_N4: CV1092.2 JDGFF2.G3
PEG_CRX_C_GTX_N5: CV1090.2 JDGFF2.H8
PEG_CRX_C_GTX_N6: CV1088.2 JDGFF2.H5
PEG_CRX_C_GTX_N7: CV1086.2 JDGFF2.H2
PEG_CRX_C_GTX_P0: CV1099.2 JDGFF2.F7
PEG_CRX_C_GTX_P1: CV1095.2 JDGFF2.G8
PEG_CRX_C_GTX_P2: CV1097.2 JDGFF2.F4
PEG_CRX_C_GTX_P3: CV1093.2 JDGFF2.G5
PEG_CRX_C_GTX_P4: CV1091.2 JDGFF2.G2
PEG_CRX_C_GTX_P5: CV1089.2 JDGFF2.H7
PEG_CRX_C_GTX_P6: CV1087.2 JDGFF2.H4
PEG_CRX_C_GTX_P7: CV64.2 JDGFF2.H1
PEG_CRX_C_RD_GTX_N8: CM69.2 UM8.4
PEG_CRX_C_RD_GTX_N9: CM66.2 UM8.8
PEG_CRX_C_RD_GTX_N10: CM62.2 UM8.6
PEG_CRX_C_RD_GTX_N11: CM65.2 UM8.2
PEG_CRX_C_RD_GTX_P8: CM67.2 UM8.3
PEG_CRX_C_RD_GTX_P9: CM63.2 UM8.7
PEG_CRX_C_RD_GTX_P10: CM68.2 UM8.5
PEG_CRX_C_RD_GTX_P11: CM64.2 UM8.1
PEG_CRX_GTX_N0: CV1100.1 UC1.U4
PEG_CRX_GTX_N1: CV1096.1 UC1.T5
PEG_CRX_GTX_N2: CV1098.1 UC1.R4
PEG_CRX_GTX_N3: CV1094.1 UC1.P5
PEG_CRX_GTX_N4: CV1092.1 UC1.N4
PEG_CRX_GTX_N5: CV1090.1 UC1.M5
PEG_CRX_GTX_N6: CV1088.1 UC1.L4
PEG_CRX_GTX_N7: CV1086.1 UC1.K5
PEG_CRX_GTX_N8: CM69.1 UC1.J4
PEG_CRX_GTX_N9: CM66.1 UC1.H5
PEG_CRX_GTX_N10: CM62.1 UC1.G4
PEG_CRX_GTX_N11: CM65.1 UC1.F5
PEG_CRX_GTX_P0: CV1099.1 UC1.U5
PEG_CRX_GTX_P1: CV1095.1 UC1.T6
PEG_CRX_GTX_P2: CV1097.1 UC1.R5
PEG_CRX_GTX_P3: CV1093.1 UC1.P6
PEG_CRX_GTX_P4: CV1091.1 UC1.N5
PEG_CRX_GTX_P5: CV1089.1 UC1.M6
PEG_CRX_GTX_P6: CV1087.1 UC1.L5
PEG_CRX_GTX_P7: CV64.1 UC1.K6
PEG_CRX_GTX_P8: CM67.1 UC1.J5
PEG_CRX_GTX_P9: CM63.1 UC1.H6
PEG_CRX_GTX_P10: CM68.1 UC1.G5
PEG_CRX_GTX_P11: CM64.1 UC1.F6
PEG_CRX_RD_GTX_N8: JCDRA.16 UM8.42
PEG_CRX_RD_GTX_N9: JCDRA.19 UM8.37
PEG_CRX_RD_GTX_N10: JCDRA.25 UM8.39
PEG_CRX_RD_GTX_N11: JCDRA.31 UM8.44
PEG_CRX_RD_GTX_P8: JCDRA.15 UM8.43
PEG_CRX_RD_GTX_P9: JCDRA.18 UM8.38
PEG_CRX_RD_GTX_P10: JCDRA.24 UM8.40
PEG_CRX_RD_GTX_P11: JCDRA.30 UM8.45
PEG_CTX_C_GRX_N0: CC7.2 JDGFF2.A8
PEG_CTX_C_GRX_N1: CC9.2 JDGFF2.A5
PEG_CTX_C_GRX_N2: CC11.2 JDGFF2.B6
PEG_CTX_C_GRX_N3: CC13.2 JDGFF2.A2
PEG_CTX_C_GRX_N4: CC15.2 JDGFF2.B9
PEG_CTX_C_GRX_N5: CC17.2 JDGFF2.B3
PEG_CTX_C_GRX_N6: CC19.2 JDGFF2.C5
PEG_CTX_C_GRX_N7: CC21.2 JDGFF2.C8
PEG_CTX_C_GRX_N8: CC60.2 JCDRA.4
PEG_CTX_C_GRX_N9: CC56.2 JCDRA.7
PEG_CTX_C_GRX_N10: CC62.2 JCDRA.10
PEG_CTX_C_GRX_N11: CC63.2 JCDRA.13
PEG_CTX_C_GRX_P0: CC6.2 JDGFF2.A7
PEG_CTX_C_GRX_P1: CC8.2 JDGFF2.A4
PEG_CTX_C_GRX_P2: CC10.2 JDGFF2.B5
PEG_CTX_C_GRX_P3: CC12.2 JDGFF2.A1
PEG_CTX_C_GRX_P4: CC14.2 JDGFF2.B8
PEG_CTX_C_GRX_P5: CC16.2 JDGFF2.B2
PEG_CTX_C_GRX_P6: CC18.2 JDGFF2.C4
PEG_CTX_C_GRX_P7: CC20.2 JDGFF2.C7
PEG_CTX_C_GRX_P8: CC57.2 JCDRA.3
PEG_CTX_C_GRX_P9: CC59.2 JCDRA.6
PEG_CTX_C_GRX_P10: CC61.2 JCDRA.9
PEG_CTX_C_GRX_P11: CC58.2 JCDRA.12
PEG_CTX_GRX_N0: CC7.1 UC1.T3
PEG_CTX_GRX_N1: CC9.1 UC1.R1
PEG_CTX_GRX_N2: CC11.1 UC1.P3
PEG_CTX_GRX_N3: CC13.1 UC1.N2
PEG_CTX_GRX_N4: CC15.1 UC1.M3
PEG_CTX_GRX_N5: CC17.1 UC1.L2
PEG_CTX_GRX_N6: CC19.1 UC1.K3
PEG_CTX_GRX_N7: CC21.1 UC1.J2
PEG_CTX_GRX_N8: CC60.1 UC1.H3
PEG_CTX_GRX_N9: CC56.1 UC1.G2
PEG_CTX_GRX_N10: CC62.1 UC1.F3
PEG_CTX_GRX_N11: CC63.1 UC1.E2
PEG_CTX_GRX_P0: CC6.1 UC1.T2
PEG_CTX_GRX_P1: CC8.1 UC1.R2
PEG_CTX_GRX_P2: CC10.1 UC1.P2
PEG_CTX_GRX_P3: CC12.1 UC1.N1
PEG_CTX_GRX_P4: CC14.1 UC1.M2
PEG_CTX_GRX_P5: CC16.1 UC1.L1
PEG_CTX_GRX_P6: CC18.1 UC1.K2
PEG_CTX_GRX_P7: CC20.1 UC1.J1
PEG_CTX_GRX_P8: CC57.1 UC1.H2
PEG_CTX_GRX_P9: CC59.1 UC1.G1
PEG_CTX_GRX_P10: CC61.1 UC1.F2
PEG_CTX_GRX_P11: CC58.1 UC1.E1
PEG_RCOMP: RC14.2 UC1.L7
PEX_RST#: JDGFF1.A4 UH1.BB16
PGOOD_1.2V: PR210.2 PU201.10
PGOOD_VCCSA: PRA20.2 PUA01.12
PM_DOWN_R: RC5.1 UC1.D8
PM_SLP_S3#: PQ710.2 PRS98.1 Q8.2 QE1.5 RC685.2 RE679.1 UH1.BF42
PM_SLP_S3_H: Q7.2 Q7.5 Q8.5 Q8.6 R307.2
PM_SLP_S3_R#: CE41.1 RE679.2 UE5.6
PM_SLP_S4#: PR2501.2 Q9.2 RE680.1 UH1.BE42
PM_SLP_S4_H: Q9.5 Q9.6 R325.2
PM_SLP_S4_R#: RE680.2 UE5.73
PM_SLP_S5#: QE4.5 RE678.1 UH1.BC42
PM_SLP_S5_R#: CE45.1 RE678.2 UE5.108
POK: DE2.1 DE3.1 PU301.7
POW_EXT_SWR: UL1.67 UL13.7
POW_MODE1: RL3.2 RL4.2 UL1.68
POWER_LED: QE4.6 QE8.2 RE28.2
PQ6A_GATE: PC15.2 PQ6.2 PQ11.2 PR21.1
PQ10A_GATE: PC25.2 PQ10.2 PQ12.2 PR41.1
PQS32_2: PQS32.2 PRS98.2 PRS99.2
PROC_DETECT#: RC356.1 UH1.AP41
PROC_SELECT#: TC2.1(TP-1) UC1.AB36
PROCHOT#_CHG: PR777.2 PU703.5
PROG_CHG: PR753.2 PU703.9
PROG_ISL95338_1: PRS18.2 PUS1.27
PROG_ISL95338_2: PRS38.2 PUS2.27
PS_ID_1: PR3.2 PR4.2 UE5.16
PS_ID_2: PR8.2 PR9.2 UE5.19
PSID_1: PJPDC1.1 PL6.1
PSID_1-1: PD1.2 PL6.2 PQ1.1 PR1.1
PSID_1-2: PQ2.2 PR1.2 PR2.1
PSID_1-3: PQ1.3 PR3.1
PSID_1-4: PQ1.2 PQ2.1 PR5.1
PSID_2: PJPDC2.1 PL12.1
PSID_2-1: PD2.2 PL12.2 PQ3.1 PR6.1
PSID_2-2: PQ4.2 PR6.2 PR7.1
PSID_2-3: PQ3.3 PR8.1
PSID_2-4: PQ3.2 PQ4.1 PR10.1
PSYS_CHG: PR727.1 PR792.2 PU703.8
PTP_KBBL#: JTP.8 RE663.2 RE703.1
PTP_LID_CLOSE#: JTP.7 RE33.2 UE10.17
PWM1_GT: PRG01.1 PUZ01.12
PWM1_IA: PRI13.1 PRI209.2
PWM1_VCORE: PRI206.1 PUZ01.25
PWM2_GT: PRG14.1 PUZ01.13
PWM2_IA: PRI28.1 PRI205.2
PWM2_VCORE: PRI213.1 PUZ01.26
PWM3_IA: PRI53.1 PRI212.2
PWM3_VCORE: PRI225.1 PUZ01.27
PWM4_IA: PRI68.1 PRI219.2
PWM5_IA: PRI93.1 PRI224.2
PWM6_IA: PRI108.1 PRI222.2
PWR_B#: JPWR.7 JPWR.8 QE13.3 RE154.2 RE160.1
PWR_B_7313#: QE13.4 UE3.14
PWR_B_EC: QE13.2 UE5.52
PWR_G#: JPWR.5 JPWR.6 QE21.3 RE155.1 RE156.2
PWR_G_7313#: QE21.4 UE3.11
PWR_LED#: QE4.2 UE5.92
PWR_R#: JPWR.3 JPWR.4 QE22.3 RE157.1 RE158.2
PWR_R_7313#: QE22.4 UE3.10
PWR_R_EC: QE22.2 UE5.57
PWRSHARE_EN_EC#: UE5.50 UU1.5
QPCP_CHG: PC750.1 PU703.27
REF_ISL95338_1: PCS28.1 PUS1.29
REF_ISL95338_2: PCS57.1 PUS2.29
REFCLK_CNV: RN113.2 RN117.2
REFCLK_CNV_H: RH628.2 RN117.1 UH1.R6
REFCLK_CNV_R: JWLAN.64 RN113.1
REMOTE1+: C2500.1 C2502.1 Q2407.1 Q2407.2 U2407.2
REMOTE1-: C2500.2 C2502.2 Q2407.3 R412.1
REMOTE2+: C2510.1 JDGFF1.G3 U2407.4
REMOTE2-: C2510.2 JDGFF1.G2 R412.2 U2407.3
REMOTE3+: C2511.1 C5361.1 Q2411.1 Q2411.2 U2407.5
REMOTE3-: C2511.2 C5361.2 Q2411.3 R185.2
REMOTE4+: C2532.1 C2533.1 Q2412.1 Q2412.2 U2408.2
REMOTE4-: C2532.2 C2533.2 Q2412.3 U2408.3
RESET_N: RT102.1 UT4.F11
RF_+1VALWP: PR106.1 PU101.5
RJ45_CT: CL10.2 RL15.2 RL16.2 RL17.2 RL18.2
RJ45_CT0: RL18.1 UL2.15
RJ45_CT1: RL17.1 UL2.18
RJ45_CT2: RL16.1 UL2.21
RJ45_CT3: RL15.1 UL2.24
RJ45_MDIN0: JLAN.2 UL2.23
RJ45_MDIN1: JLAN.6 UL2.20
RJ45_MDIN2: JLAN.5 UL2.17
RJ45_MDIN3: JLAN.8 UL2.14
RJ45_MDIP0: JLAN.1 UL2.22
RJ45_MDIP1: JLAN.3 UL2.19
RJ45_MDIP2: JLAN.4 UL2.16
RJ45_MDIP3: JLAN.7 UL2.13
RPD_G1: RT64.1 UT4.K9
RPD_G2: RT65.1 UT4.K10
RSVD8: TC17.1(TP-1) UC1.AV1
RSVD9: TC18.1(TP-1) UC1.AW2
RSVD20: TC19.1(TP-1) UC1.K10
RSVD24: TC14.1(TP-1) UC1.L10
RSVD_TP1: TC15.1(TP-1) UC1.J7
RSVD_TP2: TC16.1(TP-1) UC1.J8
RSVD_TP3: TC12.1(TP-1) UC1.K8
RTC_CELL: QE58.2 RE662.1 UE10.22
RTD3_CIO_PWR_EN: RT16.2 UH1.BF21
RTD3_CIO_PWR_EN_R: RT16.1 RT36.2 RT726.1 UT1.F1
RTD3_USB_PWR_EN: RT12.2 UH1.BE21
RTD3_USB_PWR_EN_R: RT12.1 RT37.1 UT1.D4
RTN_VCCSA: PRA10.1 PRA11.2 PUA01.1
SA0_DIM1: JDIMM1.256 RD1.1 RD4.2
SA0_DIM2: JDIMM3.256 RD12.1 RD15.2
SA0_DIM3: JDIMM2.256 RD26.1 RD29.2
SA0_DIM4: JDIMM4.256 RD38.1 RD41.2
SA1_DIM1: JDIMM1.260 RD2.1 RD5.2
SA1_DIM2: JDIMM3.260 RD13.1 RD16.2
SA1_DIM3: JDIMM2.260 RD27.1 RD30.2
SA1_DIM4: JDIMM4.260 RD39.1 RD42.2
SA2_DIM1: JDIMM1.166 RD3.1 RD6.2
SA2_DIM2: JDIMM3.166 RD14.1 RD17.2
SA2_DIM3: JDIMM2.166 RD28.1 RD31.2
SA2_DIM4: JDIMM4.166 RD40.1 RD43.2
SA_DIMM_VREFDQ: TC7.1(TP-1) UC1.AC40
SATA_GP0: JHDD.9 RS2.1 UH1.AH41
SATA_GP1: JSSD2.69 R365.1 UH1.AJ43
SATA_GP4: JSSD1.69 R363.1 UH1.AM46
SATA_PRX_C_DTX_N0: CH229.1 JHDD.1
SATA_PRX_C_DTX_P0: CH230.1 JHDD.2
SATA_PRX_DTX_N0: CH229.2 UH1.C45
SATA_PRX_DTX_P0: CH230.2 UH1.C46
SATA_PTX_C_DRX_N0: CH227.1 JHDD.4
SATA_PTX_C_DRX_P0: CH228.1 JHDD.5
SATA_PTX_DRX_N0: CH227.2 UH1.B38
SATA_PTX_DRX_P0: CH228.2 UH1.C38
SCL_CHG: PR770.2 PU703.4
SCL_ISL95338_1: PRS12.2 PRS14.2 PUS1.22
SCL_ISL95338_2: PRS32.2 PRS34.2 PUS2.22
SD_RCOMP_1P8: RH214.1 UH1.BE5
SD_RCOMP_3P3: RH215.1 UH1.BE4
SDA_CHG: PR769.2 PU703.3
SDA_ISL95338_1: PRS10.2 PRS15.2 PUS1.21
SDA_ISL95338_2: PRS30.2 PRS35.2 PUS2.21
SENSE_VCCIO: PRF05.2 PRF07.1 PRF08.1
SET0_VCCSA: PRA05.1 PRA09.2 PUA01.5
SET1_VCCSA: PRA09.1 PRA12.2 PUA01.6
SET2_VCCSA: PRA12.1 PRA15.2 PUA01.7
SLP_S3: QE1.3 RE15.2 UE1.12
SLP_S5: QE4.3 RE16.2 UE1.11
SM_PG_CTRL: PR211.2 RC684.1 RC685.1
SMBALERT#: RH95.2 UH1.BE25
SML0ALERT#: RH1023.2 UH1.BF24
SML0CLK: RH501.2 UH1.BF25 UM4.11
SML0DATA: RH502.2 UH1.BE24 UM4.10
SML1CLK: QH5.6 RH460.2 UH1.BF27
SML1DATA: QH5.3 RH461.2 UH1.BE27
SNB_1.2V: PC211.1 PR202.2
SNB_3V: PC316.1 PR310.2
SNB_5V: PC317.1 PR311.2
SNB_+1VALWP: PC112.1 PR105.2
SNB_VCCIO: PCF14.1 PRF04.2
SPI_CLK: RE11.2 UE1.15
SPI_CLK_R: CE173.1 RE11.1 UE2.6
SPI_CS#: RE12.2 UE1.14 UE2.1
SPI_MISO: RE10.2 UE1.16
SPI_MOSI: RE9.2 UE1.17
SPK_SEL: JAUDIO.11 RE201.2 UE5.44
SREF_VCCSA: PCA13.1 PRA05.2 PUA01.4
STRAP3_PCH: JDGFF1.E1 RG555.2 UH1.M45
STRAP5_PCH: JDGFF1.G5 RG556.2 UH1.L48
SUSACK#: QH1.3 RH1016.2 RH1027.1 UH1.BE35
SUSCLK: JSSD1.68 JSSD2.68 JWLAN.50 UH1.BE45
SUSP#: CE205.1 JAUDIO.9 PR209.2 PRF01.1 Q8.3 R174.1 R182.1 RT15.2 U16.4 UE5.116 UE13.4 UZ21.3
SUSP#_R: RT15.1 RT30.2 UT1.D2
SW_1.2V: PC204.2 PL201.2 PQ200.1 PQ200.2 PQ200.3 PQ201.5 PR202.1 PU201.16
SW_+1VALWP: PC107.2 PL101.1 PQ101.1 PQ101.2 PQ101.3 PQ102.5 PR105.1 PU101.8
SWR_18_PG: RL23.2 UL11.2
SWR_25_PG: RL20.2 UL10.2 UL11.7
SWTRAP: RE684.2 RE685.1 UE5.70
SYS_PWROK: CE46.1 UE5.74 UH1.AU3
SYS_RESET#: CH175.1 RH5.2 RH571.1 UH1.AU2
SYS_SWCLK: JELC.4 UE1.37
SYS_SWDIO: JELC.2 UE1.34
SYSON: CE42.2 PR208.1 Q9.3 U19.4 UE5.95
TBT_A_AUX_N: CT44.2 UT1.W15
TBT_A_AUX_N_C: CT44.1 RT70.2 UT4.J2
TBT_A_AUX_P: CT43.2 UT1.Y15
TBT_A_AUX_P_C: CT43.1 RT73.1 UT4.J1
TBT_A_CC1: CT112.1 DT11.1 JUSBC.B5 UT4.L9
TBT_A_CC2: CT113.1 DT12.1 JUSBC.A5 UT4.L10
TBT_A_SBU1: DT13.1 JUSBC.B8 UT4.K8
TBT_A_SBU2: DT14.1 JUSBC.A8 UT4.L8
TBT_A_TRX_DTX_N0: DT5.1 JUSBC.A10 UT1.A21
TBT_A_TRX_DTX_N1: DT9.1 JUSBC.B10 UT1.B15
TBT_A_TRX_DTX_P0: DT4.1 JUSBC.A11 UT1.B21
TBT_A_TRX_DTX_P1: DT8.1 JUSBC.B11 UT1.A15
TBT_A_TTX_C_DRX_N0: CT42.1 DT3.1 JUSBC.B3
TBT_A_TTX_C_DRX_N1: CT40.1 DT7.1 JUSBC.A3
TBT_A_TTX_C_DRX_P0: CT41.1 DT2.1 JUSBC.B2
TBT_A_TTX_C_DRX_P1: CT39.1 DT6.1 JUSBC.A2
TBT_A_TTX_DRX_N0: CT42.2 UT1.B19
TBT_A_TTX_DRX_N1: CT40.2 UT1.B17
TBT_A_TTX_DRX_P0: CT41.2 UT1.A19
TBT_A_TTX_DRX_P1: CT39.2 UT1.A17
TBT_A_USB20_L_NB: DT10.4 DT10.7 JUSBC.A7 LT3.3
TBT_A_USB20_L_NT: DT10.1 DT10.9 JUSBC.B7 LT2.3
TBT_A_USB20_L_PB: DT10.5 DT10.6 JUSBC.A6 LT3.2
TBT_A_USB20_L_PT: DT10.2 DT10.8 JUSBC.B6 LT2.2
TBT_A_USB20_N: RT112.1 UT1.D20
TBT_A_USB20_NB: LT3.4 UT4.L7
TBT_A_USB20_NT: LT2.4 UT4.L6
TBT_A_USB20_P: RT113.1 UT1.E20
TBT_A_USB20_PB: LT3.1 UT4.K7
TBT_A_USB20_PT: LT2.1 UT4.K6
TBT_CIO_PLUG_EVENT#: RT29.2 UH1.AV21 UT1.W2
TBT_DEMA0: RT233.2 RT234.2 RT710.1 UT6.49
TBT_DEMA1: RT235.2 RT236.2 RT709.1 UT6.50
TBT_DEMB0: RT237.2 RT239.2 UT6.53
TBT_DEMB1: RT238.2 RT240.2 UT6.54
TBT_EE_CLK: RT52.2 RT101.1 RT122.1 UT2.6
TBT_EE_CLK_R: RT52.1 UT1.AB4
TBT_EE_CS_N: RT50.2 RT100.1 UT1.AC3 UT2.1
TBT_EE_DI: RT98.1 UT1.AB3 UT2.5
TBT_EE_DO: RT49.2 RT99.1 UT1.AC4 UT2.2
TBT_EE_WP_N: RT48.2 UT1.V1 UT2.3
TBT_ENSMB: RT220.2 RT221.2 UT6.48
TBT_EQA0: RT226.2 RT230.2 UT6.20
TBT_EQA1: RT229.2 RT231.2 UT6.19
TBT_EQB0: RT225.2 RT227.2 UT6.46
TBT_EQB1: RT224.2 RT228.2 UT6.47
TBT_FORCE_PWR: RT13.2 UH1.Y47
TBT_FORCE_PWR_R: RT13.1 RT35.1 RT94.2 UT1.H4
TBT_HOLD_N: RT51.2 UT2.7
TBT_I2C_SCL: RT27.2 RT721.1 UT1.U2
TBT_I2C_SCL_R: RT721.2 UT4.D2
TBT_I2C_SDA: RT26.2 RT720.1 UT1.U1
TBT_I2C_SDA_R: RT720.2 UT4.D1
TBT_PCIE_WAKE#: RH1018.1 RT10.2 UE5.127
TBT_PCIE_WAKE_N: RT10.1 RT28.2 RT694.1 UT1.W1
TBT_PRSNT: QE65.1 RT222.2 RT223.1 UT6.52
TBT_RBIAS: RT25.1 UT1.H6
TBT_RESET_N: RT23.1 RT80.1 RT102.2 UT1.F4
TBT_RESET_N_EC: RT23.2 RT708.1 UE10.19
TBT_RSENSE: RT25.2 UT1.J6
TBT_RST#_R: QE65.2 RT1.1 RT693.1 RT723.2 RT733.1 UT1.L4 UT3.4
TBT_RTD3_RST#: RT695.2 RT733.2 UH1.AU24 UT3.2
TBT_RXDET: RT218.2 RT219.1 UT6.22
TBT_S5_OFF#: CT123.1 UE10.21 UT8.4
TBT_SDTH: RT216.1 RT217.2 RT708.2 UT6.26
TBT_SRC_CFG1: RT11.1 UT1.AA1
TBT_SRC_HPD: RT4.1 UT1.G1
TBT_SVR_IND: LT1.1 UT1.C1 UT1.C2 UT1.D1
TBT_TCK: RT7.2 UT1.T4
TBT_TDI: RT9.2 UT1.Y4
TBT_TDO: RT6.2 UT1.W4
TBT_TEST_EN: RT17.1 UT1.E1
TBT_TEST_PWG: RT18.1 UT1.AB5
TBT_TMS: RT8.2 UT1.V4
TBT_TMU_CLK_OUT: RT34.1 T2.1(TP-1) UT1.V2
TBT_XTAL_25_IN: RT116.1 UT1.D22
TBT_XTAL_25_OUT: RT117.1 UT1.D23
TBTA_DEBUG1: RT71.1 UT4.L2
TBTA_DEBUG2: RT72.1 UT4.K2
TBTA_DIG_AUD_N: RT69.1 UT4.K3
TBTA_DIG_AUD_P: RT68.1 UT4.L3
TBTA_HPD: RT41.1 UT1.M4 UT4.C10
TBTA_I2C_INT: RT32.2 RT722.1 UT1.J4
TBTA_I2C_INT_R: RT722.2 UT4.C1
TBTA_I2C_SCL1_R: RT60.2 UT4.B5
TBTA_I2C_SDA1_R: RT59.2 UT4.A5
TBTA_LDO_BMC: CT98.1 UT4.E1
TBTA_LSRX: RT42.1 UT1.A4 UT4.K4
TBTA_LSTX: RT21.2 RT40.1 UT1.A5 UT4.L4
TBTA_MRESET: RT63.1 UT4.E11
TBTA_ROSC: RT75.1 UT4.G2
TBTB_I2C_INT: RT33.2 UT1.E2
THERM#: R410.1 U2408.4
THERMDA: UT1.AB23 UT1.AC23
THERMTRIP#_R: R395.2 UC1.D11
TOBII_INT#: JTOBII.1 RE300.1 RE651.1
TOBII_PWR_EN#: CE79.1 RE652.2 UE5.41 UE12.4
TON_1.2V: PR206.2 PU201.9
TP_CLK: RE100.2 RE654.1 UE5.87
TP_CLK_R: JTP.5 RE654.2
TP_DATA: RE101.2 RE655.1 UE5.88
TP_DATA_R: JTP.4 RE655.2
TP_DIMM1_CHA_S2#: JDIMM1.162 TD1.1(TP-1)
TP_DIMM1_CHA_S3#: JDIMM1.165 TD2.1(TP-1)
TP_DIMM2_CHA_S2#: JDIMM3.162 TD3.1(TP-1)
TP_DIMM2_CHA_S3#: JDIMM3.165 TD4.1(TP-1)
TP_DIMM3_CHB_S2#: JDIMM2.162 TD5.1(TP-1)
TP_DIMM3_CHB_S3#: JDIMM2.165 TD6.1(TP-1)
TP_DIMM4_CHB_S2#: JDIMM4.162 TD7.1(TP-1)
TP_DIMM4_CHB_S3#: JDIMM4.165 TD8.1(TP-1)
TP_EN: CT114.1 QT2.2 UE5.81 UT5.3
TP_INT#: JTP.9 RE661.2 UE5.38 UH1.BE15
TP_LED_B#_DRV#: JTP.14 UE3.9
TP_LED_EN: Q2410.2 UE5.25
TP_LED_G#_DRV#: JTP.13 UE3.8
TP_LED_R#_DRV#: JTP.12 UE3.6
TRIP_+1VALWP: PR103.2 PU101.2
TRONB_LED_B_DRV#: JTRON.9 JTRON.19 UE3.21
TRONB_LED_G_DRV#: JTRON.7 JTRON.17 UE3.20
TRONB_LED_R_DRV#: JTRON.5 JTRON.15 UE3.19
TRONT_LED_B_DRV#: JTRON.10 JTRON.20 UE3.17
TRONT_LED_G_DRV#: JTRON.8 JTRON.18 UE3.16
TRONT_LED_R_DRV#: JTRON.6 JTRON.16 UE3.15
TS_EN: JDGFF1.F8 UE5.54
UART_2_PRXD_DTXD: JWDB.3 RC62.1 RN1.1 UH1.BD20
UART_2_PTXD_DRXD: JWDB.2 RC63.1 RN120.1 UH1.BE20
UG1_ISL95338_1: PQS01.4 PQS03.4 PUS1.11
UG1_ISL95338_2: PQS07.4 PQS09.4 PUS2.11
UG2_ISL95338_1: PQS05.4 PUS1.5
UG2_ISL95338_2: PQS11.4 PUS2.5
UG_3V: PQ301.4 PU301.10
UG_5V: PQ303.4 PU301.16
UG_+1VALWP: PQ101.4 PU101.9
UG_CHG: PR761.1 PU703.23
UG_CHG_R: PQ704.4 PR761.2
UG_VCCSA: PQA01.1 PUA01.15
USB2_COMP: RH109.1 UH1.F4
USB3_A_DE0: R372.2 R407.2 UU6.16
USB3_A_DE1: R374.2 R399.2 UU6.18
USB3_A_EQ0: R373.2 R400.2 UU6.17
USB3_A_EQ1: R371.2 R406.2 UU6.15
USB3_B_DE0: R377.2 R403.2 UU6.3
USB3_B_DE1: R379.2 R405.2 UU6.6
USB3_B_EQ0: R378.2 R404.2 UU6.2
USB3_B_EQ1: R376.2 R402.2 UU6.4
USB3_PD#: R393.2 UU6.5
USB3_PRX_C_DTX_N8: CI38.2 JCDRA.36
USB3_PRX_C_DTX_P8: CI39.2 JCDRA.37
USB3_PRX_C_RD_DTX_N6: CU112.2 UU6.23
USB3_PRX_C_RD_DTX_P6: CU111.2 UU6.22
USB3_PRX_DTX_N5: DU13.1 DU13.9 JUSB3.5 UH1.J13
USB3_PRX_DTX_N6: CU112.1 UH1.G14
USB3_PRX_DTX_N7: DU12.1 DU12.9 JUSB2.5 UH1.G17
USB3_PRX_DTX_N8: CI38.1 UH1.R21
USB3_PRX_DTX_P5: DU13.2 DU13.8 JUSB3.6 UH1.K13
USB3_PRX_DTX_P6: CU111.1 UH1.F14
USB3_PRX_DTX_P7: DU12.2 DU12.8 JUSB2.6 UH1.F16
USB3_PRX_DTX_P8: CI39.1 UH1.P21
USB3_PRX_RD_DTX_N6: DU2.1 DU2.9 JUSB1.5 UU6.8
USB3_PRX_RD_DTX_P6: DU2.2 DU2.8 JUSB1.6 UU6.9
USB3_PTX_C_DRX_N5: CU107.1 DU13.4 DU13.7 JUSB3.8
USB3_PTX_C_DRX_N6: CU113.1 DU2.4 DU2.7 JUSB1.8
USB3_PTX_C_DRX_N7: CU50.1 DU12.4 DU12.7 JUSB2.8
USB3_PTX_C_DRX_P5: CU106.1 DU13.5 DU13.6 JUSB3.9
USB3_PTX_C_DRX_P6: CU114.1 DU2.5 DU2.6 JUSB1.9
USB3_PTX_C_DRX_P7: CU49.1 DU12.5 DU12.6 JUSB2.9
USB3_PTX_C_RD_DRX_N6: CU110.1 UU6.20
USB3_PTX_C_RD_DRX_P6: CU12.1 UU6.19
USB3_PTX_DRX_N5: CU107.2 UH1.C15
USB3_PTX_DRX_N6: CU110.2 UH1.C17
USB3_PTX_DRX_N7: CU50.2 UH1.A17
USB3_PTX_DRX_N8: JCDRA.42 UH1.B18
USB3_PTX_DRX_P5: CU106.2 UH1.B15
USB3_PTX_DRX_P6: CU12.2 UH1.C16
USB3_PTX_DRX_P7: CU49.2 UH1.B17
USB3_PTX_DRX_P8: JCDRA.43 UH1.C18
USB3_PTX_RD_DRX_N6: CU113.2 UU6.11
USB3_PTX_RD_DRX_P6: CU114.2 UU6.12
USB3_TEST: R375.2 R411.2 UU6.14
USB20_N1: UH1.J3 UU1.2
USB20_N2: LU4.1 RU123.1 UH1.N13
USB20_N2_R: CU104.1 DU10.2 JUSB2.2 LU4.2 RU123.2
USB20_N3: LM1.1 UH1.K4
USB20_N3_R: JCDRA.40 LM1.2
USB20_N4: UE1.32 UH1.M10
USB20_N6: JDGFF1.H4 UH1.K7
USB20_N7: JDGFF1.H7 UH1.L4
USB20_N8: LU5.1 RU125.1 UH1.G4
USB20_N8_R: CU105.1 DU11.2 JUSB3.2 LU5.2 RU125.2
USB20_N9: LE3.1 RE647.1 UH1.M6
USB20_N9_R: JTOBII.4 LE3.2 RE647.2
USB20_N10: LE7.4 RE200.1 UH1.H3
USB20_N10_R: DK1.2 JPK.10 LE7.3 RE200.2
USB20_N11: RT114.1 UH1.R10
USB20_N11_R: RT112.2 RT114.2 UT4.K5
USB20_N14: JWLAN.5 UH1.E5
USB20_P1: UH1.J2 UU1.3
USB20_P2: LU4.4 RU124.1 UH1.N15
USB20_P2_R: CU104.2 DU10.3 JUSB2.3 LU4.3 RU124.2
USB20_P3: LM1.4 UH1.K3
USB20_P3_R: JCDRA.39 LM1.3
USB20_P4: UE1.33 UH1.L9
USB20_P6: JDGFF1.H5 UH1.K6
USB20_P7: JDGFF1.H8 UH1.L3
USB20_P8: LU5.4 RU126.1 UH1.G5
USB20_P8_R: CU105.2 DU11.3 JUSB3.3 LU5.3 RU126.2
USB20_P9: LE3.4 RE648.1 UH1.N8
USB20_P9_R: JTOBII.3 LE3.3 RE648.2
USB20_P10: LE7.1 RE202.1 UH1.H2
USB20_P10_R: DK1.3 JPK.11 LE7.2 RE202.2
USB20_P11: RT115.1 UH1.P9
USB20_P11_R: RT113.2 RT115.2 UT4.L5
USB20_P14: JWLAN.3 UH1.F6
USB_OC0#: RPH6.4 UH1.AH36 UU1.13
USB_OC1#: CU17.1 RPH6.3 UH1.AL40 UU3.3
USB_OC2#: RPH6.1 UH1.AJ44
USB_OC3#: RPH6.2 UH1.AL41
USB_PWR_EN1: CU16.1 RE645.1 UE5.51 UU3.4
USBCHG_DET#: CU27.2 CU28.1 DU6.2 JUSB1.10 RU4.2
USBCHG_DET_D: PD301.3 RU6.1 UU5.4
USBCHG_DET_EC#: CU29.1 DU6.1 RU6.2 UE5.75
VCIN0_PH1: PH1.1 PR24.1 PR25.1 UE5.109
VCIN1_AC_IN: CE40.2 DH1.1 PQS29.5 PQS30.5 PR731.1 PR741.2 PRS99.1 PU703.2 QE3.5 UE5.110
VCIN1_ADP_PROCHOT: PC13.1 PR23.2 PR26.1 UE5.102
VCIN_ BATT_TEMP: CE35.2 PC14.1 PC753.2 PD4.2 PR13.2 PR14.1 PR756.1 PR764.1 UE5.63
VCLK_5V: PR307.1 PU301.19
VCORE_VCC_SEN: PCZ25.1 PRZ42.1 RC197.2 UC1.C38
VCORE_VSS_SEN: PCZ26.1 PUZ01.18 RC686.1 UC1.D38
VCOUT0_MAIN_PWR_ON#: PR315.1 UE5.104
VCOUT1_PROCHOT#: RE84.2 RE85.2 UE5.103
VD0_VCCSA: PRA02.1 PUA01.2 PUA01.3
VDOP_CHG: PC769.2 PR760.2 PU703.20
VGA_EN: RM14.2 RM87.1 UM8.26
VL: PC318.1 PU301.13
VO_VCCSA: PRA13.2 PUA01.10
VOUT_ISL95338_1: PRS19.1 PUS1.31
VOUT_ISL95338_2: PRS39.1 PUS2.31
VOUTS_ISL95338_1: PRS13.1 PUS1.3
VOUTS_ISL95338_2: PRS33.1 PUS2.3
VR_PWRGD: PRZ21.1 UE5.101
VR_SVID_ALRT#: PRZ09.2 R396.1
VR_SVID_ALRT#_L: R396.2 RC16.2 RC19.1
VR_SVID_CLK: PRZ07.2 R397.1
VR_SVID_CLK_R: R397.2 UC1.E38
VR_SVID_OUT: PRZ12.2 R398.1
VR_SVID_OUT_R: R398.2 RC17.2 UC1.E40
VROM_SEL: RH588.2 RH589.2 UH1.AW26
VSB_N_001: PC18.2 PQ8.3 PR16.2 PR19.2
VSB_N_002: PC17.1 PQ9.2 PR20.2 PR34.1
VSB_N_003: PQ9.1 PR16.1
VTTREF_1.2V: PC210.1 PU201.4
WAKE#: RH4.2 RH453.1 RH1018.2 UH1.BB47
WAKE_PCH#: RH545.1 UH1.BG44
WL_OFF#: DN1.1 RH520.2 RH707.2 UH1.AP24
WL_OFF#_R: DN1.2 JWLAN.56
XCLK_BIASREF: RH71.2 RH590.2 UH1.T3
XDP_HOOK0: JPCMC.27 RC355.1
XDP_ITP_PMODE: JPCMC.26 RC353.2 UH1.AL3
XDP_PRDY#: JPCMC.34 UC1.B10 UH1.AM5
XDP_PREQ#: JPCMC.33 UC1.B9 UH1.AL2
XDP_SPI_IO2: JPCMC.24 RC354.1
XDP_SPI_SI: JPCMC.25 RC9.2 RH1.1
XDP_TCK1: JPCMC.31 RC348.1 UH1.AJ3
XDP_TDI: JPCMC.29 RH495.2 UC1.G12 UH1.AH2
XDP_TDO: JPCMC.35 RH627.2 UC1.H13 UH1.AH3
XDP_TMS: JPCMC.30 RH103.2 UC1.F13 UH1.AJ4
XMP1: PR212.1 UH1.V47
XMP1-1: PC217.1 PQ202.2 PR212.2 PR216.1
XMP1-2: PQ202.6 PR213.2
XMP2: PR214.1 UH1.V48
XMP2-1: PC218.1 PQ202.5 PR214.2 PR217.1
XMP2-2: PQ202.3 PR215.2
XTAL24_IN: RH91.2 UH1.U10
XTAL24_IN_R: CH47.1 RH72.1 RH91.1 YH2.1
XTAL24_OUT: RH92.2 UH1.U9
XTAL24_OUT_R: CH48.1 RH72.2 RH92.1 YH2.3
N12479061: RE651.2 UE1.20
N12535590: RC684.2 RH525.2 UC2.4
N12536906: RC356.2 UC1.AC38
N12705199: CD130.2 RD56.2
N13311446: CL90.1 UL1.2
N13311484: CL91.1 CL121.1 UL1.6
N13311522: CL92.1 CL122.1 UL1.11
N13311576: CL93.1 CL123.1 UL1.13
N13311596: CL94.1 CL124.1 UL1.18
N13311632: CL95.1 CL125.1 UL1.22
N13311710: CL97.1 CL127.1 UL1.77
N13311746: CL98.1 UL1.85
N13313839: RL11.2 UL1.82
N13314155: RL14.2 UL1.69
N13562288: CL99.1 CL129.1 UL1.64
N16550351: PC779.1 PD705.2 PD705.3 PL700.2 PQ717.1 PQ717.2 PQ717.3 PR765.1
N16606246: PCS30.1 PCS42.1 PCS61.1 PCS73.1 PCS74.1 PCS2510.1 PCS2511.1 PJPS03.2 PJPS04.2 PLS10.2 PQS07.5 PQS09.5 PQS27.1
N16611457: PCS01.1 PCS02.1 PCS03.1 PCS71.1 PCS72.1 PCS2508.1 PCS2509.1 PJPS01.2 PJPS02.2 PLS01.2 PQS01.5 PQS03.5 PQS26.1
N16639315: PCS69.2 PQS10.4 PQS12.1 PRS59.2 PRS61.1
N16640057: PQS12.2 PRS60.1 PRS63.2
N16641333: PQS13.5 PQS13.6 PRS58.2
N16644305: PQS13.2 PRS57.2 PRS62.1
N16645109: PQS13.3 PRS60.2
N16647112: PCS70.2 PQS15.4 PQS16.1 PRS67.2 PRS68.1
N16647166: PQS16.2 PRS64.1 PRS70.2
N16647194: PQS17.5 PQS17.6 PRS66.2
N16647286: PQS17.2 PRS65.1 PRS69.2
N16647302: PQS17.3 PRS64.2
N16677573: PR703.2 PR772.1
N16677640: PR703.3 PR740.1
N16690790: PC705.1 PC760.1 PC762.1 PC763.1 PC764.1 PC765.1 PC780.1 PC781.1 PC794.1 PL711.2 PQ704.5
N16716198: PD704.1 PDS705.1 PR743.2
N16781018: PCA01.1 PCA02.1 PCA03.1 PCA04.1 PCA05.1 PCA06.1 PCA07.1 PCA25.1 PJPA01.2 PQA01.2
N16782292: PCA12.1 PRA04.2
N16788054: PRA17.1 PRA18.2 PRA19.1
N16828896: JRTC.1 PR18.1
N16828913: PD5.3 PR15.2
N16829365: PC14.2 PQ7.2 PR28.1
N16856169: PRZ44.1 PUZ01.33
N16860465: DS1.1 QS3.1
N16862683: PCI07.2 PRI12.1 PUI01.3
N16862697: PCI17.1 PRI17.2
N16862704: PRI14.1 PUI01.26
N16862707: PCI06.1 PRI11.2 PUI01.24
N16862715: PRI15.2 PUI01.2
N16862717: PRI13.2 PUI01.1
N16862746: PCI08.1 PRI16.1
N16862747: PRI16.2 PUI01.7
N16862749: PCI08.2 PUI01.5
N16862782: PCI19.2 PRI29.1 PUI02.3
N16862802: PCI29.1 PRI35.2
N16862811: PCI20.1 PRI32.1
N16862814: PCI20.2 PUI02.5
N16862815: PRI32.2 PUI02.7
N16862866: PRI31.2 PUI02.2
N16862869: PRI28.2 PUI02.1
N16862875: PRI30.1 PUI02.26
N16862877: PCI18.1 PRI27.2 PUI02.24
N16868018: PCI36.2 PRI54.1 PUI03.3
N16868027: PRI53.2 PUI03.1
N16868041: PCI45.1 PRI58.2
N16868085: PCI37.1 PRI57.1
N16868091: PCI37.2 PUI03.5
N16868093: PRI57.2 PUI03.7
N16868095: PRI56.2 PUI03.2
N16868135: PRI55.1 PUI03.26
N16868151: PCI35.1 PRI52.2 PUI03.24
N16872715: PCI48.2 PRI69.1 PUI04.3
N16872720: PRI68.2 PUI04.1
N16872727: PCI56.1 PRI73.2
N16872751: PCI47.1 PRI72.1
N16872754: PCI47.2 PUI04.5
N16872755: PRI72.2 PUI04.7
N16872756: PRI71.2 PUI04.2
N16872763: PRI70.1 PUI04.26
N16872771: PCI46.1 PRI67.2 PUI04.24
N16876688: PCI63.2 PRI94.1 PUI05.3
N16876692: PRI93.2 PUI05.1
N16876699: PCI72.1 PRI98.2
N16876717: PCI64.1 PRI97.1
N16876720: PCI64.2 PUI05.5
N16876721: PRI97.2 PUI05.7
N16876722: PRI96.2 PUI05.2
N16876729: PRI95.1 PUI05.26
N16876737: PCI62.1 PRI92.2 PUI05.24
N16876803: PCI74.2 PRI109.1 PUI06.3
N16876807: PRI108.2 PUI06.1
N16876814: PCI83.1 PRI113.2
N16876832: PCI75.1 PRI112.1
N16876835: PCI75.2 PUI06.5
N16876836: PRI112.2 PUI06.7
N16876837: PRI111.2 PUI06.2
N16876844: PRI110.1 PUI06.26
N16876852: PCI73.1 PRI107.2 PUI06.24
N16880226: PCG01.2 PRG03.1 PUG01.3
N16880230: PCG02.1 PRG02.2 PUG01.24
N16880234: PCG20.1 PRG19.2
N16880256: PCG11.1 PRG07.2
N16880306: PRG14.2 PUG02.1
N16880310: PRG17.2 PUG02.2
N16880314: PCG13.2 PRG15.1 PUG02.3
N16880326: PCG12.1 PRG13.2 PUG02.24
N16880463: PRG04.1 PUG01.26
N16880475: PRG16.1 PUG02.26
N16880496: PCG14.2 PUG02.5
N16880498: PRG18.2 PUG02.7
N16880500: PCG14.1 PRG18.1
N16884080: PCG03.1 PRG06.1
N16884081: PCG03.2 PUG01.5
N16884082: PRG06.2 PUG01.7
N16884085: PRG05.2 PUG01.2
N16884088: PRG01.2 PUG01.1
N17251517: PRI207.1 PRI208.2 PUI07.7
N17251525: PRI202.1 PUI07.8
N17251539: PRI206.2 PUI07.3
N17251555: PCI205.2 PRI210.2 PUI07.2
N17251561: PCI201.1 PRI201.2 PUI07.1
N17251581: PCI203.2 PRI203.2 PUI07.5
N17251587: PCI202.1 PRI204.2 PUI07.4
N17251605: PRI209.1 PUI07.10
N17251609: PRI205.1 PUI07.6
N17254393: PRI214.1 PRI217.2 PUI08.7
N17254411: PRI216.1 PUI08.8
N17254421: PRI213.2 PUI08.3
N17254439: PCI209.2 PRI220.2 PUI08.2
N17254445: PCI208.1 PRI218.2 PUI08.1
N17254465: PCI207.2 PRI215.2 PUI08.5
N17254471: PCI210.1 PRI211.2 PUI08.4
N17254491: PRI212.1 PUI08.10
N17254495: PRI219.1 PUI08.6
N17256722: PRI226.1 PRI229.2 PUI09.7
N17256744: PRI228.1 PUI09.8
N17256762: PRI225.2 PUI09.3
N17256780: PCI214.2 PRI221.2 PUI09.2
N17256786: PCI213.1 PRI230.2 PUI09.1
N17256806: PCI212.2 PRI227.2 PUI09.5
N17256812: PCI215.1 PRI223.2 PUI09.4
N17256832: PRI224.1 PUI09.10
N17256836: PRI222.1 PUI09.6
N17290710: R369.1 UU6.7
N17293226: RE646.2 UE5.2
N17293290: RE694.2 UE5.20
N17297096: RE701.1 UE5.76
N17335181: RE74.2 UE5.107
N17335675: CE51.1 QE2.2 RE85.1
N17489381: T360.1(TP-1) UL1.76
N17490955: CU27.1 DU8.2 RU5.2 UU5.2
N17495484: RU3.2 UU1.16
N17495486: RU2.2 UU1.15
N17495513: RU7.2 UU1.8
N17495517: RU1.2 UU1.4
N17528252: R370.2 UU6.24
N17623308: CL9.1 CL110.1 CL111.1 CL112.1 CL113.1 CL114.1 CL115.1 CL116.1 RL70.1 UL2.1 UL2.4 UL2.7 UL2.10
N18480752: RH9.1 UH1.AN6
N19446833: RE692.2 UE1.27
N19846941: RT241.1 UT6.25
N20112847: CT37.1 RT116.2 YT1.1
N20112857: CT38.1 RT117.2 YT1.3
N20119614: RT242.2 RT243.2 UT7.1
N20119616: CT212.1 RT245.1 RT249.1
N20119618: CT211.1 RT246.1 RT247.1
N20119620: RT702.1 UT7.17
N20119626: CT214.1 CT215.1 RT250.2 UT7.20
N20119654: RT248.2 UT7.18
N20119690: RT245.2 RT719.1 UT7.13
N20119692: RT246.2 RT718.1 UT7.14
N20119710: RT705.1 RT716.1 UT7.2
N20119714: RT706.1 RT717.1 UT7.3
N20119734: RT244.2 UT7.4
N20124859: CT153.1 CT154.1 CT155.1 LT4.1 UT1.R13
N20389048: PC1807.1 PR1806.2 PU1801.4
N20408000: RS9.1 US2.12
N20412193: JHDD.11 RS17.2
N20418101: PD706.1 PR729.1
N20451899: JWLAN.38 RN118.1
N20451900: JWLAN.40 RN119.1
N20453798: PCS85.2 PQS19.1 PQS30.6 PRS74.1 PRS79.1 PRS80.2
N20463917: PQ709.2 PQ710.1
N20466818: PCS79.1 PRS83.2
N20469265: PCS81.1 PRS85.2
N20478252: PC2507.1 PR2506.2 PU2501.4
N20591895: DF2.1 JFAN2.4 RF6.1
N20642816: T372.1(TP-1) UH1.BC1
N20764785: RH580.1 UH1.F3
N20764786: RH581.1 UH1.G3
N20781272: QE64.5 QE64.6 RE698.2
N20905330: RT22.1 UT4.A6 UT4.A7 UT4.A8 UT4.B7
N20905578: CT104.1 UT4.H7
N20905857: RT83.2 UT4.F1
N20980290: LL2.1 UL11.6
N20990559: RL42.2 UL13.2
N20994075: LL4.1 UL13.6
N20998853: RL57.1 UL10.7
N21000962: LL1.1 UL10.6
N21009233: R181.2 U2407.7
N21009259: DF1.1 JFAN1.4 RF3.1
N21011071: RE14.2 UE2.3
N21011075: RE9.1 UE2.5
N21011082: RE13.2 UE2.7
N21011109: RE10.1 UE2.2
N21011136: RE20.1 UE9.3
N21021693: C3.1 UZ21.6
N21094566: PRZ02.2 PUZ01.46
N21094590: PCZ04.1 PRZ04.1 PUZ01.41
N21094642: PRZ01.2 PRZ07.1 PRZ08.1
N21094652: PRZ05.2 PRZ09.1 PRZ10.1
N21094662: PRZ06.2 PRZ12.1 PRZ13.1
N21094718: PRZ10.2 PUZ01.44
N21094756: PRZ26.2 PUZ01.1
N21094764: PRZ16.2 PRZ21.2 PUZ01.47
N21094776: PRZ24.2 PUZ01.48
N21207101: RP7.1 TC28.1(TP-1)
N21214430: JPCMC.23 RC688.1
N21284890: RS15.2 US3.2
N21889161: RL69.1 UL14.3
N21968037: JLAN.9 RL66.1
N21970003: CL109.1 JLAN.11 RL68.1
N21970023: CL108.1 JLAN.13 RL67.1
N21970031: CL31.1 JLAN.12 RL71.1
N21995476: CT156.1 RT122.2
N22716130: PCS82.2 PQS22.2 PQS26.2 PRS86.2 PRS87.1
N22716132: PQS23.1 PRS87.2
N22717170: PCS83.2 PQS24.2 PQS27.2 PRS89.2 PRS90.1
N22717172: PQS28.1 PRS90.2
N22717182: PCS83.1 PQS24.3 PQS27.3 PRS89.1
N22744293: PCS82.1 PQS22.3 PQS26.3 PRS86.1
N22801974: PQS23.2 PRS92.2
N22803402: PQS28.2 PRS93.2
N22855815: RC692.2 UC1.D1
N22932271: PQS29.2 PQS29.3 PRS94.2
N22933167: PQS30.2 PQS30.3 PRS95.2
N22940727: PQ6.6 PR27.2
N22940749: PC15.1 PQ6.3 PR22.2
N22943813: PQ10.6 PR42.2
N22943835: PC25.1 PQ10.3 PR40.2
N22956288: PQ11.1 PR44.2
N22957086: PQ12.1 PR45.2
N22958603: PQS31.2 PQS32.1
N23062034: RT716.2 RT718.2
N23062041: RT717.2 RT719.2
N24139767: RH6.1 RH7.1 UH1.BE48 UH1.BE49
N24365027: CE63.2 RE530.2 UE10.3
N24654525: C2522.1 J6.2 U18.1
N24654698: R367.1 U18.3
N24774570: RE702.1 UE5.86
N24886534: RT132.1 UT8.3
N24894786: CE202.2 RE704.2 UE6.3
N25336280: QN8.5 QN8.6 RN7.2
N25337275: QN9.5 QN9.6 RN9.2
N25456628: TC29.1(TP-1) UH1.BC17
N25456636: TC30.1(TP-1) UH1.BD17
N25456691: CH232.1 RH591.2
N25457743: RH89.1 UH1.BB36
N25459397: RT694.2 UH1.AP21
N25467546: RE25.2 UE3.24
N25467550: RE31.1 UE3.30
N25468008: QE22.6 RE157.2
N25468398: QE21.6 RE155.2
N25468783: QE13.6 RE160.2
N25473625: RT110.2 RT111.2 UT5.1 UT5.2 UT5.4
N25473695: CT115.1 QT2.5 RT90.1
N25473720: QT2.3 RT89.2
N25473733: QT2.6 RT88.2 RT90.2
N25473775: CT117.1 UT5.6
N25486032: QM1.2 QM2.6 RM92.2
N25486052: QM2.3 QM3.2 RM94.2
N25488294: RM72.1 UM8.27
N25488305: RM61.2 UM8.52
N25488307: RM64.1 RM66.1 UM8.48
N25489376: RM21.2 RM96.2 UM4.1
N25489378: CM99.1 RM28.1 RM29.1
N25489380: CM98.1 RM27.1 RM38.1
N25489388: CM16.1 CM17.1 RM18.2 UM4.20
N25489416: RM25.2 UM4.18
N25489452: RM28.2 UM4.13
N25489454: RM27.2 UM4.14
N25489496: RM20.2 UM4.4
N25570567: CL96.1 CL126.1 UL1.27
N25983095: RT724.1 UT1.Y1
N25983098: RT725.1 UT1.Y2
N26130108: RE161.1 UE12.3
N26166089: RV1.1 UV65.5
N26166093: RV2.2 UV65.4
N26166280: RV4.1 UV65.3
N26241219: RH598.1 UH1.AF19 UH1.AF20
N26426233: CE174.1 RE705.2 RE706.2 UE5.9
N26580757: RE707.1 UE13.3
N26581315: RE703.2 UE6.6
N27290476: RE77.2 UE5.111
N28714534: PC752.2 PR754.1
N28714560: PC749.2 PR775.1
N28714625: PR757.1 PR779.2
N28714782: PC767.1 PR766.2
N28714793: PC779.2 PQ717.4 PR773.2
N29418337: PCZ10.2 PRZ25.1
N29418339: PRZ23.1 PRZ25.2 PRZ28.1 PUZ01.5
N29418355: PCZ25.2 PRZ38.2
N29418359: PRZ38.1 PRZ41.1 PRZ42.2 PUZ01.17
N29418371: PHZ04.2 PRZ37.1 PRZ40.2
N29418377: PCZ28.2 PRZ37.2 PUZ01.15
N29418393: PHZ01.2 PRZ14.2 PRZ15.1
N29418395: PCZ06.2 PRZ15.2 PUZ01.3
N29418397: PCZ07.2 PRZ22.2 PUZ01.4
N29418405: PRZ27.1 PUZ01.36
N29418441: PRZ20.1 PUZ01.40
N29418445: PRZ19.1 PUZ01.39
N29418451: PRZ18.1 PUZ01.38
N29418455: PRZ17.1 PUZ01.37
N29418473: PCZ29.1 PRZ43.1 PUZ01.16
N29419473: PCZ05.2 PRZ11.2 PUZ01.2
N29419486: PCZ14.2 PRZ32.2 PUZ01.8
N29419576: PCZ08.2 PRZ22.1
N29419623: PHZ02.1 PRZ29.2
N29419667: PHZ03.2 PRZ36.1
N29419693: PCZ14.1 PRZ31.2
N29419860: PCZ27.2 PRZ39.1 PUZ01.14
N29419910: PCZ30.2 PRZ43.2
N29419918: PCZ31.1 PRZ41.2
N29419943: PCZ24.1 PRZ33.1 PUZ01.20
N29419947: PCZ24.2 PRZ35.1
N29438561: PRZ13.2 PUZ01.43
N29438571: PRZ08.2 PUZ01.45
N29599145: PCZ09.1 PRZ23.2
N37345395: T135.1(TP-1) UH1.AL35
N38701284: DE1.2 RE8.2 UE1.25
N38704058: RE6.1 UE1.31
N38704074: RE7.1 UE1.30
N40259586: RT108.1 RT109.2 UT4.D6
N105891848: CD31.2 RD11.2
N171085726: C2507.1 U17.12
N184712230: T121.1(TP-1) UT4.E10
N1710857213: C2506.1 U17.10
N1847135623: T64.1(TP-1) UT4.B2
N1847135624: T65.1(TP-1) UT4.C2
N1847135625: T114.1(TP-1) UT4.D10
N1847135626: T120.1(TP-1) UT4.G11
N1847135629: T122.1(TP-1) UT4.G10
N1847135630: T70.1(TP-1) UT4.D7
N1847135663: T62.1(TP-1) UT4.F4
N1847135664: T63.1(TP-1) UT4.G4

Pads without a net: FD1 1; FD2 1; FD10 1; FD11 1; JDGFF1 A1 A2 A10 B2 B3 B5 B6 B8 B9 C4 F5 F9 G8 H10; JDGFF2 C9 D1 F10 H10; JDIMM1 87 88 91 92 95 97 100 101 104 105; JDIMM2 87 88 91 92 95 97 100 101 104 105; JDIMM3 87 88 91 92 95 97 100 101 104 105; JDIMM4 87 88 91 92 95 97 100 101 104 105; JELC 6 7 8; JHDD 16; JPCMC 3; JPK 6 19 20; JSSD1 6 10 20 22 24 26 28 30 32 34 36 40 42 44 46 48 54 56 58 67; JSSD2 6 10 20 22 24 26 28 30 32 34 36 40 42 44 46 48 54 56 58 67; JWLAN 6 8 12 16 20 42 44 46 48 55 58 60 62 66 68 70; PD1 3; PD2 3; PD4 3; PU1801 5; PU2501 5; PUF01 10 12; PUG01 6 22 25 27; PUG02 6 22 25 27; PUI01 6 22 25 27; PUI02 6 22 25 27; PUI03 6 22 25 27; PUI04 6 22 25 27; PUI05 6 22 25 27; PUI06 6 22 25 27; PUS1 23 26 30; PUS2 23 26 30; PUZ01 28 29 30 31 32 34 35; U2407 8 11; U2408 6; UC1 A5 A6 A14 A16 AB35 AB37 AB38 AC37 AJ22 AL25 AL26 AM25 AM26 AN25 AN26 AP25 AP26 AR25 AR26 AT33 AU9 AU10 AU31 AU32 AU33 AV31 AV32 AV33 AW31 AW33 AY3 AY31 B4 B5 B7 B8 B11 B14 B15 B16 B17 B39 C3 C4 C6 C7 C9 C11 C15 C17 C40 D2 D3 D5 D6 D9 D10 D12 D14 D15 D16 D17 E4 E5 E10 E12 F9 F15 G8 G9 G10 G14 H8 H10 H14 J11 J13 J14 J15 J17 J19 K11 K12 K13 L12; UC2 1; UE1 2 3 4 10 26 29 38 39 40 41 45 46; UE3 12 13 22 28 29; UE5 37; UE6 7 8 9 10 11 13 14 15 16 17 18 19 20 21 22 23; UE10 13; UH1 A22 A25 AA1 AA45 AB48 AC6 AC7 AC9 AC11 AC14 AC15 AC39 AC41 AC43 AC44 AC48 AD47 AD48 AE9 AE11 AE39 AE41 AE43 AE44 AE48 AF47 AF48 AH14 AH15 AH40 AJ46 AJ47 AK47 AL9 AL15 AL37 AL47 AM7 AM43 AM45 AM47 AM48 AN4 AN35 AN37 AN46 AN47 AP2 AP3 AP9 AP29 AP47 AP48 AR2 AR13 AR35 AR37 AR42 AR48 AT5 AT10 AT40 AT49 AU4 AU46 AU47 AU48 AV6 AV7 AV13 AV16 AV18 AV43 AV44 AV46 AV47 AW2 AW3 AW13 AW15 AW18 AW21 AW48 B9 B10 B14 B19 B21 B23 B24 B25 B26 B27 BA33 BA36 BB24 BB34 BC28 BC33 BD8 BD12 BD16 BD39 BD42 BE8 BE9 BE12 BE19 BE23 BE29 BE32 BE33 BE34 BE36 BE40 BF8 BF9 BF10 BF15 BF19 BF32 BF33 BF36 BF40 BF41 BG8 C3 C9 C10 C11 C14 C19 C20 C21 C23 C24 C26 C27 C39 C47 D4 D11 D20 D21 D29 D39 D46 E28 F7 F9 F11 F20 F24 F26 G1 G2 G12 G20 G24 G26 J15 J18 J21 J24 K16 K18 K21 K29 K46 K47 L2 L24 L26 L46 L47 M1 M26 M29 N2 N3 N18 N32 N47 N48 P24 P47 P48 R13 R15 R18 R24 R32 R46 R47 T1 T2 T45 T46 T47 T48 U2 U3 U13 U35 U37 U47 U48 V2 V3 W6 W7 W46 W47 Y2 Y14 Y15 Y35 Y36 Y46 Y48; UL1 47 74 75; UL4 7; UL10 5; UL11 5; UL13 5; UM4 7 8; UM8 10 11 12 13 15 16 17 18 21 22 23 28 29 30 31 32 33 34 35; US1 2 3; US2 10 11; UT1 A7 A9 A11 A13 A23 B7 B9 B11 B13 B23 D19 E18 E19 J1 J2 L1 L2 N1 N2 R1 R2 V18 W16 W19 Y16 Y19; UT4 A9 B9; UT6 21 23 27; UT7 7 8; UU1 9; UU5 1

## Via types
v1: diameter 0.305, hole 0.152, TOP to BOTTOM, 886 vias
v2: diameter 0.457, hole 0.203, TOP to BOTTOM, 9393 vias
v3: diameter 0.406, hole 0.203, TOP to BOTTOM, 203 vias
v4: diameter 0.508, hole 0.254, TOP to BOTTOM, 79 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
0.9V_FB:
  vias: v1(161.89,165.76)
1.2V_B+: length 13.3
  TOP w0.254: 227.23,115.53 226.66,114.95 226.66,112.07 225.42,110.83 220.12,110.83 219.36,111.59 PR206.1
  vias: v1(226.47,117.88)
1.8V_FB: length 3.7
  TOP w0.254: v2(170.72,166.8) 170.63,166.71 170.63,164.56 171.43,163.76 UL11.1
  vias: v1(172.11,167.47)
2.5V_FB: length 4.9
  TOP w0.254: v2(193.01,166.65) 193.14,166.52 v1(193.64,166.52) 194.2,166.52 RL22.1 195.15,165.57 UL10.1
  BOTTOM w0.254: v2(193.01,166.65) 193.09,166.74 CL21.2 RL21.2
3/5V_B+: length 14.7
  TOP w0.203: PU301.12 v2(326.71,38.73)
  BOTTOM w0.508: v2(326.71,38.73) 326.57,38.73 325.72,37.87 322.48,37.87 322.03,38.31 315.99,38.31 v2(314.07,36.4)
  vias: v1(310.48,37.62)
3V_5V_EN: length 1.1
  TOP w0.112: PC319.1 v1(326.64,13.13)
3V_ELC_ON: length 133.2
  TOP w0.112: RE83.1 242.19,8.12 242.79,8.12 v2(243.03,8.35) 243.26,8.12 UE10.18
  TOP w0.127: UE9.4 v2(350.1,28.4)
  IN3 w0.104: v2(341.53,9.17) 341.46,9.17 340.92,9.72 305.63,9.72 303.9,11.44 290.29,11.44 289.05,10.2 280.87,10.2 278.45,7.78 277.14,7.78 274.97,9.96 270.1,9.96 265.76,5.61 253.02,5.61 252.16,6.47 245.99,6.47 244.11,8.35 v2(243.03,8.35)
  BOTTOM w0.112: v2(350.1,28.4) 350.1,24.39 349.99,24.28 344.97,24.28 343.57,22.88 343.57,13.81 341.6,11.83 v1(341.6,11.01) 341.6,9.24 v2(341.53,9.17)
3V_EN: length 27.9
  TOP w0.203: PU301.6 329.83,39.99 330.02,40.18 330.38,40.18 330.78,40.59 v2(330.78,40.71)
  TOP w0.254: PR312.1 326.48,17.43 v2(325.79,18.12)
  BOTTOM w0.254: v2(325.79,18.12) v1(325.79,19.84) 325.79,19.98 328.14,22.32 328.14,32.4 331.35,35.61 331.35,38.52 330.78,39.09 v2(330.78,40.71)
3VS: length 1.7
  TOP w0.112: 343.56,23.9 v1(345.28,23.9)
3VS_GATE: length 4.9
  TOP w0.112: R174.2 C258.1 ; C258.1 338.19,22.67 339,21.86 U17.3 ; C258.1 338.13,22.67 337.84,22.95 337.74,22.95 337.55,23.14 336.65,23.14 v1(336.2,22.69)
5V_EN: length 23.1
  TOP w0.203: v2(330.76,35.94) 330.33,35.94 329.83,36.43 PU301.20
  TOP w0.254: PR313.1 324.96,17.81 v2(324.96,18.12)
  BOTTOM w0.254: v2(330.76,35.94) 330.76,35.56 327.76,32.55 327.76,22.48 324.96,19.68 v1(324.96,18.69) v2(324.96,18.12)
5VS: length 1.7
  TOP w0.112: 343.56,18.63 v1(345.22,18.63)
5VS_GATE: length 2.5
  TOP w0.112: v1(338.09,20.1) R182.2 338.48,21.04 338.55,20.98 338.99,20.98 339.08,21.06 U17.5
+0.6V_DDR_REFCA_A: length 29.2
  TOP w0.127: CD52.2 235.47,70.33 v1(235.36,70.44)
  TOP w0.457: v2(237.47,69.26) 237.47,70.2 CD51.2 CD52.2
  TOP w0.508: RD9.1 RD8.1 RD10.2 CD30.1 251.82,69.8 v2(251.74,69.87) 251.74,70.18 252.25,70.69 CD18.1 CD19.2
  IN4 w0.457: v2(251.74,69.87) 251.46,70.15 237.87,70.15 237.47,69.75 v2(237.47,69.26)
  BOTTOM w0.305: JDIMM1.164 252.09,69.53 v2(251.74,69.87) ; v2(237.47,69.26) 237.47,69.77 237.67,69.97 238.33,69.97 238.78,69.53 JDIMM3.164
+0.6V_DDR_REFCA_B: length 25.7
  TOP w0.457: CD81.1 223.27,70.94 CD82.2 222.49,70.97 RD57.1 ; CD81.1 RD54.2 225.75,70.94 CD132.1 226.64,71.02 RD55.1 ; CD81.1 224.13,70.94 v2(224.13,70.08) 224.13,69.37 223.81,69.04 221.9,69.04 221.64,69.3 v3(218.47,69.3) 215.92,69.3 215.4,68.78 215.39,68.78 ; 215.39,68.78 214.93,69.24 214.05,69.24 213.33,69.95 CD114.2 CD113.2 ; 215.39,68.78 v2(215.39,68.46)
  BOTTOM w0.305: v2(224.13,70.08) 224.13,69.86 224.47,69.53 JDIMM2.164 ; JDIMM4.164 214.98,69.53 215.39,69.11 v2(215.39,68.46)
+0.6V_VREF_CA: length 171.2
  TOP w0.508: v2(150,44.54) 150,36.68 151.69,35 161.32,35 163.54,32.78 v3(163.54,25.3) v2(163.54,24.6) ; CD31.1 255.45,67.61 255.24,67.61 255.09,67.76 v2(254.97,67.76) 254.94,67.79 254.66,67.79 RD9.2
  IN4 w0.508: v2(163.54,24.6) 163.54,24.33 165.78,22.1 185.28,22.1 188.46,18.92 239.2,18.92 243.55,23.26 249.73,23.26 253.29,26.82 253.29,67.06 254,67.76 v2(254.97,67.76)
  BOTTOM w0.305: UC1.AB40 150.35,44.54 v2(150,44.54)

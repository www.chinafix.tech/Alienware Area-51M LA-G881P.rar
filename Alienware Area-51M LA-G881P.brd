# Allegro board Alienware Area-51M LA-G881P.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+0.6V_VREF_DQ: length 148.8
  TOP w0.457: CD130.1 RD57.2 221.79,70.75 v2(221.79,70.08)
  TOP w0.508: v2(164.17,24.6) 164.17,33.04 161.23,35.99 152.48,35.99 150.96,37.5 v3(150.96,42.57) v2(150.96,45.24)
  IN4 w0.457: 221.79,69.66 v2(221.79,70.08)
  IN4 w0.508: v2(164.17,24.6) 166.04,22.73 192.71,22.73 194.02,21.42 211.62,21.42 213.11,22.92 224.28,22.92 226.91,25.55 226.91,68.79 226.47,69.24 222.21,69.24 221.79,69.66
  BOTTOM w0.305: v2(150.96,45.24) 151.19,45.24 151.49,45.54 UC1.AC39
+0.6VS: length 26.2
  TOP w2.032: 204.56,115.21 197.2,115.21 196.07,114.09 196.05,114.09 195.25,113.29 195.25,113.27 193.32,111.34 193.32,108.29 195.1,106.51 195.1,100.42 194.91,100.23 194.91,98.83
  vias: v2(192.94,96.99) v2(193.64,96.99) v2(194.27,96.99) v2(194.91,96.99) v2(195.54,96.99) v2(196.18,96.99) v2(196.81,96.99) v2(211.23,94.08) v2(211.81,94.08) v2(227.67,94.22) v2(228.25,94.22) v2(238.18,94.92) v2(238.76,94.92) v2(251.71,92.66) v2(252.3,92.66) v3(207.29,115.28)
+0.6VSP: length 2.2
  TOP w0.203: PU201.2 215.86,117.28 215.71,117.42 214.99,117.42 214.79,117.63
  vias: v3(215.29,118.26)
+0.9V_CIO: length 4.5
  TOP w0.381: v2(26.17,44.52) 26.09,44.43 CT79.1 ; CT78.1 25.53,43.21 v2(25.52,43.22) 25.41,43.1 CT80.1
  IN2 w0.457: v2(25.52,43.22) 25.8,43.22 26.17,43.59 v2(26.17,44.52)
  BOTTOM w0.254: UT1.R11 v2(25.52,43.22) ; v2(25.52,43.22) 25.52,43.22 ; v2(25.52,43.22) UT1.R12
+0.9V_DP: length 26.5
  TOP w0.076: CT57.1 24.68,46.54 24.68,47.04 25.23,47.58 v1(25.75,47.58)
  TOP w0.203: v2(26.82,43.22) 26.22,42.61 CT60.1
  TOP w0.254: CT62.1 27.83,42.19 27.58,42.45 CT61.1 27.41,41.98 v2(27.47,41.92)
  TOP w0.305: v2(24.22,45.82) 24.48,46.07 24.85,46.07 CT57.1
  TOP w0.381: v2(23.57,43.22) 23.43,43.07 CT54.1 ; CT58.1 24.33,45.05 v2(24.22,45.17) 24.22,45.02 24.41,44.84 CT59.1
  IN3 w0.457: 29.01,42.55 29.34,42.88 29.34,45 28.72,45.63 28.72,47.1 28.57,47.24 28.57,47.49 28.26,47.8 27.18,47.8 27.08,47.7 25.67,47.7 24.92,46.96 24.92,46.27 24.47,45.82 v2(24.22,45.82)
  IN3 w0.508: v2(27.47,41.92) 28.38,41.92 29.01,42.55
  BOTTOM w0.203: UT1.M8 v2(24.22,45.17)
  BOTTOM w0.254: v2(23.57,43.22) UT1.L11 ; v2(23.57,43.22) 23.57,43.24 ; v2(23.57,43.22) UT1.L12 ; UT1.L8 v2(24.22,45.17) UT1.L6 v2(24.22,45.82) UT1.M6 ; UT1.V13 v2(27.47,41.92) ; v2(26.82,43.22) UT1.T11 v2(26.82,43.87) UT1.V11 ; v2(26.82,43.22) UT1.V12 ; v2(26.82,43.22) UT1.T12
+0.9V_LVR_OUT: length 13.3
  TOP w0.127: CT82.1 19.6,39.15 19.14,38.69 v1(18.7,38.69)
  TOP w0.254: CT83.1 22.38,43.33 v2(22.92,43.87)
  IN2 w0.457: v2(21.62,40.62) 20.15,40.62 19.64,41.12 19.64,44.09 20.07,44.52 22.56,44.52 22.92,44.16 v2(22.92,43.87)
  BOTTOM w0.254: UT1.H18 22.45,40.14 22.09,40.14 UT1.F18 v2(21.62,40.62) ; UT1.H11 v2(22.92,43.87) UT1.J11
+0.9V_PCIE: length 3.7
  BOTTOM w0.254: UT1.M15 v2(24.22,41.92) UT1.M13 ; UT1.N19 v2(25.52,39.97) UT1.N18 ; v2(24.22,39.97) UT1.L18 ; v2(24.22,39.97) UT1.L19 ; v2(24.22,39.97) UT1.M18 ; UT1.M16 v2(24.22,40.62)
  vias: v1(26.06,39.46) v2(24.22,41.27)
+0.9V_SVR: length 9.6
  TOP w0.305: CT66.1 20.1,42.16 20,42.07 20,42.03 19.85,41.88 CT69.1
  TOP w0.381: CT63.1 21.23,42.81 21.41,42.81 21.57,42.97 21.57,43.16 v2(21.62,43.22) ; CT63.1 20.85,42.43 20.65,42.43 20.57,42.35 CT66.1 CT67.1 20.1,43.18 CT68.1 ; CT63.1 21.11,42.51 21.49,42.13 21.49,42.04 v2(21.62,41.92)
  BOTTOM w0.254: UT1.F15 v2(21.62,41.92) UT1.E13 ; UT1.F13 v2(22.27,41.92) ; UT1.M9 v2(24.22,43.87) UT1.L9 v2(23.57,43.87) UT1.J9 ; UT1.E12 v2(21.62,43.22) ; v2(21.62,43.22) UT1.F11 ; v2(21.62,43.22) UT1.F12
  vias: v2(18.74,56.61) v2(18.74,56.03) v2(18.74,55.45) v2(18.74,54.86) v3(19.4,55.33)
+0.9V_USB: length 2.7
  TOP w0.254: CT56.1 26.28,40.72 v2(26.17,40.61) 26.16,40.62 v2(26.16,41.27) 26.1,41.32 CT77.1
  BOTTOM w0.203: v2(26.17,40.61) 25.85,40.93 UT1.R16
  BOTTOM w0.254: UT1.R15 26.16,41.28 v2(26.16,41.27)
+1.2V_DDR: length 372.2
  TOP w0.254: CH197.1 175.99,29.31 175.99,29.55 175.68,29.86 UC2.5
  TOP w0.305: CD102.1 216,31.43 v2(216,30.88) ; RD8.2 253.47,67.18 CD29.1 254.8,67.26 v2(255.03,67.03) ; CD11.1 246.92,90.75 v2(247.48,90.19) ; CD8.1 244.74,58.08 244.74,57.72 v2(244.37,57.35) ; CD42.1 238.38,39.49 v2(238.36,39.48) ; v2(216.69,44.23) 216.8,44.35 CD77.1 ; CD69.1 228.23,65.23 v2(228.24,65.22) ; v2(214.69,82.07) 214.67,82.09 CD107.1 ; CD47.1 229.3,78.99 v2(229.31,79) ; v2(233.83,46.25) 234.02,46.06 CD43.1 ; v2(202.5,79.02) 202.5,78.48 CD108.1 ; v2(225.13,29.6) 225.17,29.56 CD72.1 ; CD3.1 244.12,61.87 v2(244.02,61.97) ; v2(217.19,65.22) 217.26,65.15 CD64.1 ; v2(256.23,83.03) 256.23,83.17 256.69,83.63 RD7.1 ; CD5.1 255.04,57.53 v2(255.03,57.53) ; CD78.1 216.01,78.54 v2(215.98,78.51) ; CD94.1 201.04,71.05 v2(201.04,71.88) ; CD71.1 227.6,55.39 v2(228.12,55.91) ; CD96.1 213.6,67.84 v2(214.22,68.46) ; v2(214.88,39.02) 214.85,38.99 CD104.1 ; CD95.1 205.54,60.15 v2(206.24,60.85) ; CD101.1 203.27,66.98 v2(203.22,67.02) ; v2(240.98,65.25) 240.91,65.17 CD33.1 ; v2(215.8,58.57) 215.98,58.75 RD44.1 ; v2(243.23,60.48) 242.8,60.04 RD18.1 ; v2(203.1,56.33) 203.1,56.34 CD100.1 ; CD13.1 243.22,44.59 v2(242.98,44.35) ; CD74.1 215.76,86.8 v2(215.8,86.76) ; CD1.1 244.55,65.68 v2(244.12,65.25) ; CD39.1 240.8,50.29 v2(241.03,50.53) ; v2(201.82,89.82) 201.74,89.74 CD106.1 ; v2(214.15,61.41) 213.97,61.24 CD97.1 ; CD70.1 217.47,54.79 v2(217.4,54.86) ; v2(241,55.25) 240.78,55.03 CD34.1 ; v2(251.82,51.64) 252.39,51.64 RD51.1 ; v2(242.8,73.63) 242.33,74.1 CD46.1 ; v2(202.84,34.31) 202.87,34.29 CD105.1 ; CD66.1 217.57,58.29 v2(217.29,58.57) ; v2(224.76,59.88) 224.76,59.08 CD68.1 ; v2(216.74,35.39) 216.78,35.43 CD73.1 ; v2(228.9,89.48) 229.04,89.61 CD45.1 ; v2(225.66,68.46) 226.2,67.92 CD65.1 ; v2(244.24,55.25) 244.47,55.47 CD7.1 ; CD103.1 202.34,46.14 v2(202.34,46.76) ; v2(229.64,36.85) 229.81,36.69 CD41.1 ; v2(243.1,76.53) 243.12,76.52 CD12.1 ; v2(217.32,68.46) 217.77,68.01 CD67.1 ; RD32.1 228.02,61.53 v2(228.13,61.41) ; CD14.1 v2(252.37,40.16) ; CD76.1 224.8,40.07 v2(224.92,39.96) ; v2(230.4,59.95) 230.67,60.22 CD36.1 ; v2(228.24,83.94) 228.21,83.97 CD79.1 ; CD44.1 237.12,82.37 v2(237.01,82.26) ; v2(255.01,73.03) 255.06,72.97 CD9.1 ; v2(255.03,60.53) 255.67,61.16 CD2.1 ; CD32.1 230.08,68.65 v2(229.88,68.46) ; v2(243.96,68.4) 243.98,68.37 CD4.1 ; v2(230.28,56.03) 230.8,55.51 CD38.1 ; CD10.1 v2(252.42,49.78) ; CD35.1 240.96,57.48 v2(241.07,57.37) ; CD99.1 213.99,54.99 v2(214.14,54.84) ; v2(214.4,58.57) 213.87,58.04 CD98.1 ; v2(247.37,35.58) 247.37,35.16 CD15.1 ; v2(241.05,60.48) 240.94,60.58 240.14,60.58 CD37.1 ; v2(241.66,30.58) 241.66,31.04 CD40.1
  TOP w0.356: CD16.1 255.71,30.16 v2(255.49,30.38)
  TOP w0.508: 158.14,73.11 157.95,73.3 156.87,73.3 156.44,73.73 RC25.2 ; CH197.1 182.13,29.25 182.14,29.26 ; CD6.1 267.87,77.3 266.73,78.45 260.62,78.45 258.37,80.69
  TOP w1.016: 168.25,97.97 168.25,96.29 169.82,94.71 188.72,94.71 188.8,94.79
  BOTTOM w0.254: UC1.AU13 v2(164.75,69)
  BOTTOM w0.305: JDIMM1.136 253.8,60.53 v2(255.03,60.53) ; v2(225.45,52.37) 225.45,51.14 226.07,50.53 JDIMM2.96 ; 202.44,57.27 202.44,57.28 JDIMM4.123 ; 202.44,57.27 202.44,58.57 202.64,58.78 JDIMM4.129 ; 202.44,57.27 202.44,56.69 v2(202.08,56.33) ; v2(238.36,39.48) 238.36,39.7 238.68,40.03 JDIMM3.54 ; JDIMM1.96 252.98,50.53 252.42,49.97 v2(252.42,49.78) ; JDIMM2.163 217.56,69.27 217.32,69.04 v2(217.32,68.46) 217.5,68.27 JDIMM2.159 ; v2(247.48,90.19) 247.48,89.65 246.61,88.78 JDIMM1.241 ; JDIMM3.147 230.66,65.28 230.6,65.22 v2(230,65.22) ; v2(255.03,59.03) 253.8,59.03 JDIMM1.130 ; JDIMM1.54 252.5,40.03 v2(252.37,40.16) ; JDIMM4.130 213.95,59.03 v2(214.4,58.57) 214.4,57.83 214.1,57.53 JDIMM4.124 ; v2(225.66,68.46) 225.73,68.53 JDIMM2.160 227.76,68.53 228.12,68.17 228.12,67.43 227.71,67.03 JDIMM2.154 ; JDIMM3.129 230.68,58.78 230.4,59.06 v2(230.4,59.95) 230.72,60.28 JDIMM3.135 ; JDIMM4.153 203.47,66.78 v2(203.22,67.02) ; v2(167.96,60.26) 167.09,60.26 UC1.AY23 ; JDIMM2.112 227.73,54.53 228.12,54.91 v2(228.12,55.91) 228,56.03 226.91,56.03 JDIMM2.118 ; v2(216.74,35.39) 216.74,35.11 217.07,34.78 JDIMM2.33 ; JDIMM1.154 v2(255.03,67.03) ; JDIMM2.241 216.36,88.78 215.8,88.21 v2(215.8,86.76) ; JDIMM1.135 244.62,60.28 244.42,60.48 v2(244.04,60.48) ; JDIMM1.111 244.6,54.28 244.25,54.63 244.25,55.24 v2(244.24,55.25) 244.24,55.44 244.58,55.78 245.6,55.78 JDIMM1.117 ; v2(224.92,39.96) 224.99,40.03 JDIMM2.54 ; JDIMM4.160 214.16,68.53 v2(214.22,68.46) 214.22,67.54 213.71,67.03 JDIMM4.154 ; JDIMM2.220 226.9,83.53 227.83,83.53 v2(228.24,83.94) ; JDIMM4.178 213.97,73.03 214.27,73.33 v2(214.27,73.87) ; v2(201.82,89.82) 202.86,88.78 204.7,88.78 JDIMM4.241 ; JDIMM2.12 225.21,29.53 v2(225.13,29.6) ; v2(255.49,30.38) 255.49,30.33 254.69,29.53 JDIMM1.12 ; JDIMM3.124 240.92,57.53 v2(241.07,57.37) ; JDIMM1.124 253.8,57.53 v2(255.03,57.53) ; JDIMM3.178 242.19,73.03 v2(242.8,73.63) ; JDIMM4.33 203.18,34.78 202.84,34.44 v2(202.84,34.31) ; JDIMM4.118 212.9,56.03 213.86,56.03 214.16,55.72 214.16,54.84 v2(214.14,54.84) 213.83,54.53 JDIMM4.112 ; v2(255.01,73.03) 254.05,73.03 JDIMM1.178 ; v2(237.01,82.26) 237.01,82.57 237.96,83.53 JDIMM3.220 ; JDIMM2.135 217.78,60.28 217.29,59.78 v2(217.29,58.57) 217.49,58.78 JDIMM2.129 ; JDIMM3.130 240.79,59.03 241.1,58.72 242.24,58.72 243.23,59.71 v2(243.23,60.48) ; 244.31,69.28 JDIMM1.163 ; v2(233.83,46.25) 233.65,46.25 232.68,45.28 JDIMM3.75 ; UC1.AU15 164.23,67.7 v2(163.84,68.1) ; JDIMM1.160 253.8,68.53 254.86,68.53 v2(254.98,68.4) ; v2(229.27,73.65) 228.65,73.02 JDIMM2.178 ; v2(214.69,82.07) 214.65,82.11 214.65,83.28 214.41,83.53 JDIMM4.220 ; JDIMM2.141 218.7,61.78 217.6,61.78 216.89,62.48 216.89,64.46 217.19,64.77 v2(217.19,65.22) 217.25,65.27 JDIMM2.147 ; v2(215.8,58.57) 215.8,58.04 216.56,57.28 JDIMM2.123 ; v2(228.9,89.48) 229,89.48 229.7,88.78 JDIMM3.241 ; JDIMM4.54 212.9,40.03 214.35,40.03 214.88,39.5 v2(214.88,39.02) ; 228.18,61.94 228.1,62.03 JDIMM2.142 ; JDIMM1.220 253.8,83.53 v2(255.03,83.53) ; v2(202.67,67.02) 202.67,65.73 203.12,65.28 JDIMM4.147 ; v2(216,30.88) 216,30.26 215.7,29.53 JDIMM4.12 ; v2(230.28,56.03) 230.28,54.58 230.58,54.28 JDIMM3.111 ; v2(230.28,56.03) 230.53,55.78 JDIMM3.117 ; v2(230.28,56.03) 230.28,56.97 230.58,57.28 JDIMM3.123 ; 228.25,60.92 227.85,60.53 JDIMM2.136 ; v2(215.98,78.51) 215.98,78.1 216.21,77.87 217.12,77.87 217.52,78.27 JDIMM2.199 ; JDIMM3.112 240.58,54.53 241,54.94 v2(241,55.25) 241,55.83 240.81,56.03 JDIMM3.118 ; JDIMM1.153 244.72,66.78 244.12,66.17 v2(244.12,65.25) 244.14,65.28 JDIMM1.147 ; v2(247.37,35.58) 247.37,35.08 247.07,34.78 JDIMM1.33 ; v2(243.1,76.53) 243.1,76.98 244.39,78.28 JDIMM1.199 ; JDIMM1.148 254,65.53 v2(255.03,65.53) ; v2(202.5,79.02) 202.5,78.6 202.82,78.28 JDIMM4.199 ; v2(243.96,68.4) 244.08,68.28 JDIMM1.159 ; v2(224.76,59.88) 224.76,59.52 225.25,59.03 JDIMM2.130 228.2,59.03 228.42,58.8 228.42,57.81 228.14,57.53 JDIMM2.124 ; JDIMM3.148 240.71,65.53 v2(240.98,65.25) 241.34,65.61 241.34,66.51 241.05,66.8 240.82,66.8 240.59,67.03 JDIMM3.154 ; 203.11,56.33 v2(203.1,56.33) 203.09,56.33 202.72,55.96 202.72,54.58 203.02,54.28 JDIMM4.111 ; v2(216.61,65.2) 216.61,66.11 217.27,66.78 218.7,66.78 JDIMM2.153 ; JDIMM4.75 202.96,45.28 202.34,45.9 v2(202.34,46.76) ; JDIMM4.135 203.89,60.28 v2(203.32,60.85) 203.17,60.99 203.17,61.59 203.36,61.78 JDIMM4.141 ; JDIMM1.129 245.58,58.78 243.56,58.78 242.49,57.71 v2(242.49,57.35) ; JDIMM4.148 212.16,65.53 212.11,65.48 211.74,65.48 v2(211.48,65.22) ; JDIMM1.142 253.8,62.03 v2(255.03,62.03) ; v2(214.27,50.05) 214.27,50.3 214.05,50.53 JDIMM4.96 ; v2(200.48,71.88) 200.48,70.46 202.66,68.28 JDIMM4.159 ; v2(244.37,57.35) 244.68,57.35 244.75,57.28 JDIMM1.123 ; JDIMM3.163 230.72,69.28 230.58,69.14 229.59,69.14 229.3,68.85 v2(229.3,68.46) ; JDIMM3.136 241,60.53 v2(241.05,60.48) ; v2(255.03,56.03) 253.8,56.03 JDIMM1.118 ; JDIMM1.112 v2(255.03,54.53) ; v2(242.98,44.35) 242.98,44.73 243.52,45.28 JDIMM1.75 ; v2(228.24,65.22) 227.93,65.53 JDIMM2.148 ; v2(241.03,68.4) 240.91,68.53 JDIMM3.160 ; v2(244.02,61.97) 244.41,61.97 244.61,61.78 JDIMM1.141 ; JDIMM4.142 213.84,62.03 214.15,61.72 v2(214.15,61.41) 214.15,60.83 213.84,60.53 JDIMM4.136 ; v2(241.66,30.58) 241.66,30.08 241.11,29.53 JDIMM3.12 ; v2(233.07,62.13) 232.72,61.78 JDIMM3.141 ; JDIMM4.163 202.3,69.28 201.04,70.53 v2(201.04,71.88) ; JDIMM3.33 230.45,34.78 229.64,35.58 v2(229.64,36.85) ; 203.42,55.78 204.7,55.78 JDIMM4.117 ; JDIMM3.199 230.03,78.28 v2(229.31,79) ; 240.92,62.03 JDIMM3.142 ; v2(216.69,44.23) 216.69,44.97 216.99,45.28 JDIMM2.75 ; JDIMM3.159 230.07,68.28 v2(229.88,68.46) 229.88,67.58 230.69,66.78 JDIMM3.153 ; JDIMM2.111 217.83,54.28 217.4,54.71 v2(217.4,54.86) 217.4,55.46 217.71,55.78 218.7,55.78 JDIMM2.117 ; JDIMM3.96 v2(241.03,50.53)
  BOTTOM w0.356: v2(163.84,61.71) 163.41,62.14 UC1.AT21 ; UC1.AV11 165.21,71.57 v2(165.56,71.92) ; UC1.AW10 v2(164.75,74.86) ; v2(165.84,62.14) UC1.AV21 ; v2(165.67,58.07) 166.09,58.49 UC1.AW25 ; v2(167.77,66.71) 167.77,66.72 UC1.AY16 ; v2(167.67,70.46) 167.59,70.37 UC1.AY12 ; v2(165.72,65.34) 165.67,65.34 UC1.AV17 ; v2(167.78,64.83) 167.73,64.89 UC1.AY18 ; UC1.AU19 164.29,63.95 v2(163.84,63.49) ; v2(163.84,59.83) UC1.AU23 ; v2(166.58,69) UC1.AW14 ; v2(163.84,65.32) UC1.AT18
  vias: v2(171.7,49.81) v2(201.07,46.76) v2(201.36,39.02) v2(201.7,46.76) v2(208.25,50.05) v2(208.89,50.05) v2(214.73,61.41) v2(215.24,65.22) v2(215.44,70.08) v2(215.98,68.45) v2(216.61,70.08) v2(216.66,61.41) v2(221.84,59.88) v2(224.82,80.24) v2(251.06,86.51) v3(185.26,44.66)
+1.2V_VCCPLL_OC: length 25.3
  TOP w0.254: RC21.2 155.1,77.22 155.1,79.15 155.04,79.21 155.04,79.79 156.05,80.8 156.5,80.8 159.41,83.72 159.41,86.89 163.66,91.15 163.66,98.38
  vias: v3(164.75,98.13)
+1.2VP: length 86
  TOP w0.254: v2(217.67,119.23) 218.02,118.89 PU201.19 ; PR205.2 214.85,115.91 214.91,115.85 215.29,115.85 215.85,115.29 v2(216.13,115.29) 216.13,115.54 216.67,116.08 PU201.5
  IN4 w0.254: v2(248.19,113.85) 248.19,112.01 247.49,111.31 228.4,111.31 227.4,112.32 223.76,112.32 221.72,114.36 216.72,114.36 216.13,114.95 v2(216.13,115.29)
  IN4 w0.508: v2(249.08,113.79) 249.08,112.23 247.69,110.83 228.2,110.83 227.2,111.83 223.56,111.83 221.52,113.88 214.91,113.88 214.21,114.58 214.21,117.75 215.17,118.7 216.25,118.7 216.77,119.23 v2(217.67,119.23)
  vias: v3(261.01,111.15)
+1.05V_VCCAMPHYPLL: length 1.4
  TOP w0.089: CH263.1 v3(263.68,37.49)
+1.05V_VCCST: length 449.3
  TOP w0.254: RH627.1 RH495.1 122.71,83.86 122.06,84.51 v2(122.06,84.7) ; RC16.1 134.98,28.6 RC3.1 RC17.1 v2(133.96,27.53) ; RH613.2 296.93,30.38 v2(296.74,30.57)
  TOP w0.508: v2(139.39,97.24) 139.48,97.24 139.54,97.18 139.54,94.13 v3(141.79,91.87) 144.8,88.86 v2(144.8,84.22) ; RH103.1 142.02,72.62 v2(142.07,72.67)
  IN1 w0.254: v2(296.74,30.57) 296.74,29.79 295.55,28.6 295.55,26.44 296.76,25.23 297.36,25.23 298.67,23.93 298.67,23.58 299.87,22.38 300.12,22.38 300.72,21.77 300.72,16.8 302.87,14.65 302.87,13.84 v2(303.02,13.69) ; v2(83.46,23.26) 83.46,24.85 84.04,25.42 88.55,25.42 90.64,23.33 93.47,23.33 94.83,21.97 106.77,21.97 108.78,19.96 v2(110.03,19.96)
  IN3 w0.254: v2(127.53,6.5) 127.68,6.65 139.7,6.65 139.96,6.39 166.45,6.39 167.13,5.71 178.57,5.71 179.4,4.87 181.99,4.87 182.59,5.47 186.1,5.47 190.71,10.09 195.51,10.09 196.65,8.94 223.19,8.94 223.99,8.15 241.01,8.15 244.16,11.31 249.15,11.31 251.58,8.88 257.89,8.88 258.14,9.13 258.14,9.67 258.47,10 261.08,10 264.14,13.06 264.14,14.17 267.75,17.78 269.26,17.78 269.75,18.27 269.75,19.41 269.98,19.64 275.67,19.64 277.54,17.77 277.54,14.81 279.26,13.09 283.34,13.09 285.07,14.83 286.54,14.83 287.34,14.03 292.26,14.03 292.51,13.77 302.94,13.77 v2(303.02,13.69) ; v2(110.03,19.96) 110.03,21.15 112.97,24.09 130.77,24.09 133.96,27.28 v2(133.96,27.53)
  IN3 w0.508: v2(150.43,104.77) 149.9,104.24 140.47,104.24 v2(139.25,103.03)
  IN3 w1.016: 130.52,79.27 129.88,79.27 128.55,80.6 122.83,80.6 120.55,78.32 109.36,78.32 106.02,74.98 106.02,65.56 89.76,49.3 89.18,49.3
  IN4 w0.508: v2(82.83,23.26) 80.94,23.26 80.17,22.5 70.92,22.5 68.91,24.51 67.54,24.51 66.51,23.48 66.51,22.63 65.84,21.95 65.12,21.95 64.17,22.9 62.02,22.9 61.41,23.52 58.97,23.52 57.32,25.17 57.32,27.76 57.04,28.04 v2(57.04,28.13) ; v2(146.44,80.47) 146.31,80.47 145.76,81.02 145.76,83.27 v2(144.8,84.22)
  BOTTOM w0.254: v2(110.03,19.96) 110.03,16.71 113.13,13.6 115.97,13.6 119.29,10.28 124.16,10.28 125.37,9.07 125.37,7.69 126.57,6.5 v2(127.53,6.5) ; RC2.1 119.13,83.82 120.61,85.3 RC693.1 121.68,85.07 v2(122.06,84.7) ; CC31.1 148.7,103.88 148.89,104.07 CC30.1 CC38.1 150.65,104.54 v2(150.43,104.77)
  BOTTOM w0.508: v2(139.39,97.24) 139.6,97.45 139.6,101.51 139.25,101.86 v2(139.25,103.03) 139.72,103.5 RC12.1 ; PCZ01.1 57.03,32.14 PRZ06.1 57.04,31.38 PRZ05.1 PRZ01.1 v2(57.04,28.13)
  vias: v2(145.5,77.56)
+1.05V_XTAL: length 21.9
  TOP w0.152: UH1.P3 291.25,47.83 UH1.P2
  TOP w0.254: 291.9,48.09 291.99,48.18 292.34,48.18 292.54,48.37 292.6,48.37 292.68,48.45 293.53,48.45 294.2,47.78 294.2,47.6
  TOP w0.508: 294.2,47.6 295.11,46.69 295.11,46.68 295.19,46.61 295.19,46.02 297.87,43.33 v3(298.1,43.33) 299.56,43.33 300.41,44.18 CH56.1 301.21,45.81 301.57,45.45 301.57,43.54 300.89,42.86 300.89,42.06 299.18,40.35 LH1.2
+1.8V_PRIM: length 2.7
  TOP w0.254: UH1.AG19 283.27,53.94 v2(283.21,53.94) 282.86,54.29 UH1.AG20 ; UH1.BB11 287.74,61.55 v2(287.87,61.42) ; UH1.AN15 v2(285.46,57.65) ; UH1.AR15 v2(285.46,58.74)
  vias: v3(285.46,59.46)
+1.8VA_TBTA_LDO: length 4.6
  BOTTOM w0.254: UT4.K1 41.11,49.07 40.77,49.41 40.77,49.73 40.52,49.98 40.52,50.09 39.91,50.71 v1(39.91,50.95) 39.91,51.62 39.21,52.32 CT100.1
+1.8VALW: length 495.9
  TOP w0.127: v2(339.12,40.54) v3(339.75,40.54)
  TOP w0.254: v2(208.88,126.64) 208.88,125.44 210.34,123.98 210.34,119.03 210.09,118.78 210.09,117.94 209.35,117.2 192.96,117.2 182.91,107.15 176.43,107.15 176.24,106.96 126.39,106.96 125.89,107.47 123.92,107.47 116.84,114.55 116.84,120.07 120.81,124.04 v2(120.81,125.05) ; RS12.2 v2(115.66,171.09) ; RS11.2 v2(110.3,171.64)
  TOP w0.381: RH180.1 296.2,62.43 296.72,62.95 296.72,64.21 RH181.1
  TOP w0.508: CE204.1 266.64,80.36 UE13.5 267.68,81.36 268.24,80.8 v2(268.32,80.8) 269.08,80.8 269.9,79.97 RE50.1 ; v2(296.19,59.9) 296.61,60.32 RH182.1 RH603.1 296.61,61.95 RH180.1
  IN1 w0.381: v2(268.32,80.8) 268.42,80.8 271.72,84.1 v2(274.54,84.1)
  IN2 w0.254: v2(120.81,125.05) 119.73,123.98 107.66,123.98 106.11,125.53 106.11,130.67 111.1,135.66 111.1,138.7 106.39,143.4 106.39,155.28 108.11,157 108.11,166.46 108.73,167.08 108.73,169.64 109.06,171.15 109.54,171.64 v2(110.3,171.64)
  IN3 w0.254: v2(110.3,171.64) 110.3,172.08 110.65,172.43 114.33,172.43 v2(115.66,171.09)
  IN3 w0.508: v2(339.12,40.54) 338.36,39.77 336.08,39.77 335.2,38.89 335.2,31.76 331.37,27.94 331.37,24.77 330.11,23.52 328.02,23.52 326.93,22.43 320.9,22.43 319.18,24.15 316.52,24.15 313.47,27.2 313.03,27.2 311.62,28.61 311.62,29.3 311.12,29.79 309.09,29.79 307.91,30.97 307.91,32.99 306.82,34.09 304.86,34.09 304.64,34.31 304.64,34.31 304.62,34.33 303.22,34.33 300.93,36.62 300.93,44.77 303.34,47.18 303.34,48.57 302.58,49.33
  IN3 w1.016: v2(285.92,68.98) 290.28,68.98 291.96,67.3 292.95,67.3 294.16,66.1 294.16,64.93 296.19,62.9 v2(296.19,59.9) 298.47,57.62 298.47,55.73 298.63,55.56 298.63,54.86 298.09,54.32 298.09,52.73 298.67,52.16 299.96,52.16 300.79,51.32 301.26,51.32 301.3,51.28 301.45,51.28
  IN4 w0.254: v2(255.05,108.67) 254.17,109.54 238.46,109.54 237.57,108.64 228.44,108.64 226.34,110.74 215.17,110.74 214.88,111.02 212.37,111.02 209.83,113.56 209.83,124.51 208.88,125.46 v2(208.88,126.64)
  IN4 w0.508: v2(269.27,70.1) 270.02,69.35 278.85,69.35 279.07,69.57 283.42,69.57 284,68.98 v2(285.92,68.98) ; v2(352.2,38.38) 352.2,38.19 351.61,37.6 349.74,37.6 347.21,40.13 340.41,40.13 340.01,40.54 v2(339.12,40.54)
  BOTTOM w0.356: RH723.2 353.05,39.16 352.26,38.38 v2(352.2,38.38) 351.88,38.06 351.88,36.03 352.32,35.59 353.86,35.59 354.31,35.14 RH722.2
  BOTTOM w0.381: 275.58,86.38 275.58,94.55 271.23,98.9 259.92,98.9 259.24,99.59 259.24,107.34 257.46,109.12 255.49,109.12 v2(255.05,108.67) ; 275.58,86.38 274.54,85.35 v2(274.54,84.1) ; 275.58,86.38 280.89,86.38 281.32,86.81 281.32,87.7 281.74,88.12 283.09,88.12 283.44,87.77 QH1.2 283.44,86.78 283.13,86.46 RH1027.2
  BOTTOM w0.508: RH599.2 286.87,67.83 285.92,68.77 v2(285.92,68.98) ; v2(269.27,70.1) 269.27,71.8 269.19,71.89 269.19,80.15 268.54,80.8 v2(268.32,80.8)
  BOTTOM w1.016: 304.28,40.37 304.73,40.82 304.73,44.63 304.75,44.65 304.75,49.8
  vias: v2(302.41,50.63) v2(302.41,50.05)
+1.8VD_TBTA_LDO: length 4.5
  BOTTOM w0.254: UT4.A2 41.79,44.32 41.37,43.89 41.37,42.64 v1(40.89,42.16) CT99.1
+1.8VS_EC: length 12.5
  TOP w0.381: UE13.1 270.32,81.36 CE203.1 271.3,80.38 RE50.2 271.3,78.66 272.33,77.63 v1(272.33,76.9) 272.33,76.49 272.91,75.91 272.91,72.36 273.4,71.88 RH111.2 RH518.2
+1.8VSP: length 0.9
  TOP w0.508: v2(300.32,37.87) 300.57,37.62 PC1803.1
  vias: v3(302.23,35.84)
+1.8VSP_ADJ:
  vias: v1(302.61,31.9)
+1.8VSP_EN: length 6.3
  BOTTOM w0.112: PR1801.1 292.46,34.12 291.99,33.66 291.22,33.66 v1(290.61,34.27)
  BOTTOM w0.254: PR1801.1 293.15,33.55 PR1802.1 PC1805.1 293.61,32.28 294.13,32.8 PU1801.2
+1.8VSP_PGOOD: length 2.7
  BOTTOM w0.112: v1(292.17,31.26) 292.28,31.37 PR1803.2
  BOTTOM w0.254: PU1801.1 293.27,31.53 PR1803.2
+1.8VSP_VIN: length 1.1
  TOP w0.089: v2(292.76,36.49) v3(291.63,36.49)
  vias: v2(292.76,35.93)
+1.24V_DPHY: length 44.2
  TOP w0.203: 291.8,65.38 290.49,64.07 UH1.BG5
  TOP w0.254: UH1.AK23 281.38,55.85 v2(281.71,56.18) 282.04,55.85 UH1.AK22 ; UH1.AJ22 282.07,55.08 v2(281.69,55.46) 281.31,55.09 UH1.AJ23
  TOP w0.3: CH36.1 293.55,66.54 293.55,65.71 293.22,65.38 291.8,65.38
  TOP w0.508: CH36.1 293.67,68.11 293.67,70.82 293.16,71.33 292.44,71.33 291.84,70.72 291.17,70.72 290.82,71.08 290.82,71.12 290.75,71.19 290.75,72.29 291.26,72.79 v2(291.43,72.79)
  IN2 w0.381: v2(288.38,67.41) 289.02,67.41 289.41,67.03 289.41,64.63 288.23,63.46 286.28,63.46 285.45,62.63 285.45,61.04 285.69,60.79 285.69,59.61 286.66,58.63 286.66,57.49 286.13,56.96 285.24,56.96 284.45,56.17 281.72,56.17 v2(281.71,56.18) 281.71,55.49 v2(281.69,55.46)
  BOTTOM w0.508: v2(288.38,67.41) v3(290.15,69.19) 290.73,69.77 290.73,72.29 291.24,72.79 v2(291.43,72.79)
+1V_MPHY: length 6.3
  TOP w0.203: UH1.W20 v2(283.25,50.82) UH1.W19
  TOP w0.254: v2(277.81,50.88) 277.44,50.51 UH1.W31 ; v2(283.25,50.04) UH1.V19 ; UH1.B3 UH1.B2 UH1.B1 ; UH1.C1 UH1.C2
  TOP w0.508: 297.03,37.81 298.62,37.81 LH1.1
  vias: v2(266.15,42.63) v2(266.15,42.06) v2(292.89,41.67) v3(281.27,49.24)
+1VALW: length 355
  TOP w0.203: v2(278.63,52.37) 278.6,52.37 UH1.AD30 v2(278.64,53.19) ; v2(278.63,52.37) 278.24,51.98 ; v2(278.63,52.37) 278.63,52.34 UH1.AB28 ; v2(278.63,52.37) 278.63,52.39 UH1.AD28 ; v2(278.64,53.19) 278.58,53.19 278.24,53.53 ; v2(278.64,53.19) 278.99,52.84 UH1.AD28 ; v2(281.7,51.59) UH1.AA23 v2(280.92,51.59) UH1.AB23 ; v2(281.7,51.59) UH1.AB22 v2(281.7,52.37) ; v2(281.7,51.59) UH1.AB23 ; v2(281.7,51.59) UH1.AA22 ; UH1.AB28 279.05,51.98 v2(279.43,52.36) ; UH1.AB28 278.99,51.94 v2(278.64,51.6) 278.26,51.98 278.24,51.98 ; UH1.AB28 279.37,51.6 v2(279.44,51.6) 279.44,51.66 UH1.AB27 ; 278.24,53.53 UH1.AF30 ; 278.24,53.53 v2(278.64,53.93) ; UH1.V30 277.91,49.35 v2(277.84,49.35) 277.74,49.35 UH1.V31 277.8,50.02 277.8,50.06 277.85,50.02 ; UH1.V30 278.57,50.01 v2(278.63,50.01) UH1.V28 ; UH1.V30 UH1.U29 UH1.V28 ; UH1.V30 277.85,50.02 ; v2(277.85,49.97) 277.85,50.02 ; UH1.V28 279.35,50.01 v2(279.44,50.01) ; v2(279.43,52.36) 279.03,52.75 UH1.AD28 ; v2(279.43,52.36) 279.76,52.02 UH1.AB27 ; v2(279.43,52.36) 279.76,52.69 UH1.AD27 ; v2(281.7,52.37) UH1.AD23 281.31,52.83 v2(281.67,53.19) 281.34,53.53 UH1.AF23 v2(281.7,53.92) ; v2(281.7,52.37) UH1.AB23 ; 278.24,51.98 UH1.AB30 ; UH1.W22 282.09,50.41 v2(281.76,50.08) 281.4,50.43 UH1.W23 ; UH1.AD27 280.12,52.39 v2(280.12,52.34) UH1.AB27 ; UH1.AD27 280.1,53.09 v2(280.1,53.17) 280.07,53.17 279.76,53.48 UH1.AF27 v2(280.12,53.89) ; UH1.AG31 v2(277.82,53.92) ; UH1.AF31 277.51,53.53 v2(277.82,53.22) ; UH1.V27 v2(280.12,50.01) 280.47,49.65 UH1.V25 280.21,49.38 UH1.U26 ; UH1.AD31 v2(277.82,52.37)
  TOP w0.254: v2(277.82,53.22) 277.91,53.22 UH1.AF30 ; v2(284.54,52.74) UH1.AE17 ; UH1.BG45 UH1.BG46 ; UH1.E1 UH1.D1 292.61,42.79 292.78,42.97 v2(293.08,42.97) ; v2(282.47,52.37) UH1.AD20 ; v2(62.76,41.83) 62.81,41.88 62.81,42.12 JPCMC.22 ; v2(279.44,50.01) 279.44,50.01 279.44,49.98 UH1.V27
  TOP w0.305: UH1.AB20 v2(283.25,52.37)
  TOP w0.356: CH185.1 264.86,52.77 v2(265.28,52.35) 265.12,52.19 CH188.1
  TOP w0.381: v2(269.96,64.54) 269.96,64.38 270.08,64.27 UH1.BG46
  TOP w0.508: v2(120.23,23.35) 111.12,23.35 109.25,21.49 107.16,21.49 106.63,20.95 106.63,20.22 106.45,20.03 101.19,20.03 99,22.22 96.65,22.22 95,23.87 88.39,23.87 87.3,24.97 82.22,24.97 80.8,23.54 ; v2(56.48,35.74) 56.48,36.58 57.38,37.48 57.38,37.72 RC353.1 ; RH71.1 296.81,46.59 297.84,45.55 297.84,44.22 v2(298.03,44.03) ; v2(71.35,40.08) v3(69.82,40.08) 63.4,40.08 62.81,40.66 62.81,41.78 v2(62.76,41.83) ; v2(70.92,26.06) 70.92,23.58 71.42,23.07 79.04,23.07 79.05,23.09
  IN1 w0.508: v2(293.08,42.97) 293.79,42.97 294.66,43.83 297.83,43.83 v2(298.03,44.03)
  IN3 w0.508: 263.98,40.74 264.03,40.69 264.03,40.16 263.83,40.16 256.42,32.75 255.11,32.75 251.7,29.34 246.72,29.34 245.34,27.96 242.92,27.96 241.74,26.79 237.87,26.79 237.39,27.26 231.86,27.26 227.06,22.46 217.22,22.46 216.98,22.22 215.5,22.22 215.49,22.21 206.65,22.21 205.29,23.57 188.03,23.57 186.05,25.55 145.79,25.55 145.46,25.88 133.61,25.88 131.08,23.35 v2(120.23,23.35) ; v2(71.35,40.08) 69.47,38.2 69.47,36.28 68.76,35.57 68.76,34.27 67.96,33.47 67.96,28.65 68.71,27.9 69.21,27.9 70.92,26.2 v2(70.92,26.06)
  IN4 w0.508: v2(302.35,54.32) 303.28,53.39 303.28,47.81 300.58,45.11 298.54,45.11 298.03,44.6 v2(298.03,44.03)
  BOTTOM w0.356: v2(280.44,46.78) 280.56,46.9 CH183.1 CH180.1
  BOTTOM w0.508: v2(269.96,64.54) 269.06,63.64 269.06,58.78 267.95,57.67 267.36,57.67 266.07,56.39 266.07,55.35 264.72,54 264.72,53.08 265.28,52.53 v2(265.28,52.35) 265.28,51.63 263.67,50.03 263.67,47.74 263.05,47.12 v2(263.05,44.65) ; v2(280.44,46.78) 280.89,46.34 CH189.1 CH181.1 ; v2(284.54,52.74) 285,52.28 291.47,52.28 292.43,53.24 295.05,53.24 295.84,52.45 297.12,52.45 298.74,54.07 298.74,54.6 299.1,54.95 299.6,54.95 300.24,54.32 v2(302.35,54.32) ; v2(62.76,41.83) 62.74,41.81 62.74,41.15 59.55,37.96 56.98,37.96 56.48,37.45 v2(56.48,35.74)
  vias: v2(263.05,44.07) v2(263.05,43.48) v2(263.05,42.9) v2(263.05,42.32) v2(263.05,41.73) v2(263.66,44.65) v2(263.66,44.07) v2(263.66,43.48) v2(263.66,42.9) v2(263.66,42.32) v2(263.66,41.73)
+1VALWP: length 20.3
  TOP w0.254: 258.04,26.41 257.52,25.89 257.52,13.61 258.03,13.1 258.03,8.72 259.22,7.53 PR107.2
  vias: v3(259.11,21.23)
+1VALWP_B+: length 1.2
  TOP w0.127: 272.19,22.12 272.19,22.88 v3(271.87,23.2)
+1VALWP_PGOOD: length 71.6
  TOP w0.127: v1(258.47,12.66) 258.73,12.41 v2(260.58,12.41)
  TOP w0.254: v2(295.01,26.86) 295.09,26.86 295.52,26.44 295.52,26.41 295.54,26.39 UE5.122 ; PU101.1 261.75,10.34 261.49,10.6 261.48,10.6 261.32,10.75 PR101.2
  TOP w0.508: v2(260.58,12.41) PR101.2
  IN3 w0.508: v2(295.01,26.86) 294.28,26.86 293.37,27.77 292.44,27.77 290.41,29.81 290.41,30.43 288.15,32.69 284.65,32.69 284.32,33.02 284.32,34.3 283.96,34.66 283.38,34.66 281.89,33.17 280.44,33.17 279.05,31.79 264.3,31.79 259.12,26.61 258.41,26.61 v2(257.03,25.23)
  BOTTOM w0.508: v2(260.58,12.41) 260.58,11.47 259.99,10.88 258.41,10.88 257.58,11.71 257.58,24.69 v2(257.03,25.23)
+2.5V_MEM: length 159.7
  IN2 w0.508: v2(244.22,93.28) 244.22,92.87 243.81,92.45 241.48,92.45 238.29,93.76 237.64,94.41
  BOTTOM w0.305: JDIMM4.257 205.86,92.78 206.02,92.94 v2(206.02,93.32) 205.98,93.28 JDIMM4.259
  BOTTOM w0.508: 212.62,20.85 215.42,20.85 215.8,20.47 217.89,20.47 219.47,22.04 219.47,22.61 218.54,22.61 217.13,24.03 213.07,24.03 211.26,22.21 212.62,20.85
  BOTTOM w1.016: 219.47,22.61 229.22,22.61 230.73,21.11 230.73,20.09 ; 204.78,96.04 204.78,98.99 201.03,102.74 193.06,102.74 190.43,100.11 190.43,26.31 194.53,22.21 211.26,22.21
  vias: v2(218.17,94.04) v2(218.75,94.04) v2(230.56,94.54) v2(231.14,94.54) v3(244.82,92.86)
+2.5V_MEMP:
  vias: v3(231.55,15.96)
+2.5VOUT: length 33.8
  TOP w0.127: v2(169.82,185.19) v3(170.53,185.19)
  IN2 w0.508: v2(168.3,176.74) 168.3,176.93 168.62,177.25 168.62,184.11 169.7,185.19 v2(169.82,185.19) 170.08,185.44 v2(173.77,185.44) 173.77,185.44 175.79,183.41 175.79,180.74 176.4,180.14 v2(176.64,180.14)
  BOTTOM w0.254: 176.65,180.14 176.5,180.3 UM8.51 ; 176.65,180.14 v2(176.64,180.14) ; 176.65,180.14 176.74,180.23 176.77,180.23 176.8,180.25 176.97,180.25 176.97,180.26 177.11,180.26 177.3,180.45 CM9.1 ; CM35.1 169.96,175.68 169.96,176.02 171.06,177.13 UM8.9 ; v2(173.77,185.44) 173.49,185.16 CM34.1 173.06,185.1 UM8.41 ; UM8.14 168.56,177.26 168.3,177 v2(168.3,176.74) ; CM32.1 170.56,185.14 UM8.36
  BOTTOM w0.508: CM35.1 169.31,175.49 168.93,175.87 CM36.1 168.3,176.07 v2(168.3,176.74) ; v2(169.82,185.19) CM32.1
+2.5VOUT_TBT: length 13.2
  TOP w0.254: UT6.36 43.15,25.72 43,25.58 v1(41.27,25.58) v2(40.64,26.21) ; UT6.51 47.03,19.76 v2(47.26,19.53) ; UT6.14 v2(50.13,27.72) ; UT6.9 50.4,25.22 v2(50.41,25.23) ; UT6.41 v2(42.48,23.22)
  BOTTOM w0.508: v2(47.26,19.53) 47.26,20.21 CT203.1 ; CT204.1 CT200.1 43.57,24.31 v2(42.48,23.22) ; CT201.1 v2(50.41,25.23) ; CT202.1 50.08,27.77 v2(50.13,27.72)
+2.5VSP_ADJ:
  vias: v1(233.58,19.33)
+2.5VSP_ON: length 1.8
  BOTTOM w0.127: v3(245.74,19.17) 245.58,19.01 245.3,19.01 244.63,18.34 244.63,18.06 PR2501.1
+2.5VSP_PGOOD: length 3
  BOTTOM w0.127: v3(244.06,19.33) 244,19.33 243.52,18.85 PR2503.2
  BOTTOM w0.508: PR2503.2 242.31,18.85 242.02,18.57 PU2501.1
+2.5VSP_VIN: length 2.4
  BOTTOM w0.127: v3(246.03,14.57) 245.41,13.96 243.83,13.96
+3.3V_ANA_PCIE: length 2
  TOP w0.254: RT200.2 22.51,39.9 CT85.1 23.09,40.14 v2(23.57,40.62)
  BOTTOM w0.203: UT1.L16 v2(23.57,40.62)
+3.3V_ANA_USB2: length 1.1
  TOP w0.102: v2(23.57,41.27) 23.47,41.37 CT86.1
  BOTTOM w0.203: v2(23.57,41.27) 23.57,41.25 23.27,40.94 UT1.J16
+3.3V_ELC: length 475.9
  TOP w0.254: UE3.27 156.15,181.42 CE24.1
  TOP w0.508: v2(356.39,45.9) RE4.2 356.36,44.88 RE23.1 ; RE15.1 v2(352.48,42.44) ; RE8.1 v2(354.1,28.47) ; RE13.1 v2(368.43,43.25) ; RE40.1 RE43.1 v2(154.51,183.86) ; v2(155.54,181.44) 155.54,181.44 155.55,181.43 CE24.1 ; RE21.1 349.78,36.73 v2(349.72,36.66) ; RE7.2 RE6.2 RE692.1 356.13,25.98 356.03,25.98 355.98,25.93 355.92,25.93 355.7,25.71 355.7,25.65 v2(355.62,25.58) ; UE2.8 367.16,41.53 CE19.1 v2(366.27,41.55) ; RE25.1 157.99,183.12 v2(157.95,183.16) ; RE12.1 v2(367,28.92) ; RE17.1 v2(349.86,41.58) ; RE14.1 v2(369.72,28.98)
  TOP w0.635: v2(349.72,36.66) 348.96,37.42 348.96,40.88 349.66,41.58 v2(349.86,41.58)
  IN1 w0.635: v2(352.48,42.44) 352.48,41.11 354.95,38.63 354.95,37.26 354.49,36.81 354.49,33.74 352.58,31.83 v2(352.58,30.6) 354.1,29.08 v2(354.1,28.47)
  IN2 w0.508: v2(154.51,183.86) 154.5,183.85 154.5,181.95 155.01,181.44 v2(155.54,181.44) 156.23,181.44 v2(157.95,183.16)
  IN3 w0.635: v2(181.7,97.05) 175.48,97.05 v2(172.18,100.35) ; v2(367,28.92) 366.48,29.44 362.51,29.44 v2(361.54,28.47) ; v2(349.86,41.58) 351.61,41.58 v2(352.48,42.44)
  IN4 w0.635: v2(188.08,1.49) 194.97,1.49 196.97,3.49 218.23,3.49 218.72,2.99 222.88,2.99 223.37,3.49 240.58,3.49 242.39,1.67 291.74,1.67 291.93,1.49 338.8,1.49 v2(340.51,3.2) ; v2(160.93,119.24) 167.18,125.48 167.18,142.23 155.79,153.62 155.79,169.99 154.77,171.01 154.77,172.23 155.32,172.78 155.32,174.33 154.81,174.84 153.69,174.84 153,175.54 153,179.86 154.57,181.43 155.53,181.43 155.54,181.44 v2(155.54,181.44)
  BOTTOM w0.508: RE16.1 350.26,37.36 349.72,36.82 v2(349.72,36.66)
  BOTTOM w0.635: 355.62,26.95 355.62,27.13 354.28,28.47 v2(354.1,28.47) 354.1,27.26 350.62,23.78 345.17,23.78 344.07,22.68 344.07,12.43 343.34,11.71 343.34,9.33 340.51,6.5 v2(340.51,3.2) ; 355.62,26.95 v2(355.62,25.58) ; 355.62,26.95 356.95,26.95 358.04,28.04 358.04,28.76 358.49,29.21 360.8,29.21 v2(361.54,28.47) ; v2(172.18,100.35) 171.61,100.92 171.61,106.88 165.6,112.89 162.46,112.89 161.59,113.76 161.59,118.6 160.96,119.24 v2(160.93,119.24) ; v2(356.39,45.9) 353.72,45.9 352.48,44.65 v2(352.48,42.44) ; v2(181.7,97.05) 181.7,30.51 176.87,25.68 176.87,17.21 183.22,10.86 183.22,6.35 v2(188.08,1.49)
  vias: v2(363.3,41.1) v2(366.27,36.1) v2(366.88,36.1) v3(363.38,40.28)
+3.3V_FLASH: length 32.3
  TOP w0.254: RT67.1 RT66.1 40.46,44.31 v2(40.46,44.32)
  TOP w0.381: v2(40.61,50.67) 40.42,50.47 v1(40.42,50.06) 40.42,49.68 40.58,49.51 RT124.1
  IN3 w0.508: v2(44.2,31.37) 45.03,30.53 47.7,30.53 50.16,32.99 50.16,44.4 49.62,44.94 49.62,47.08 v2(50.32,47.78)
  BOTTOM w0.229: UT4.B1 40.55,44.32 40.47,44.32 v2(40.46,44.32)
  BOTTOM w0.254: RT130.1 50.07,47.98 50.12,47.93 50.16,47.93 v2(50.32,47.78)
  BOTTOM w0.381: RT50.1 35.03,32.1 34.67,32.46 v2(34.42,32.46) ; v2(33.17,33.71) 33.25,33.62 34.27,33.62 34.52,33.37 RT49.1 ; v2(34.92,35.6) 35.14,35.38 RT48.1
  BOTTOM w0.508: v2(44.2,31.37) 44.52,31.69 UT2.8
  vias: v2(39.77,47.38)
+3.3V_LC: length 7.5
  TOP w0.127: v2(27,51.59) v1(27.65,51.59)
  TOP w0.254: CT46.1 v2(26.18,45.16)
  TOP w0.381: RT8.1 RT6.1 RT9.1 v2(31.43,51.52) ; v2(27,51.59) 27,51.42 RT7.1
  IN1 w0.508: v2(33.48,47.19) 33.45,47.19 33.32,47.06 33.06,47.06 32.08,46.09 32.08,45.24
  BOTTOM w0.254: UT1.R6 v2(26.18,45.16)
+3.3V_TBT_SX: length 36.2
  TOP w0.254: RT28.1 v2(28.86,51.61) ; 18.22,50.25 18.22,48.99 18.47,48.74 RT94.1
  TOP w0.381: CT47.1 21.36,45.55 21.62,45.28 v2(21.62,45.17)
  IN1 w0.508: v2(22,51) 21.92,51 21.01,50.09 20.29,49.37 20.29,46.28 20.8,45.77 21.23,45.77 21.62,45.38 v2(21.62,45.17)
  IN2 w0.254: v2(15.71,45.97) 15.63,45.97 14.53,44.87 14.53,43.94 15.39,43.08 18.37,43.08 19.16,43.86 19.16,44.29 20.52,45.65 21.37,45.65 21.62,45.39 v2(21.62,45.17)
  IN3 w0.254: v2(38.43,51.4) 39.02,50.81 39.02,49.56 37.88,48.42 v2(37.49,48.42)
  BOTTOM w0.203: UT1.F8 v2(21.62,45.17)
  BOTTOM w0.254: 25.66,52.36 v2(26.38,52.36) 26.57,52.55 RT729.1 ; 25.66,52.36 RT30.1 ; 25.66,52.36 25.6,52.36 25.35,52.1 25.35,51.12 25.24,51.02 RT27.1 RT26.1 ; v2(37.49,48.42) 37.44,48.38 RT61.2 ; RT86.1 16.68,45.96 16.62,45.89 16.36,45.89 16.28,45.97 v2(15.71,45.97) ; RT29.1 27.81,51.05 27.81,51.67 28.07,51.92 28.58,51.92 28.86,51.64 v2(28.86,51.61) ; RT70.1 v2(38.43,51.4)
  vias: v3(18.63,51.97)
+3.3V_TBT_SX_R: length 9
  TOP w0.127: v2(39.8,48.35) 39.8,48.14 v1(40.16,47.78)
  IN1 w0.254: v2(39.8,48.35) 39.69,48.46 39.64,48.46 38.62,49.48 36.59,49.48 v2(36.5,49.39)
  BOTTOM w0.076: UT4.H2 41.54,47.82 41.16,47.82 41.16,47.82
  BOTTOM w0.102: v2(39.8,48.35) 40.15,48.35 40.68,47.82 41.16,47.82
  BOTTOM w0.254: RT61.1 36.34,49.23 v2(36.5,49.39)
  BOTTOM w0.356: v2(39.8,48.35) 39.65,48.35 39.27,48.73 CT102.1
+3V_PCH: length 524
  TOP w0.254: UH1.AP26 v2(279.41,57.82) ; UH1.BB7 289.13,61.06 289.07,61.01 UH1.AY8 289.07,60.27 289.15,60.19 v2(289.15,60.17) ; UH1.AN21 283.09,57.04 v2(283.1,57.05) ; UH1.AE35 275.73,53.82 275.63,53.93 v2(275.38,53.93) ; v2(274.79,51.66) 274.97,51.84 UH1.AC36 ; UH1.AE36 274.97,53.71 v2(274.79,53.89) ; v2(288.59,60.93) 288.36,60.7 UH1.AW9 ; UH1.V23 v2(280.9,50.06) ; UH1.AN44 UH1.AT44 271.24,58.74 v2(271.39,58.89) ; v2(275.31,51.23) 275.31,51.28 275.39,51.36 275.39,51.63 275.73,51.98 UH1.AC35 ; UH1.AN26 v2(279.41,57.06) ; UH1.AN24 v2(281.66,57.06) ; UH1.BB14 v2(286.7,61.55)
  TOP w0.356: v2(283.43,70.94) 283.46,70.9 283.46,70.81 283.57,70.71 RH27.2 ; RG556.1 RG555.1 182.94,130.99 182.46,130.51 v2(182.27,130.51)
  TOP w0.381: RH25.2 287.25,70.17 v2(287.18,70.24) ; RH21.2 284.24,75.09 284.75,75.09 285.33,74.51 v2(285.33,74.51) ; RH29.2 275.57,67.79 275.72,67.94 v2(276.09,67.94) RH558.2
  TOP w0.508: RH506.2 275.39,70.61 275.41,70.58 RH63.1 RH130.1 v2(275.41,71.85) ; RN122.1 342.74,46.89 343.56,46.06 v2(344.07,46.06) ; RC9.1 56.41,37.89 56.32,37.8 55.41,37.8 54.95,38.25 v2(54.95,38.38) ; v2(271.6,71.24) RH533.2 RH545.2 RH515.2 ; v2(266.37,71.91) CH192.1 267.26,71.24 CH186.1 267.26,71.14 267.26,70.91 266.94,70.6 RH7.2 ; RH594.1 v2(272.77,71.22) ; CH190.1 265.09,53.5 v2(265.33,53.74) ; RH453.2 261.89,69.3 260.95,69.3 260.88,69.23 260.44,69.68 260.44,71.77 v2(262.03,73.37) ; v2(291.43,72.03) 294.34,72.03 296.37,70 296.37,69.67 299.16,66.88 RH571.2 ; RH634.1 RH632.1 265.9,60.92 265.96,60.92 266.03,60.86 v2(266.01,60.86) ; RH631.1 RH633.1 265.75,58.91 v2(266.34,58.91) ; RH460.1 RH461.1 278.6,77.21 278.12,76.73 278.12,76.48 277.14,75.5 RH524.1 v2(276.25,74.75) ; v2(282.63,71.42) 282.63,71.4 282.27,71.04 RH95.1 281.52,70.43 RH1023.1
  IN1 w0.508: v2(54.95,38.38) 54.95,37.06 55.46,36.55 59.74,36.55 60.35,35.94 61.44,35.94 62.33,36.83 64.8,36.83 65.58,37.61 65.83,37.61 72.2,43.98 80.07,43.98 80.87,44.77 83.57,44.77 86.01,47.22 87.93,47.22 96.63,55.91 96.63,57.86 98.09,59.32 99.5,59.32 107.08,66.9 107.08,75.88 115.7,84.5 117.21,84.5 118.4,85.7 118.4,87.64 v2(118.27,87.78) ; v2(344.07,46.06) 343.56,46.06 343.25,46.38 343.25,49.05 342.04,50.25 340.52,50.25 340.07,49.81 335.31,49.81 332.71,52.41 326.04,52.41 v2(325.02,53.43)
  IN2 w0.508: 260.3,101.48 260.3,101.48 255.04,101.48 254.45,102.07 238.1,102.07 237.61,102.57 213.08,102.57 212.1,103.55 196.77,103.55 191.18,109.14 191.18,115.28 186.95,119.51 186.95,124.78 182.88,128.86 182.88,129.9 v2(182.27,130.51)
  IN3 w0.508: v2(118.27,87.78) 118.27,88.93 120.74,91.4 123.47,91.4 124.42,92.35 182.97,92.35 194.63,104.01 211.33,104.01 211.8,104.48 218.48,104.48 219.14,103.82 222.54,103.82 223.43,104.71 236.78,104.71 238.23,103.26 243.05,103.26 244.69,104.9 252.5,104.9 252.99,104.4 255.48,104.4 259.03,100.86 269.59,100.86 270.13,100.32 270.13,95.46 270.76,94.83 270.76,93.18 267.82,90.23 v2(267.82,89.88) v2(267.82,89.29)
  IN4 w0.508: v2(357.84,36.73) 355.88,36.73 354.51,38.1 354.45,38.1 350.3,42.25 v2(350.3,42.25)
  BOTTOM w0.356: RN9.1 350.74,41.81 v2(350.3,42.25) ; RH724.2 357.84,36.17 v2(357.84,36.73) 357.84,37.63 357.03,38.44 RN7.1 354.84,38.94 RH725.2
  BOTTOM w0.508: v2(291.43,72.03) 298.03,72.03 301.15,68.92 301.15,65.57 302.42,64.3 302.42,60.83 305.65,57.59 309.38,57.59 312.34,54.63 323.35,54.63 324.48,53.5 324.95,53.5 v2(325.02,53.43) ; v2(344.07,46.06) 344.07,43.84 344.58,43.33 347.94,43.33 349.02,42.25 v2(350.3,42.25)
  vias: v2(260.85,101.5) v2(260.81,56.72) v2(260.83,56.06) v2(260.83,55.4) v2(261.48,101.5) v2(262.12,101.5) v2(265.07,49.55) v2(265.65,49.55) v2(266.37,73.66) v2(266.37,73.07) v2(266.37,72.49) v2(266.65,89.88) v2(266.65,89.29) v2(266.65,88.71) v2(266.65,88.12) v2(267.23,89.88) v2(267.23,89.29) v2(267.23,88.71) v2(267.23,88.12) v2(268.4,89.88) v2(268.4,89.29) v2(277.2,71.71) v2(277.2,71.08) v2(277.91,57.78) v2(283.11,57.68) v2(286.36,73.02) v2(286.92,73.02) v2(291.43,71.33) v3(269.52,89.3)
+3V_TOUCH: length 273.7
  TOP w0.254: RT89.1 84.35,13.92 v3(85.3,12.97) 85.6,12.67 v2(86.74,12.67) ; v2(310.92,20.09) 310.51,20.5 RE100.1 RE101.1
  IN3 w0.254: v2(86.74,12.67) 87.75,12.67 89.98,14.9 92.9,14.9 94.95,12.85 v2(98.58,12.85) 105.29,12.85 106.04,12.11 109.09,12.11 109.53,12.11 111.93,9.71 115.25,9.71 116.02,10.48 117.76,10.48 118.38,9.87 122.64,9.87 122.91,9.6 124.83,9.6 125.5,8.93 133.31,8.93 133.75,9.36 140.83,9.36 141.28,8.91 155.9,8.91 156.62,9.63 180.67,9.63 181.03,10 186.38,10 189.4,13.02 233.03,13.02 234.44,14.43 237.23,14.43 239.27,16.47 260,16.47 267.84,24.31 270.08,24.31 271.44,25.67 283.6,25.67 285.32,23.95 288.16,23.95 288.44,23.67 288.56,23.67 289.37,22.86 289.37,22.74 289.77,22.34 291.05,22.34 291.74,21.65 292.01,21.65 292.64,21.02 294.68,21.02 295.31,20.39 297.33,20.39 297.71,20.78 297.71,21.58 298.02,21.88 298.74,21.88 299.53,21.1 299.53,20.86 300.12,20.27 301.14,20.27 301.39,20.52 310.49,20.52 v2(310.92,20.09)
  BOTTOM w0.254: C2.1 101.65,17.78 101.18,18.25 101.18,19.2 100.49,19.9 98.54,19.9 97.31,18.67 97.31,14.12 v2(98.58,12.85) ; C2.1 102.46,17.08 101.45,16.06 JTP.6 ; C2.1 102.93,18.25 RE33.1 RE663.1 RE661.1 ; 92.73,18.12 92.73,17.23 92.48,16.98 89.96,16.98 87.21,14.22 87.21,13.91 86.7,13.41 86.7,12.73 86.76,12.67 v2(86.74,12.67)
+3V_WLAN:
  vias: v2(333.58,32.64) v2(333.58,32.05) v2(334.16,32.64) v2(334.16,32.05) v2(334.58,52.27) v2(334.58,51.69) v2(335.17,52.27) v2(335.17,51.69) v2(339.75,48.21) v2(339.85,47.6) v2(339.85,47.01) v2(340.18,48.94) v3(333.02,32.03)
+3VALW: length 1019.3
  TOP w0.203: U17.4 v2(338.76,21.46)
  TOP w0.254: CE62.1 247.8,6.75 v2(247.67,6.88) 247.48,6.88 247.22,7.14 UE10.24
  TOP w0.508: RH707.1 347.18,51.59 v2(345.28,49.68) ; v2(207.16,147.95) 206.72,147.51 PR756.2 ; RE643.1 250.49,11.73 v2(250.91,12.15) 250.91,12.69 249.4,14.2 RE689.1 ; R325.1 209.07,100.43 206.91,102.6 v2(206.91,104.93) ; PR101.1 259.18,10.75 258.68,11.26 v2(258.68,11.96) ; RE700.1 311.31,25.24 RE79.1 310.63,26.02 311.44,26.82 v2(311.44,27.02) ; v2(220.12,112.16) 220.13,112.18 PR210.1 ; v2(181.89,194.02) 180.07,195.83 172.27,195.83 v2(171.67,195.22) 171.16,195.22 171.15,195.22 169.44,195.22 v2(168.05,193.83) ; v2(182.27,187.41) 182.27,187.42 RM41.1 ; v2(286.64,5.46) RE688.1 RE704.1 ; RH706.1 v2(349.84,48.66) ; v2(152.27,166.55) 152.83,165.99 PR4.1 ; RT731.1 v2(35.02,56.47) ; RH2.1 270.83,75.39 v2(270.65,75.21) ; RT88.1 79.88,7.06 80.39,6.56 86.2,6.56 86.87,7.23 v2(86.99,7.23) 87,7.23 93.67,7.23 95.7,9.26 115.75,9.26 116.84,10.36 130.23,10.36 133.49,7.1 180.1,7.1 v3(190.02,17.02) v2(190.02,21.68) ; v2(277.18,10.17) 277.56,10.17 RE201.1 ; v2(299.08,29.18) 298.87,28.96 RE70.1 ; PRS34.1 149.97,147.25 PRS35.1 149.96,147.74 v2(150.33,148.11) ; v2(268.57,70.29) 268.55,70.27 RH6.2 ; v2(353.59,44.14) 353.52,44.22 RE691.1 352.98,43.71 352.62,43.35 351.31,43.35 350.54,44.12 342.06,44.12 341.7,44.48 338.76,44.48 338.76,44.47 ; v2(130.33,148.87) 130.33,149.2 129.82,149.71 PRS14.1 128.59,149.71 PRS15.1 ; RE698.1 314.54,18.74 315.54,18.74 v2(315.95,19.15) 315.22,19.89 315.22,20.52 314.74,21 v2(314.74,21.56) 314.73,21.56 314.63,21.67 312.14,21.67 311.71,22.1 RE695.1 ; v2(319.1,18.91) 319.1,17.94 317.67,16.5 316.17,16.5 315.73,16.06 315.73,14.53 v3(316.04,14.21) 316.3,13.96 316.3,7.94 314.61,6.25 RE64.2 ; CE62.1 249.86,5.89 250.55,6.58 RE642.1 RE530.1
  IN1 w0.508: v2(353.59,44.14) 352.55,44.14 351.66,43.25 351.66,40.93 354.25,38.34 354.25,37.55 353.8,37.1 353.8,34.03 351.79,32.03 351.79,30.4 352.88,29.31 v2(352.88,27.76) ; v2(157.8,110.69) 157.57,110.93 v2(157.57,113.89) 158.46,114.78 v2(158.46,119.53) ; v2(200.89,125.46) 198.06,125.46 193.89,129.63 v2(193.89,136.94) ; v2(286.64,5.46) 286.07,6.03 284.26,6.03 283.91,6.37 280.98,6.37 v2(277.18,10.17) ; v2(150.33,148.11) 149.96,148.47 149.96,151.74 151.28,153.06 151.28,154.65 150,155.92 v2(150,157.24) 149.47,157.78 149.47,161.36 150.66,162.56 150.66,165.9 151.31,166.55 v2(152.27,166.55) ; v2(130.33,148.87) 129.51,148.05 129.51,147.2 129.77,146.94 129.77,142.77 126.39,139.39 126.39,133 125.38,131.99 125.38,125.25 124.1,123.98 118.58,123.98 115.87,121.27 114.1,121.27 v2(112.42,119.59) ; v2(250.91,12.15) 250.95,12.19 258.44,12.19 v2(258.68,11.96)
  IN2 w0.508: 161.19,168.55 160.74,169 160.74,172.45 166.01,177.71 166.01,181.24 164.53,182.71 164.53,186.48 164.24,186.78 164.24,191.48 166.59,193.83 v2(168.05,193.83) ; v2(130.33,148.87) 141.44,148.87 142.5,147.81 146.05,147.81 146.43,147.43 149.66,147.43 v2(150.33,148.11) ; 299.58,51.59 300.66,51.59 301.43,50.82 301.43,50.15 302.11,49.46 v2(302.11,48.66) ; v2(193.89,136.94) 197.82,136.94 206.81,145.93 206.81,147.6 v2(207.16,147.95) ; v2(268.57,70.29) 270.91,72.64 270.91,74.94 v2(270.65,75.21)
  IN2 w2.032: 227.69,107.36 238.85,107.36 239.3,106.91 265.36,106.91 265.71,106.56 268.89,106.56 279.37,96.09 279.37,92.29
  IN3 w0.508: v2(35.02,56.47) 36.92,56.47 37.43,55.97 37.43,54.92 42.87,49.48 43.76,49.48 46.83,52.55 48.28,52.55 51.33,49.5 51.33,47.57 52.04,46.86 52.04,39.77 v2(53.43,38.38) ; v2(315.95,19.15) 316.8,18.31 318.53,18.31 318.97,18.76 318.97,18.78 v2(319.1,18.91) ; v2(193.89,136.94) 193.88,136.93 193,136.93 192.3,136.23 192.3,128.9 191.72,128.32 191.72,122.73 183.16,114.17 182.33,114.17 182.05,113.89 v2(157.57,113.89) ; v2(182.27,187.41) 182.85,186.84 v2(186.52,186.84) ; v2(270.65,75.21) 271.6,75.21 271.98,75.59 271.98,76.57 272.47,77.06 274.71,77.06 277.38,79.73 280.14,79.73 281.77,81.37 284.82,81.37 v2(285.52,80.67) ; v2(206.91,104.93) 204.05,104.93 201.74,107.24 199.58,107.24 v2(199.23,107.59) 199.16,107.66 199.16,115.46 200.89,117.19 v2(200.89,125.46)
  IN3 w2.032: 149.94,165.22 114.47,165.22 109.06,159.81 106.45,152.98 106.45,144.96 112.21,139.2 112.21,136.09 106.39,130.27 106.39,121.13 106.49,121.03 ; 181.39,154.96 175.29,154.96 ; 167.99,153.19 166.11,153.19 161.17,158.13 161.01,158.13 157.64,161.5 157.64,165.95 ; 363.7,18.39 367.27,18.39 367.83,17.83 373.15,17.83 374.14,18.82 374.14,23.42 374.78,24.05
  IN4 w0.508: v2(258.68,11.96) 258.7,11.96 261.71,8.94 261.71,8.7 262.65,7.76 263.12,7.76 264.38,6.5 266.34,6.5 270.01,10.17 v2(277.18,10.17) ; v2(311.44,27.02) 313.28,27.02 314.04,26.26 314.04,22.51 314.74,21.81 v2(314.74,21.56) ; v2(172.49,127.98) 172.4,127.98 171.65,127.22 171.65,123.95 172.16,123.44 172.16,115.91 167.19,110.94 165.12,110.94 164.49,110.31 159.25,110.31 158.8,109.87 158.31,109.87 157.8,110.37 v2(157.8,110.69)
  IN4 w2.032: 185.73,153.66 186.17,153.21 186.17,147.18 187.35,146 187.35,144.17 191.42,140.1 191.42,128.61 194.21,125.82 194.21,118.64
  BOTTOM w0.254: RT732.1 v2(44.73,39.65) ; PUF01.15 157.53,111.36 v2(157.8,110.69) 157.8,110.63 158.35,110.08 158.84,110.08 159.21,110.45 PCF15.1 ; PRF09.2 158.04,114.36 v2(157.57,113.89)
  BOTTOM w0.356: RE300.2 297.18,40.45 297.84,41.11 v2(297.97,41.11)
  BOTTOM w0.406: JDGFF1.C7 174.27,128.42 173.82,127.98 v2(172.49,127.98)
  BOTTOM w0.508: v2(150.33,148.11) 150.33,148.1 151.47,148.1 152.31,147.27 152.31,146.42 152.68,146.05 153.64,146.05 154.7,144.98 154.7,141.93 153.38,140.61 153.38,122.37 156.22,119.53 v2(158.46,119.53) ; RE652.1 302.38,48.93 v2(302.11,48.66) ; v2(130.33,148.87) 130.99,148.87 PR9.1 ; v2(86.99,7.23) 86.84,7.38 86.84,10.45 86.12,11.17 86.12,13.23 86.12,13.65 86.7,14.23 86.7,14.43 88.39,16.13 RT111.1 ; v2(280.23,88.33) 280.69,88.78 RH1026.1 ; v2(220.12,112.16) 219.04,111.08 215.1,111.08 214.85,111.34 210.4,111.34 207.93,108.86 202.59,108.86 200.96,107.24 199.58,107.24 v2(199.23,107.59) ; v2(171.67,195.22) 171.67,194.6 RM5.1 ; UM3.5 169.16,194.54 CM23.1 168.05,194.28 v2(168.05,193.83) ; v2(152.27,166.55) 150.85,166.55 150.46,166.16 PR40.1 ; v2(240.25,21.87) 240.25,21.46 241.93,19.77 PR2503.1 ; RT729.2 29.25,53.95 31.78,56.47 v2(35.02,56.47) ; PR22.1 v2(150,157.24) ; v2(182.27,187.41) 181.89,187.8 v2(181.89,194.02) ; v2(247.67,6.88) 247.67,10.56 248.52,11.41 250.17,11.41 v2(250.91,12.15) ; v2(286.64,5.46) 286.89,5.46 289.08,7.64 289.08,10.94 290.41,12.27 290.41,13.14 292.54,15.28 294.85,15.28 295.63,16.05 295.63,17.3 R307.1 294.17,18.64 293.59,18.06 292.03,18.06 290.66,19.42 290.66,20.38 290.34,20.7 288.94,20.7 287.46,22.19 287.46,22.92 285.82,24.56 285.06,24.56 281.87,27.75 v2(281.87,29.51)
  vias: v2(54.07,38.38) v2(59.61,24.46) v2(60.06,25.17) v2(60.12,24.23) v2(60.42,24.72) v2(111.78,119.56) v2(111.78,118.95) v2(112.44,119) v2(161.76,166.58) v2(162.27,166.9) v2(162.27,166.33) v2(162.82,166.58) v2(184.78,155.45) v2(184.78,154.86) v2(184.78,154.28) v2(184.8,153.64) v2(193.89,114.89) v2(194.34,115.34) v2(194.47,114.7) v2(194.91,115.15) v2(278.35,88.1) v2(278.35,89.05) v2(278.6,87.53) v2(278.73,88.61) v2(278.86,89.37) v2(278.98,88.03) v2(279.04,87.15) v2(279.3,88.92) v2(279.42,87.65) v2(279.55,88.35) v2(280,87.72) v2(286.09,80.16) v2(293.59,37.23) v2(294.17,37.23) v2(294.75,37.23) v2(337.46,48.79) v2(337.46,48.21) v2(337.46,47.62) v2(337.46,47.04) v2(337.57,44.75) v2(337.57,44.12) v2(337.57,43.48) v2(337.57,42.85) v2(338.1,48.79) v2(338.1,48.21) v2(338.1,47.62) v2(338.1,47.04) v2(338.2,44.75) v2(338.2,44.12) v2(338.2,43.48) v2(338.2,42.85) v2(338.8,27.07) v2(338.8,26.49) v2(338.8,25.91) v2(338.8,25.32) v2(338.8,24.74) v2(339.39,27.07) v2(339.39,26.49) v2(339.39,25.91) v2(339.39,25.32) v2(339.39,24.74) v2(352.88,27.18) v2(360.88,17.6) v2(361.29,18.16) v2(361.49,17.6) v2(361.9,18.16) v2(376.45,24.92) v2(376.45,24.33) v2(377.04,24.92) v2(377.04,24.33) v3(363,18.06)
+3VALW_EC: length 327.2
  TOP w0.254: CE32.2 293.14,9.24 UE5.33 ; CE30.1 308.69,23.98 308.43,23.98 308.33,23.88 UE5.96 ; PR14.2 78.69,9.26 78.67,9.24 78.67,7.3 79.92,6.05 93.2,6.05 95.91,8.76 116.46,8.76 119.95,5.27 v2(125.7,5.27) ; v2(289.58,15.9) 289.58,15.73 289.9,15.41 290.56,15.41 290.62,15.48 UE5.22
  TOP w0.457: v2(288.45,22.76) 288.4,22.81 CE29.1
  TOP w0.508: RE24.2 294.18,29.44 293.72,29.89 v1(291.06,29.89) 290.6,29.89 289.37,28.67 v2(289.37,28.57) ; v2(312.66,7.87) LE1.1 313.4,9.24 313.5,9.14 RE78.2 314.6,9.55 RE705.1 315.66,10.02 315.66,13.51 315.09,14.09 315.09,15.58 314.34,16.33 313.31,16.33 ; RE79.2 309.57,25.58 CE30.1 ; RE79.2 308.41,25.92 v2(307.78,25.29) ; RE79.2 309.24,26.68 PR24.2 ; v2(289.58,15.9) 289.53,15.9 289.13,15.49 CE31.2 ; v2(291.72,9.89) 291.77,9.84 291.77,8.02 CE32.2
  IN1 w0.508: v2(285.57,25.19) 287.93,27.56 288.57,27.56 289.37,28.36 v2(289.37,28.57) ; v2(291.72,9.89) 292.28,9.89 292.83,10.44 292.83,11.67 292.53,11.97 292.53,12.96 v2(289.58,15.9) 288.74,16.74 288.74,19.68 289.78,20.72 v2(289.78,21.32)
  IN2 w0.508: v2(291.72,9.89) 291.93,9.69 311.1,9.69 312.66,8.13 v2(312.66,7.87) ; v2(307.78,25.29) 307.33,24.84 295.24,24.84 293.42,26.66 293.42,27.2 292.05,28.57 v2(289.37,28.57)
  IN3 w0.254: v2(291.72,9.89) 290.31,8.48 285.3,8.48 283.61,6.79 278.26,6.79 275.07,3.6 247.46,3.6 245.84,5.23 243.81,5.23 242.41,6.63 197.51,6.63 194.03,3.14 189.72,3.14 189.05,3.82 186.64,3.82 186.63,3.8 173.73,3.8 173.45,4.09 166.92,4.09 165.75,5.27 v2(125.7,5.27)
  BOTTOM w0.457: v2(288.45,22.76) 288.81,22.76 289.78,21.79 v2(289.78,21.32)
  BOTTOM w0.508: v2(285.57,25.19) 286.43,25.19 288.45,23.17 v2(288.45,22.76)
+3VALW_LAN: length 78.4
  TOP w0.254: v2(192.05,164.23) 192.31,164.23 192.56,164.49 CL20.1 192.56,165.52 192.91,165.87 193.59,165.87 194.15,165.31 UL10.3
  TOP w0.508: v2(185.7,178.27) 185.7,178.01 185.76,177.95 RL52.1 ; RL1.2 173.45,173.63 v2(173.26,173.82)
  IN1 w0.508: v2(192.05,164.23) 193.32,162.96 195.93,162.96 196.56,163.6 210.53,163.6 212.21,165.28 v2(212.21,167.51)
  IN3 w0.508: v2(185.7,178.27) 184.15,176.72 182.4,176.72 182.07,176.39 178.9,176.39 175.83,173.31 173.77,173.31 v2(173.26,173.82)
  IN3 w1.016: 159.86,163.6 162.06,163.6 162.42,163.95 163.26,163.95 164.88,165.57 165.7,165.57
  IN4 w1.016: 173.26,172.49 175.61,172.49 176.69,173.57 176.69,175.22 177.66,176.19 177.66,179.62 178.91,180.87 ; 185.64,179.35 184.05,180.93 181.83,180.93
  BOTTOM w0.254: v2(192.05,164.23) 192.51,163.78 RL20.1 193.82,164.53 RL57.2
  BOTTOM w0.508: RL71.2 v2(212.21,167.51) ; RL66.2 191.57,177.27 v2(190.77,176.48) ; RL54.1 185.76,177.95 185.7,178.01 v2(185.7,178.27)
  vias: v2(159.28,162.83) v2(159.28,162.24) v2(166.72,166.71) v2(166.72,166.13) v2(167.3,166.71) v2(167.3,166.13) v2(167.89,166) v2(169.47,166.95) v2(169.83,172.36) v2(169.92,166.58) v2(170.08,167.16) v2(170.41,172.36) v2(171,172.36) v2(173.4,162.96) v2(177.54,159.77) v2(177.97,159.35) v2(186.22,178.65) v2(186.72,178.9) v2(190.19,176.48) v3(169.38,165.95)

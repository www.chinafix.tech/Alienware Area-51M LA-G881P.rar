# Allegro board Alienware Area-51M LA-G881P.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
LSM6DSLUSTR_LGA14_2P5X3
  rect 0.483x0.254 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 8(2.325,-1.5) 9(2.325,-1) 10(2.325,-0.5) 11(2.325,0)
  rect 0.254x0.483 smd: 5(0.662,-1.662) 6(1.163,-1.662) 7(1.662,-1.662) 12(1.662,0.163) 13(1.163,0.163) 14(0.662,0.163)
LTC015EUBFS8TL_UMT3F
  oval 0.787x0.889 smd: 1(0,0) 2(-0.65,-1.6) 3(0.65,-1.6)
MAG_MMD05CZR47M_4P
  custom 0.54x0.54 smd: 1(0,0) 4(4.35,0)
  rect 0.762x0.508 smd: 2(0.699,0) 3(3.652,0)
MAG_MMD-05CZ-3R3M-M7L_2P
  rect 1.905x2.794 smd: 1(0,0) 2(4.1,0)
MAG_MMD-10CZ-2R2M-X2L_2P
  rect 4.089x4.089 smd: 1(0,0) 2(9.5,0)
MAG_MMD-10CZN1R0M-R1L_2P
  rect 3.81x3.988 smd: 1(0,0) 2(9.2,0)
MAG_MND-04ABIR60M-XGL_2P
  rect 1.448x3.708 smd: 1(0,0) 2(2.845,0)
MAGIC_SRPG1005-1R0M-AD_2P
  rect 3.505x3.988 smd: 1(0,0) 2(9.5,0)
MESS138W-G_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
MMBT3904WH_SOT323-3
  oval 0.61x0.787 smd: 1(0,0) 2(-0.65,-1.6) 3(0.65,-1.6)
MURAT_BLM15AG121SN1D_L0402_2P
  rect 0.457x0.711 smd: 1(0,0) 2(0.85,0)
MURAT_BLM15HG601SN1D_2P
  rect 0.508x0.762 smd: 1(0,0) 2(0.75,0)
MURAT_DLM0NSN900HY2D_4P
  rect 0.305x0.305 smd: 1(0,0) 2(0.6,0) 3(0.6,-0.5) 4(0,-0.5)
MURAT_LQM18PN1R0MFHD_2P
  rect 0.61x0.711 smd: 1(0,0) 2(1.3,0)
NL17SZ08DFT2G_SC70-5
  oval 0.406x0.508 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0,1.9)
NTR4502PT1G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
PESD5V0H1BSF_SOD962-2-2
  rect 0.279x0.381 smd: 1(0,0) 2(0.4,0)
PESD5V0U2BT_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
PESD24VS2UT_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
PI6CEQ20200LIEX_TSSOP20
  oval 0.381x1.626 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(2.6,0) 6(3.25,0) 7(3.9,0) 8(4.55,0) 9(5.2,0) 10(5.85,0) 11(5.85,5.8) 12(5.2,5.8) 13(4.55,5.8) 14(3.9,5.8) 15(3.25,5.8) 16(2.6,5.8) 17(1.95,5.8) 18(1.3,5.8) 19(0.65,5.8) 20(0,5.8)
PK5N2EA_PDFN5X6P8-5
  oval 0.559x0.864 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0)
  custom 1.1x1.1 smd: 5(1.905,2.77)
PS8713BTQFN24GTR2-A_TQFN24_4X4
  oval 0.889x0.254 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 5(0,-2) 6(0,-2.5) 13(4.1,-2.5) 14(4.1,-2) 15(4.1,-1.5) 16(4.1,-1) 17(4.1,-0.5) 18(4.1,0)
  oval 0.254x0.889 smd: 7(0.8,-3.3) 8(1.3,-3.3) 9(1.8,-3.3) 10(2.3,-3.3) 11(2.8,-3.3) 12(3.3,-3.3) 19(3.3,0.8) 20(2.8,0.8) 21(2.3,0.8) 22(1.8,0.8) 23(1.3,0.8) 24(0.8,0.8)
  rect 2.692x2.692 smd: 25(2.05,-1.25)
Q_N_DFN56-8-5
  oval 0.61x1.27 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0)
  custom 1.105x1.105 smd: 5(1.905,3.715)
R0201_0OHM
  rect 0.381x0.356 smd: 1(0,0) 2(0.584,0)
R0402_0OHM
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
R0603_0OHM
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
R_0201
  rect 0.381x0.356 smd: 1(0,0) 2(0.584,0)
R_0201-NPM
  rect 0.381x0.356 smd: 1(0,0) 2(0.584,0)
R_0402
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
R_0402-NPM
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
R_0603
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
R_0805
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
R_1206
  rect 1.016x1.651 smd: 1(0,0) 2(2.667,0)
R_2512_4P
  custom 0.826x0.826 smd: 1(0,0) 4(0,-8.687)
  rect 0.508x3.2 smd: 2(0,-2.108) 3(0,-6.579)
RB520SM-30T2R_EMD2-2
  rect 0.61x0.787 smd: 1(0,0) 2(1.7,0)
RB751S40T1G_SOD523-2
  rect 0.61x0.787 smd: 1(0,0) 2(1.7,0)
RB751V-40_SOD323-2
  rect 0.787x0.889 smd: 1(0,0) 2(2.14,0)
RHU002N06_SOT323-3
  oval 0.813x0.914 smd: 1(0,0) 2(0.65,1.6) 3(-0.65,1.6)
RP_0804_8P4R
  oval 0.66x0.254 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 5(1.15,-1.5) 6(1.15,-1) 7(1.15,-0.5) 8(1.15,0)
RT8207PGQW_WQFN20_3X3
  oval 0.203x0.889 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 11(1.6,3.1) 12(1.2,3.1) 13(0.8,3.1) 14(0.4,3.1) 15(0,3.1)
  oval 0.889x0.203 smd: 6(2.35,0.75) 7(2.35,1.15) 8(2.35,1.55) 9(2.35,1.95) 10(2.35,2.35) 16(-0.75,2.35) 17(-0.75,1.95) 18(-0.75,1.55) 19(-0.75,1.15) 20(-0.75,0.75)
  rect 1.702x1.702 smd: 21(0.8,1.55)
RT9059GSP_SO8
  oval 0.635x1.854 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,5.157) 6(2.54,5.157) 7(1.27,5.157) 8(0,5.157)
  rect 2.311x2.311 smd: 9(1.905,2.579)
RT9297GQW_WDFN10_3X3
  oval 0.254x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2,3.1) 7(1.5,3.1) 8(1,3.1) 9(0.5,3.1) 10(0,3.1)
  rect 2.464x1.626 smd: 11(1,1.55)
RTL8125-CG_QFN88_10X10
  oval 0.94x0.254 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 9(0,-3.2) 10(0,-3.6) 11(0,-4) 12(0,-4.4) 13(0,-4.8) 14(0,-5.2) 15(0,-5.6) 16(0,-6) 17(0,-6.4) 18(0,-6.8) 19(0,-7.2) 20(0,-7.6) 21(0,-8) 22(0,-8.4) 45(10.1,-8.4) 46(10.1,-8) 47(10.1,-7.6) 48(10.1,-7.2) 49(10.1,-6.8) 50(10.1,-6.4) 51(10.1,-6) 52(10.1,-5.6) 53(10.1,-5.2) 54(10.1,-4.8) 55(10.1,-4.4) 56(10.1,-4) 57(10.1,-3.6) 58(10.1,-3.2) 59(10.1,-2.8) 60(10.1,-2.4) 61(10.1,-2) 62(10.1,-1.6) 63(10.1,-1.2) 64(10.1,-0.8) 65(10.1,-0.4) 66(10.1,0)
  oval 0.254x0.94 smd: 23(0.85,-9.25) 24(1.25,-9.25) 25(1.65,-9.25) 26(2.05,-9.25) 27(2.45,-9.25) 28(2.85,-9.25) 29(3.25,-9.25) 30(3.65,-9.25) 31(4.05,-9.25) 32(4.45,-9.25) 33(4.85,-9.25) 34(5.25,-9.25) 35(5.65,-9.25) 36(6.05,-9.25) 37(6.45,-9.25) 38(6.85,-9.25) 39(7.25,-9.25) 40(7.65,-9.25) 41(8.05,-9.25) 42(8.45,-9.25) 43(8.85,-9.25) 44(9.25,-9.25) 67(9.25,0.85) 68(8.85,0.85) 69(8.45,0.85) 70(8.05,0.85) 71(7.65,0.85) 72(7.25,0.85) 73(6.85,0.85) 74(6.45,0.85) 75(6.05,0.85) 76(5.65,0.85) 77(5.25,0.85) 78(4.85,0.85) 79(4.45,0.85) 80(4.05,0.85) 81(3.65,0.85) 82(3.25,0.85) 83(2.85,0.85) 84(2.45,0.85) 85(2.05,0.85) 86(1.65,0.85) 87(1.25,0.85) 88(0.85,0.85)
  rect 7.798x7.493 smd: 89(5.05,-4.2)
SANTA_130456-931_13P-T
  round 1.295 hole 0.889: 1(0,0) 2(1.02,-1.1) 3(2.04,0) 4(3.06,-1.1) 5(4.08,0) 6(5.1,-1.1) 7(6.12,0) 8(7.14,-1.1)
  round 1.397 hole 0.991: 9(-3.39,1.4) 10(-2.245,-0.1) 11(8.24,1.4) 12(9.385,-0.1) 13(10.53,1.4)
  oval 1.295x2.997 hole 0.711x2.388: 14(13.32,-11.6) 15(-6.18,-11.6)
SDMK0340L-7-F_SOD323-2
  rect 1.346x0.66 smd: 1(0,0) 2(2.4,0)
SHORTPADS
  custom 0.19x0.19 smd: 1(-0.483,0) 2(0.483,0)
SI2301CDS-T1-GE3_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
SI3457CDV-T1-GE3_TSOP6
  oval 0.508x1.422 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.44) 5(0.95,2.44) 6(0,2.44)
SIC632CDT1GE3_POWERPAK31_5X5
  oval 0.889x0.305 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 5(0,-2) 6(0,-2.5) 7(0,-3) 8(0,-3.5) 11(5,-3.5) 12(5,-3) 13(5,-2.5) 14(5,-2) 15(5,-1.5) 16(5,-1) 17(5,-0.5) 18(5,0)
  custom 0.337x0.337 smd: 9(1.25,-3.185)
  custom 0.549x0.549 smd: 10(3.327,-2.275)
  oval 0.305x0.889 smd: 19(4.25,0.75) 20(3.75,0.75) 21(3.25,0.75) 22(2.75,0.75) 23(2.25,0.75) 24(1.75,0.75) 25(1.25,0.75) 26(0.75,0.75)
  rect 0.406x0.559 smd: 27(2.6,-0.275)
  rect 1.118x1.422 smd: 28(1.315,-0.71)
SMF4L22A_SOD123FL2
  rect 1.295x1.397 smd: 1(0,0) 2(2.9,0)
SS5P10-M3-86A_TO277A3
  rect 4.801x4.724 smd: 1(0,0)
  rect 1.397x1.27 smd: 2(-1.04,-3.805) 3(1.04,-3.805)
SSM3K7002FU_SC70-3
  oval 0.508x0.991 smd: 1(0,0) 2(0.65,1.9) 3(-0.65,1.9)
STM32F070CBT6TR_LQFP48_7X7
  oval 1.753x0.254 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 5(0,-2) 6(0,-2.5) 7(0,-3) 8(0,-3.5) 9(0,-4) 10(0,-4.5) 11(0,-5) 12(0,-5.5) 25(8.654,-5.5) 26(8.654,-5) 27(8.654,-4.5) 28(8.654,-4) 29(8.654,-3.5) 30(8.654,-3) 31(8.654,-2.5) 32(8.654,-2) 33(8.654,-1.5) 34(8.654,-1) 35(8.654,-0.5) 36(8.654,0)
  oval 0.254x1.753 smd: 13(1.577,-7.077) 14(2.077,-7.077) 15(2.577,-7.077) 16(3.077,-7.077) 17(3.577,-7.077) 18(4.077,-7.077) 19(4.577,-7.077) 20(5.077,-7.077) 21(5.577,-7.077) 22(6.077,-7.077) 23(6.577,-7.077) 24(7.077,-7.077) 37(7.077,1.577) 38(6.577,1.577) 39(6.077,1.577) 40(5.577,1.577) 41(5.077,1.577) 42(4.577,1.577) 43(4.077,1.577) 44(3.577,1.577) 45(3.077,1.577) 46(2.577,1.577) 47(2.077,1.577) 48(1.577,1.577)
SW_EVQPLHA15_4P
  rect 1.016x0.61 smd: 1(-2.2,1.85) 2(2.2,1.85) 3(-2.2,-1.85) 4(2.2,-1.85)
  rect 1.016x0.457 smd: 5(0,2.525) 6(0,-2.525)
SX34_SMA2
  rect 2.057x2.057 smd: 1(0,0) 2(3.73,0)
SY6288C20AAC_SOT23-5
  oval 0.559x0.787 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.4) 5(0,2.4)
SY6288D20AAC_SOT23-5
  oval 0.559x0.787 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.4) 5(0,2.4)
SY8003EDFC_DFN8_2X2
  oval 0.254x0.787 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(1.5,2.2) 6(1,2.2) 7(0.5,2.2) 8(0,2.2)
  rect 1.549x0.813 smd: 9(0.75,1.1)
SY8286RAC_QFN20_3X3
  oval 0.889x0.254 smd: 1(0,0) 2(0,-0.45) 3(0,-0.9) 4(0,-1.35) 5(0,-1.8) 11(3.1,-1.8) 12(3.1,-1.35) 13(3.1,-0.9) 14(3.1,-0.45) 15(3.1,0)
  oval 0.254x0.889 smd: 6(0.65,-2.45) 7(1.1,-2.45) 8(1.55,-2.45) 9(2,-2.45) 10(2.45,-2.45) 16(2.45,0.65) 17(2,0.65) 18(1.55,0.65) 19(1.1,0.65) 20(0.65,0.65)
  rect 0.991x0.991 smd: 21(1.55,-0.9)
TAI-T_AHP252010HF-1R0M_2P
  rect 0.94x2.388 smd: 1(0,0) 2(1.95,0)
TAIWI_USB050-10B7CRL-TWD_10P-T
  round 1.168 hole 0.914: 1(0,0) 2(-2.5,0) 3(-4.5,0) 4(-7,0) 5(-8,-1.5) 6(-5.75,-1.5) 7(-3.5,-1.5) 8(-1.25,-1.5) 9(1,-1.5)
  round 1.016 hole 0.762: 10(-8.2,-2.77)
  oval 1.372x3.15 hole 0.61x2.388: 11(2.9,-1.59) 12(-9.9,-1.59)
  oval 1.372x2.667 hole 0.61x1.905: 13(4.4,-10.35) 14(-11.4,-10.35)
TC7SH08FU_SSOP5
  oval 0.406x0.787 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0,1.9)
TC7SZ14FU_SSOP5
  oval 0.381x1.448 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.675) 5(0,1.675)
TDK_MLF1608A2R2KT_2P
  rect 0.559x1.041 smd: 1(0,0) 2(1.3,0)
TE_2260531-1_46P
  oval 0.508x1.803 smd: 1(0,0) 2(0.8,0) 45(18.6,0) 46(19.4,0)
  oval 0.203x1.803 smd: 3(1.55,0) 4(1.95,0) 5(2.35,0) 6(2.75,0) 7(3.15,0) 8(3.55,0) 9(3.95,0) 10(4.35,0) 11(4.75,0) 12(5.15,0) 13(5.55,0) 14(5.95,0) 15(6.35,0) 16(6.75,0) 17(7.15,0) 18(7.55,0) 19(7.95,0) 20(8.35,0) 21(8.75,0) 22(9.15,0) 23(9.55,0) 24(9.95,0) 25(10.35,0) 26(10.75,0) 27(11.15,0) 28(11.55,0) 29(11.95,0) 30(12.35,0) 31(12.75,0) 32(13.15,0) 33(13.55,0) 34(13.95,0) 35(14.35,0) 36(14.75,0) 37(15.15,0) 38(15.55,0) 39(15.95,0) 40(16.35,0) 41(16.75,0) 42(17.15,0) 43(17.55,0) 44(17.95,0)
  custom 0.688x0.688 hole 0.889x2.007: 47(-6.7,0) 49(25.8,0)
  oval 1.651x2.769 hole 0.889x2.007: 48(-6.7,-4.6) 50(25.8,-4.6)
TLC59116FIRHBR_VQFN32_5X5
  oval 0.254x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 17(3.5,5.1) 18(3,5.1) 19(2.5,5.1) 20(2,5.1) 21(1.5,5.1) 22(1,5.1) 23(0.5,5.1) 24(0,5.1)
  oval 0.889x0.254 smd: 9(4.3,0.8) 10(4.3,1.3) 11(4.3,1.8) 12(4.3,2.3) 13(4.3,2.8) 14(4.3,3.3) 15(4.3,3.8) 16(4.3,4.3) 25(-0.8,4.3) 26(-0.8,3.8) 27(-0.8,3.3) 28(-0.8,2.8) 29(-0.8,2.3) 30(-0.8,1.8) 31(-0.8,1.3) 32(-0.8,0.8)
  rect 3.454x3.454 smd: 33(1.75,2.55)
TP0610K-T1-E3_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
TPC12
  round 0.305 smd: 1(0,0)
TPS2546RTER_QFN16_3X3
  oval 0.254x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 9(1.5,3.1) 10(1,3.1) 11(0.5,3.1) 12(0,3.1)
  oval 0.889x0.254 smd: 5(2.3,0.8) 6(2.3,1.3) 7(2.3,1.8) 8(2.3,2.3) 13(-0.8,2.3) 14(-0.8,1.8) 15(-0.8,1.3) 16(-0.8,0.8)
  rect 1.651x1.651 smd: 17(0.75,1.55)
TPS22966DPUR_SON14_2X3
  oval 0.203x0.762 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.4,2.05) 9(2,2.05) 10(1.6,2.05) 11(1.2,2.05) 12(0.8,2.05) 13(0.4,2.05) 14(0,2.05)
  rect 2.489x0.889 smd: 15(1.2,1.025)
TPS51212DSCR_SON10_3X3
  oval 0.279x0.838 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2,2.95) 7(1.5,2.95) 8(1,2.95) 9(0.5,2.95) 10(0,2.95)
  custom 0.412x0.412 smd: 11(1,1.475)
TPS51225CRUKR_QFN20_3X3
  oval 0.203x0.889 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 11(1.6,3.1) 12(1.2,3.1) 13(0.8,3.1) 14(0.4,3.1) 15(0,3.1)
  oval 0.889x0.203 smd: 6(2.35,0.75) 7(2.35,1.15) 8(2.35,1.55) 9(2.35,1.95) 10(2.35,2.35) 16(-0.75,2.35) 17(-0.75,1.95) 18(-0.75,1.55) 19(-0.75,1.15) 20(-0.75,0.75)
  rect 1.702x1.702 smd: 21(0.8,1.55)
TPS65982_BGA_96P
  round 0.254 smd: A1(0,0) A2(0.5,0) A3(1,0) A4(1.5,0) A5(2.001,0) A6(2.501,0) A7(3.001,0) A8(3.501,0) A9(4.001,0) A10(4.501,0) A11(5.001,0) B1(0,-0.5) B2(0.5,-0.5) B3(1,-0.5) B4(1.5,-0.5) B5(2.001,-0.5) B6(2.501,-0.5) B7(3.001,-0.5) B8(3.501,-0.5) B9(4.001,-0.5) B10(4.501,-0.5) B11(5.001,-0.5) C1(0,-1) C2(0.5,-1) C10(4.501,-1) C11(5.001,-1) D1(0,-1.5) D2(0.5,-1.5) D5(2.001,-1.5) D6(2.501,-1.5) D7(3.001,-1.5) D8(3.501,-1.5) D10(4.501,-1.5) D11(5.001,-1.5) E1(0,-2.001) E2(0.5,-2.001) E4(1.5,-2.001) E5(2.001,-2.001) E6(2.501,-2.001) E7(3.001,-2.001) E8(3.501,-2.001) E10(4.501,-2.001) E11(5.001,-2.001) F1(0,-2.501) F2(0.5,-2.501) F4(1.5,-2.501) F5(2.001,-2.501) F6(2.501,-2.501) F7(3.001,-2.501) F8(3.501,-2.501) F10(4.501,-2.501) F11(5.001,-2.501) G1(0,-3.001) G2(0.5,-3.001) G4(1.5,-3.001) G5(2.001,-3.001) G6(2.501,-3.001) G7(3.001,-3.001) G8(3.501,-3.001) G10(4.501,-3.001) G11(5.001,-3.001) H1(0,-3.501) H2(0.5,-3.501) H4(1.5,-3.501) H5(2.001,-3.501) H6(2.501,-3.501) H7(3.001,-3.501) H8(3.501,-3.501) H10(4.501,-3.501) H11(5.001,-3.501) J1(0,-4.001) J2(0.5,-4.001) J10(4.501,-4.001) J11(5.001,-4.001) K1(0,-4.501) K2(0.5,-4.501) K3(1,-4.501) K4(1.5,-4.501) K5(2.001,-4.501) K6(2.501,-4.501) K7(3.001,-4.501) K8(3.501,-4.501) K9(4.001,-4.501) K10(4.501,-4.501) K11(5.001,-4.501) L1(0,-5.001) L2(0.5,-5.001) L3(1,-5.001) L4(1.5,-5.001) L5(2.001,-5.001) L6(2.501,-5.001) L7(3.001,-5.001) L8(3.501,-5.001) L9(4.001,-5.001) L10(4.501,-5.001) L11(5.001,-5.001)
TVNST52302AB0_SOT523-3
  oval 0.508x0.559 smd: 1(0,0) 2(-0.5,-1.4) 3(0.5,-1.4)
TVWDF1004AD0_DFN9
  oval 0.203x0.686 smd: 1(0,0) 2(0.5,0) 4(1.5,0) 5(2,0) 6(2,0.875) 7(1.5,0.875) 8(0.5,0.875) 9(0,0.875)
  oval 0.406x1.549 smd: 3(1,0.437)
UNIMI_FBGCAX011_68P-T
  round 1.194 hole 1.194 unplated: (-1.06,0.64) (11.88,0.64)
  round 0.991 hole 0.991 unplated: (5.41,-6.27)
  round 2.692 hole 2.692 unplated: (5.41,-2.82)
  oval 0.711x0.406 smd: A1(0,0) A2(0,-0.6) A3(0,-1.2) A4(0,-1.8) A5(0,-2.4) A6(0,-3) A7(0,-3.6) A8(0,-4.2) A9(0,-4.8) A10(0,-5.4) B1(0.92,0) B2(0.92,-0.6) B3(0.92,-1.2) B4(0.92,-1.8) B5(0.92,-2.4) B6(0.92,-3) B7(0.92,-3.6) B8(0.92,-4.2) B9(0.92,-4.8) B10(0.92,-5.4) C1(3.3,0) C2(3.3,-0.6) C3(3.3,-1.2) C4(3.3,-1.8) C5(3.3,-2.4) C6(3.3,-3) C7(3.3,-3.6) C8(3.3,-4.2) C9(3.3,-4.8) C10(3.3,-5.4) D1(4.22,0) D2(4.22,-0.6) D9(4.22,-4.8) D10(4.22,-5.4) E1(6.6,0) E2(6.6,-0.6) E9(6.6,-4.8) E10(6.6,-5.4) F1(7.52,0) F2(7.52,-0.6) F3(7.52,-1.2) F4(7.52,-1.8) F5(7.52,-2.4) F6(7.52,-3) F7(7.52,-3.6) F8(7.52,-4.2) F9(7.52,-4.8) F10(7.52,-5.4) G1(9.9,0) G2(9.9,-0.6) G3(9.9,-1.2) G4(9.9,-1.8) G5(9.9,-2.4) G6(9.9,-3) G7(9.9,-3.6) G8(9.9,-4.2) G9(9.9,-4.8) G10(9.9,-5.4) H1(10.82,0) H2(10.82,-0.6) H3(10.82,-1.2) H4(10.82,-1.8) H5(10.82,-2.4) H6(10.82,-3) H7(10.82,-3.6) H8(10.82,-4.2) H9(10.82,-4.8) H10(10.82,-5.4)
W25Q80DVSSIG_SO8
  oval 0.635x1.676 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,7.25) 6(2.54,7.25) 7(1.27,7.25) 8(0,7.25)
W25Q128JVSIQ_SO8
  oval 0.635x1.676 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,7.25) 6(2.54,7.25) 7(1.27,7.25) 8(0,7.25)
Y_7M25000153_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.7) 4(0,1.7)
Y_CM31532768DZFT_2P
  rect 1.092x1.905 smd: 1(0,0) 2(2.5,0)
Y_X3G024000DC1H_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.7) 4(0,1.7)
Y_XRCGB25M000F2P18R0_4P
  rect 0.762x0.711 smd: 1(0,0) 2(1.35,0) 3(1.35,1) 4(0,1)

## Nets
0.9V_FB: CL101.2 RL41.2 RL43.1 UL13.1
1.2V_B+: PC200.1 PC201.1 PC202.1 PC203.1 PC208.1 PC216.1 PC219.1 PC220.1 PJP203.2 PQ200.5 PR206.1
1.8V_FB: CL25.2 RL24.2 RL25.1 UL11.1
2.5V_FB: CL21.2 RL21.2 RL22.1 UL10.1
3/5V_B+: PC301.1 PC303.1 PC304.1 PC305.1 PC306.1 PC307.1 PC308.1 PC309.1 PL311.2 PL312.2 PQ301.5 PQ303.5 PU301.12
3V_5V_EN: PC319.1 PR312.2 PR313.2 PR314.2 PR315.2 PR317.1
3V_ELC_ON: RE83.1 UE9.4 UE10.18
3V_EN: PR312.1 PU301.6
3VS: C2523.1 J5.2 U17.13 U17.14
3VS_GATE: C258.1 R174.2 U17.3
5V_EN: PR313.1 PU301.20
5VS: C2524.1 J4.2 U17.8 U17.9
5VS_GATE: R182.2 U17.5
+0.6V_DDR_REFCA_A: CD18.1 CD19.2 CD30.1 CD51.2 CD52.2 JDIMM1.164 JDIMM3.164 RD8.1 RD9.1 RD10.2
+0.6V_DDR_REFCA_B: CD81.1 CD82.2 CD113.2 CD114.2 CD132.1 JDIMM2.164 JDIMM4.164 RD54.2 RD55.1 RD57.1
+0.6V_VREF_CA: CD31.1 RD9.2 UC1.AB40
+0.6V_VREF_DQ: CD130.1 RD57.2 UC1.AC39
+0.6VS: CD20.1 CD21.1 CD24.1 CD28.1 CD49.1 CD50.1 CD53.1 CD58.1 CD83.1 CD84.1 CD87.1 CD90.1 CD111.1 CD112.1 CD115.1 CD119.1 JDIMM1.258 JDIMM2.258 JDIMM3.258 JDIMM4.258 PJP202.2
+0.6VSP: PC205.1 PC206.1 PJP202.1 PU201.2 PU201.20
+0.9V_CIO: CT78.1 CT79.1 CT80.1 UT1.R8 UT1.R9 UT1.R11 UT1.R12
+0.9V_DP: CT54.1 CT57.1 CT58.1 CT59.1 CT60.1 CT61.1 CT62.1 UT1.L6 UT1.L8 UT1.L11 UT1.L12 UT1.M6 UT1.M8 UT1.T11 UT1.T12 UT1.V11 UT1.V12 UT1.V13
+0.9V_LVR_OUT: CT81.1 CT82.1 CT83.1 CT84.1 UT1.F18 UT1.H11 UT1.H18 UT1.J11
+0.9V_PCIE: CT55.1 CT70.1 CT71.1 CT72.1 UT1.L18 UT1.L19 UT1.M13 UT1.M15 UT1.M16 UT1.M18 UT1.N18 UT1.N19
+0.9V_SVR: CT63.1 CT64.1 CT65.1 CT66.1 CT67.1 CT68.1 CT69.1 CT73.1 CT74.1 CT75.1 LT1.2 UT1.E12 UT1.E13 UT1.F11 UT1.F12 UT1.F13 UT1.F15 UT1.J9 UT1.L9 UT1.M9
+0.9V_USB: CT56.1 CT77.1 UT1.R15 UT1.R16
+1.2V_DDR: C2518.1 CC22.1 CC23.1 CC24.1 CC25.1 CD1.1 CD2.1 CD3.1 CD4.1 CD5.1 CD6.1 CD7.1 CD8.1 CD9.1 CD10.1 CD11.1 CD12.1 CD13.1 CD14.1 CD15.1 CD16.1 CD17.1 CD29.1 CD32.1 CD33.1 CD34.1 CD35.1 CD36.1 CD37.1 CD38.1 CD39.1 CD40.1 CD41.1 CD42.1 CD43.1 CD44.1 CD45.1 CD46.1 CD47.1 CD48.1 CD64.1 CD65.1 CD66.1 CD67.1 CD68.1 CD69.1 CD70.1 CD71.1 CD72.1 CD73.1 CD74.1 CD75.1 CD76.1 CD77.1 CD78.1 CD79.1 CD80.1 CD94.1 CD95.1 CD96.1 CD97.1 CD98.1 CD99.1 CD100.1 CD101.1 CD102.1 CD103.1 CD104.1 CD105.1 CD106.1 CD107.1 CD108.1 CD109.1 CD110.1 CD131.1 CH197.1 CH234.1 CH235.1 CH236.1 CH237.1 CH238.1 CH239.1 CH240.1 CH241.1 JDIMM1.12 JDIMM1.33 JDIMM1.54 JDIMM1.75 JDIMM1.96 JDIMM1.111 JDIMM1.112 JDIMM1.117 JDIMM1.118 JDIMM1.123 JDIMM1.124 JDIMM1.129 JDIMM1.130 JDIMM1.135 JDIMM1.136 JDIMM1.141 JDIMM1.142 JDIMM1.147 JDIMM1.148 JDIMM1.153 JDIMM1.154 JDIMM1.159 JDIMM1.160 JDIMM1.163 JDIMM1.178 JDIMM1.199 JDIMM1.220 JDIMM1.241 JDIMM2.12 JDIMM2.33 JDIMM2.54 JDIMM2.75 JDIMM2.96 JDIMM2.111 JDIMM2.112 JDIMM2.117 JDIMM2.118 JDIMM2.123 JDIMM2.124 JDIMM2.129 JDIMM2.130 JDIMM2.135 JDIMM2.136 JDIMM2.141 JDIMM2.142 JDIMM2.147 JDIMM2.148 JDIMM2.153 JDIMM2.154 JDIMM2.159 JDIMM2.160 JDIMM2.163 JDIMM2.178 JDIMM2.199 JDIMM2.220 JDIMM2.241 JDIMM3.12 JDIMM3.33 JDIMM3.54 JDIMM3.75 JDIMM3.96 JDIMM3.111 JDIMM3.112 JDIMM3.117 JDIMM3.118 JDIMM3.123 JDIMM3.124 JDIMM3.129 JDIMM3.130 JDIMM3.135 JDIMM3.136 JDIMM3.141 JDIMM3.142 JDIMM3.147 JDIMM3.148 JDIMM3.153 JDIMM3.154 JDIMM3.159 JDIMM3.160 JDIMM3.163 JDIMM3.178 JDIMM3.199 JDIMM3.220 JDIMM3.241 JDIMM4.12 JDIMM4.33 JDIMM4.54 JDIMM4.75 JDIMM4.96 JDIMM4.111 JDIMM4.112 JDIMM4.117 JDIMM4.118 JDIMM4.123 JDIMM4.124 JDIMM4.129 JDIMM4.130 JDIMM4.135 JDIMM4.136 JDIMM4.141 JDIMM4.142 JDIMM4.147 JDIMM4.148 JDIMM4.153 JDIMM4.154 JDIMM4.159 JDIMM4.160 JDIMM4.163 JDIMM4.178 JDIMM4.199 JDIMM4.220 JDIMM4.241 PJP200.2 PJP201.2 RC25.2 RD7.1 RD8.2 RD18.1 RD32.1 RD44.1 RD51.1 RD55.2 UC1.AT18 UC1.AT21 UC1.AU13 UC1.AU15 UC1.AU19 UC1.AU23 UC1.AV11 UC1.AV17 UC1.AV21 UC1.AW10 UC1.AW14 UC1.AW25 UC1.AY12 UC1.AY16 UC1.AY18 UC1.AY23 UC2.5 UZ21.1 UZ21.2
+1.2V_VCCPLL_OC: C11.1 RC21.2 UZ21.7 UZ21.8
+1.2VP: PC209.1 PC215.1 PJP200.1 PJP201.1 PL201.1 PR205.2 PU201.5 PU201.19
+1.05V_VCCAMPHYPLL: CH263.1 LH2.2 UH1.C49 UH1.D49 UH1.E49
+1.05V_VCCST: C6.1 C8.1 CC30.1 CC31.1 CC38.1 PCZ01.1 PRZ01.1 PRZ05.1 PRZ06.1 RC2.1 RC3.1 RC12.1 RC16.1 RC17.1 RC693.1 RH103.1 RH495.1 RH613.2 RH627.1 U19.6 UC1.V4 UC1.V5 UC1.V6
+1.05V_XTAL: CH56.1 LH1.2 UH1.P2 UH1.P3
+1.8V_PRIM: CH176.1 CH177.1 CH233.1 RH218.2 RH219.1 RH598.2 RH599.1 UH1.AG19 UH1.AG20 UH1.AN15 UH1.AN32 UH1.AR15 UH1.BB11
+1.8VA_TBTA_LDO: CT100.1 UT4.K1
+1.8VALW: CE204.1 PJP1802.2 QH1.2 RE50.1 RE706.1 RH180.1 RH181.1 RH182.1 RH599.2 RH603.1 RH722.2 RH723.2 RH1027.2 RS11.2 RS12.2 UE13.5
+1.8VD_TBTA_LDO: CT99.1 UT4.A2
+1.8VS_EC: CE203.1 RE50.2 RH111.2 RH518.2 UE13.1
+1.8VSP: PC1801.1 PC1803.1 PC1806.1 PJP1802.1 PR1804.1 PU1801.6
+1.8VSP_ADJ: PC1801.2 PR1804.2 PR1805.1 PU1801.7
+1.8VSP_EN: PC1805.1 PR1801.1 PR1802.1 PU1801.2
+1.8VSP_PGOOD: PR1803.2 PU1801.1
+1.8VSP_VIN: PC1802.1 PC1804.1 PJP1801.2 PU1801.3
+1.24V_DPHY: CH36.1 UH1.AJ22 UH1.AJ23 UH1.AK22 UH1.AK23 UH1.BG5
+1V_MPHY: CH82.1 CH83.1 CH184.1 CH187.1 LH1.1 LH2.1 RH12.2 UH1.B1 UH1.B2 UH1.B3 UH1.C1 UH1.C2 UH1.V19 UH1.W19 UH1.W20 UH1.W31
+1VALW: C4.1 C5.1 CH180.1 CH181.1 CH183.1 CH185.1 CH188.1 CH189.1 JPCMC.22 PJP102.2 PJP103.2 RC353.1 RH12.1 RH71.1 U19.1 U19.2 U19.7 UH1.AA22 UH1.AA23 UH1.AB20 UH1.AB22 UH1.AB23 UH1.AB27 UH1.AB28 UH1.AB30 UH1.AD20 UH1.AD23 UH1.AD27 UH1.AD28 UH1.AD30 UH1.AD31 UH1.AE17 UH1.AF23 UH1.AF27 UH1.AF30 UH1.AF31 UH1.AG31 UH1.BG45 UH1.BG46 UH1.D1 UH1.E1 UH1.U26 UH1.U29 UH1.V25 UH1.V27 UH1.V28 UH1.V30 UH1.V31 UH1.W22 UH1.W23
+1VALWP: PC110.1 PC111.1 PJP102.1 PJP103.1 PL101.2 PR107.2
+1VALWP_B+: PC101.1 PC102.1 PC103.1 PC104.1 PC105.1 PC106.1 PJP101.1 PQ101.5
+1VALWP_PGOOD: PR101.2 PU101.1 UE5.122
+2.5V_MEM: CD25.1 CD27.1 CD56.1 CD59.1 CD88.1 CD89.1 CD118.1 CD120.1 JDIMM1.257 JDIMM1.259 JDIMM2.257 JDIMM2.259 JDIMM3.257 JDIMM3.259 JDIMM4.257 JDIMM4.259 PJP2502.2
+2.5V_MEMP: PC2504.1 PC2505.1 PC2506.1 PJP2502.1 PR2504.1 PU2501.6
+2.5VOUT: CM9.1 CM32.1 CM34.1 CM35.1 CM36.1 UM8.9 UM8.14 UM8.36 UM8.41 UM8.51
+2.5VOUT_TBT: CT200.1 CT201.1 CT202.1 CT203.1 CT204.1 UT6.9 UT6.14 UT6.36 UT6.41 UT6.51
+2.5VSP_ADJ: PC2504.2 PR2504.2 PR2505.1 PU2501.7
+2.5VSP_ON: PC2501.1 PR2501.1 PR2502.1 PU2501.2
+2.5VSP_PGOOD: PR2503.2 PU2501.1
+2.5VSP_VIN: PC2502.1 PC2503.1 PJP2501.2 PU2501.3
+3.3V_ANA_PCIE: CT85.1 RT200.2 UT1.L16
+3.3V_ANA_USB2: CT86.1 UT1.J16
+3.3V_ELC: CE1.1 CE6.1 CE19.1 CE24.1 CE59.1 CE60.1 CE64.1 CE65.1 CE170.1 CE177.1 JELC.1 LE4.1 RE1.1 RE2.1 RE4.2 RE6.2 RE7.2 RE8.1 RE12.1 RE13.1 RE14.1 RE15.1 RE16.1 RE17.1 RE21.1 RE23.1 RE25.1 RE40.1 RE43.1 RE657.1 RE692.1 UE1.1 UE1.24 UE1.36 UE1.48 UE2.8 UE3.27 UE9.1
+3.3V_FLASH: CT45.1 CT103.1 RT48.1 RT49.1 RT50.1 RT51.1 RT66.1 RT67.1 RT124.1 RT130.1 UT2.8 UT4.B1 UT4.G1
+3.3V_LC: CT46.1 RT6.1 RT7.1 RT8.1 RT9.1 UT1.R6
+3.3V_TBT_SX: CT47.1 RT26.1 RT27.1 RT28.1 RT29.1 RT30.1 RT31.1 RT32.1 RT33.1 RT36.1 RT61.2 RT70.1 RT86.1 RT94.1 RT97.2 RT729.1 UT1.F8 UT10.3
+3.3V_TBT_SX_R: CT102.1 RT61.1 UT4.H2
+3V_PCH: C266.1 C267.1 CH49.1 CH182.1 CH186.1 CH190.1 CH192.1 CH231.1 CH245.2 J6.1 R367.2 RC9.1 RG555.1 RG556.1 RH7.2 RH21.2 RH25.2 RH27.2 RH29.2 RH63.1 RH95.1 RH99.2 RH100.1 RH130.1 RH453.2 RH460.1 RH461.1 RH506.2 RH515.2 RH524.1 RH533.2 RH545.2 RH558.2 RH571.2 RH594.1 RH631.1 RH632.1 RH633.1 RH634.1 RH724.2 RH725.2 RH1023.1 RN7.1 RN9.1 RN122.1 RPH6.5 RPH6.6 RPH6.7 RPH6.8 UH1.AC35 UH1.AC36 UH1.AE35 UH1.AE36 UH1.AN21 UH1.AN24 UH1.AN26 UH1.AN44 UH1.AP26 UH1.AT44 UH1.AW9 UH1.AY8 UH1.BB7 UH1.BB14 UH1.V23 UH4.8
+3V_TOUCH: C2.1 CT116.1 CT118.1 JTP.6 RE33.1 RE100.1 RE101.1 RE661.1 RE663.1 RT89.1 UT5.7 UT5.8
+3V_WLAN: CN1.1 CN2.1 CN3.1 CN4.1 CN5.1 CN8.1 CN9.1 JWLAN.2 JWLAN.4 JWLAN.72 JWLAN.74 RN20.2 RN122.2
+3VALW: C262.1 C263.1 C269.1 C270.1 C2514.1 C2515.1 CE22.1 CE62.1 CE201.1 CL117.1 CL118.1 CM23.1 CM70.1 CT121.1 CT122.1 CT5361.1 CV1076.1 CV1080.1 CV1081.1 CV1103.1 CV1105.1 CV1106.1 JDGFF1.C7 JDGFF1.C8 JDGFF1.C9 JDGFF1.C10 PCF15.1 PJP301.2 PJP304.2 PJP1801.1 PR4.1 PR9.1 PR22.1 PR40.1 PR101.1 PR210.1 PR756.2 PR2503.1 PRF09.2 PRS14.1 PRS15.1 PRS34.1 PRS35.1 PUF01.15 R307.1 R325.1 RE64.2 RE70.1 RE79.1 RE201.1 RE300.2 RE530.1 RE642.1 RE643.1 RE652.1 RE688.1 RE689.1 RE691.1 RE695.1 RE698.1 RE700.1 RE704.1 RH2.1 RH6.2 RH706.1 RH707.1 RH1026.1 RM5.1 RM41.1 RT88.1 RT111.1 RT260.1 RT729.2 RT730.2 RT731.1 RT732.1 U16.1 U16.2 U16.7 U17.1 U17.2 U17.4 U18.5 UE6.24 UE9.5 UE10.24 UL14.5 UM3.5 UM7.5 UT3.5 UT8.5 UV64.1 UV64.2 UV64.7 UV65.6
+3VALW_EC: CE29.1 CE30.1 CE31.2 CE32.2 LE1.1 PR14.2 PR24.2 RE24.2 RE78.2 RE79.2 RE90.5 RE90.6 RE705.1 UE5.22 UE5.33 UE5.96
+3VALW_LAN: CL20.1 CL24.1 CL100.1 CL103.1 CL120.1 RL1.2 RL3.1 RL20.1 RL23.1 RL30.2 RL42.1 RL44.2 RL52.1 RL54.1 RL57.2 RL60.1 RL66.2 RL71.2 UL4.6 UL4.8 UL10.3 UL11.3 UL13.3 UL14.1
+3VALW_PD: CT88.1 CT101.1 RT53.2 RT731.2 UT4.H1
+3VALW_SSD: C617.1 C618.1 C620.1 C621.1 C622.1 C623.1 C624.1 C625.1 C627.1 C628.1 C631.1 C635.1 C636.1 C637.1 C638.1 C641.1 JP6.2 JSSD1.2 JSSD1.4 JSSD1.12 JSSD1.14 JSSD1.16 JSSD1.18 JSSD1.70 JSSD1.72 JSSD1.74 JSSD2.2 JSSD2.4 JSSD2.12 JSSD2.14 JSSD2.16 JSSD2.18 JSSD2.70 JSSD2.72 JSSD2.74 R363.2 R365.2
+3VALW_TBT: CH242.1 CT48.1 CT49.1 CT50.1 CT51.1 CT52.1 CT53.1 LT4.2 RT20.1 RT21.1 RT76.2 RT77.2 RT95.2 RT695.1 RT723.1 RT730.1 UT1.A2 UT1.A3 UT1.B3 UT1.H9
+3VALW_TBT_S5: CT124.1 CT205.1 CT206.1 CT207.1 CT208.1 CT209.1 CT210.1 CT213.1 CT216.1 CT217.1 CT218.1 CT219.1 RT53.1 RT95.1 RT97.1 RT107.1 RT217.1 RT218.1 RT220.1 RT222.1 RT225.1 RT226.1 RT228.1 RT231.1 RT233.1 RT236.1 RT237.1 RT240.1 RT242.1 RT244.1 RT250.1 RT260.2 RT713.1 RT714.1 UT6.24 UT7.5 UT7.9 UT7.12 UT7.16 UT8.1 UT10.1
+3VALWP: PC312.1 PC313.1 PJP301.1 PJP304.1 PL301.1 PR301.1
+3VLP: CU26.1 DU8.1 PC302.1 PR15.1 PR17.1 PR25.2 PU301.3 RE63.1 RE77.1 RE78.1 RE684.1 RU1.1 RU4.1 RU5.1 RU7.1 UU5.5
+3VS: C256.1 C257.1 C2498.1 C2531.1 CH201.1 CM18.1 CM19.1 CM20.1 CM21.1 CM22.1 CM29.1 CM30.1 CM31.1 CM33.1 CM37.1 CM38.1 CS2.1 CS7.1 CU108.2 CU109.2 CV19.1 CV21.1 CV902.1 CV903.1 CV956.1 J5.1 JDGFF1.D9 JDGFF1.D10 JDGFF2.D9 JDGFF2.D10 PR1803.1 PRA02.2 PRA20.1 PRF02.1 PRZ16.1 QE59.2 QH5.2 QH5.5 QS3.2 R181.1 R371.1 R372.1 R373.1 R374.1 R375.1 R376.1 R377.1 R378.1 R379.1 R408.2 R409.2 R410.2 RC62.2 RC63.2 RD1.2 RD2.2 RD3.2 RD12.2 RD13.2 RD14.2 RD26.2 RD27.2 RD28.2 RD38.2 RD39.2 RD40.2 RD58.2 RD59.2 RD60.2 RD61.2 RE20.2 RE84.1 RE90.7 RE90.8 RE656.1 RE690.1 RE696.1 RE707.2 RF1.2 RF2.2 RF4.2 RF5.2 RH5.1 RH85.2 RH462.1 RH463.1 RH501.1 RH502.1 RH512.2 RH516.1 RH517.1 RH520.1 RH521.1 RH525.1 RH537.2 RH588.1 RH600.2 RH601.1 RH602.1 RH604.1 RH605.1 RH606.1 RH607.1 RH614.1 RL9.1 RL69.2 RM14.1 RM18.1 RM20.1 RM26.1 RM66.2 RM76.1 RM79.1 RM81.1 RM85.1 RM86.1 RM96.1 RN20.1 RP3.1 RP3.2 RP3.3 RP3.4 RP5.1 RP8.1 RP9.1 RP10.1 RPC7.5 RPC7.6 RPC7.7 RPC7.8 RS2.2 RT110.1 RT132.2 U2407.1 U2408.1 UH3.5 UM4.5 UM4.9 UM4.12 UM4.16 UM8.24 US1.1 US1.7 US1.8 US1.14 UU6.1 UU6.13
+3VS_ACC: CS17.1 CS18.1 CS19.1 CS20.1 RH614.2 RS9.2 RS10.2 RS15.1 RS16.2 RS18.2 RS19.2 US2.5 US2.8 US3.9 US3.10
+3VSP_SSD: C2512.1 C2513.1 JP6.1 U16.6
+5V_HDD: CS1.1 CS5.1 CS6.1 CS16.1 CV1073.1 JHDD.17 JHDD.18 JHDD.19 JHDD.20 JP3.2
+5V_TOBII: CV1071.1 JTOBII.5 UE12.1
+5V_USB_PWR1: CU2.1 CU3.1 CU6.1 CU47.1 CU242.1 CU243.1 JUSB1.1 UU1.12
+5V_USB_PWR2: CU10.1 CU11.1 CU45.1 CU101.1 CU102.1 CU244.1 CU245.1 JUSB2.1 JUSB3.1 UU3.1
+5VALW: C264.1 C265.1 C2516.1 C2519.1 C2521.1 C2525.1 CE80.1 CE81.1 CE82.1 CT90.1 CT91.1 CT92.1 CT93.1 CT157.1 CU7.1 CU46.1 CU48.1 CV1074.1 CV1078.1 JDGFF1.C5 JDGFF1.D2 JDGFF1.E2 JWDB.1 PC109.1 PJP302.2 PJP303.2 PJP2501.1 PR5.2 PR10.2 PR203.1 PR204.1 PR1806.1 PR2506.1 PU101.7 QE8.3 RE28.1 RE154.1 RE156.1 RE158.1 RE161.2 RM91.1 RM92.1 RM93.1 RM94.1 U16.3 U17.6 U17.7 U19.3 UE12.5 UT4.A11 UT4.B11 UT4.C11 UT4.D11 UT4.H10 UU1.1 UU3.5 UV64.3 UZ21.4
+5VALW_LED: JPWR.1 JPWR.2 QE8.1
+5VALWP: PC314.1 PC315.1 PJP302.1 PJP303.1 PL302.2 PR302.2 PU301.14
+5VS: C29.1 C260.1 C261.1 CE61.1 CE86.1 CE87.1 CE175.1 CE176.1 CF4.1 CF5.1 CV805.1 CV806.1 CV957.1 J4.1 JDGFF1.E9 JDGFF1.E10 JDGFF2.E9 JDGFF2.E10 JFAN1.2 JFAN2.2 JFC.1 JP3.1 JPK.1 JPK.2 JPK.3 JPK.4 JPK.5 JTRON.1 JTRON.2 JTRON.3 JTRON.4 JTRON.21 JTRON.22 JTRON.23 JTRON.24 PCA08.1 PCI204.1 PCI206.1 PCI211.1 PJP1201.1 PR1201.1 PRA01.2 PRG02.1 PRG03.2 PRG04.2 PRG13.1 PRG15.2 PRG16.2 PRI11.1 PRI12.2 PRI14.2 PRI27.1 PRI29.2 PRI30.2 PRI52.1 PRI54.2 PRI55.2 PRI67.1 PRI69.2 PRI70.2 PRI92.1 PRI94.2 PRI95.2 PRI107.1 PRI109.2 PRI110.2 PRI208.1 PRI217.1 PRI229.1 PRZ03.1 PRZ44.2 PUA01.18 PUI07.9 PUI08.9 PUI09.9 Q2409.1 Q2409.2 Q2409.5 Q2409.6 RF3.2 RF6.2 RS1.1
+5VS_TP_LED: C2501.1 C2508.1 JTP.15 JTP.16 Q2409.4
+12V_COMP: PR1206.1 PU1201.1
+12V_COMP_1: PC1207.1 PR1206.2
+12V_ENA: PR1201.2 PR1205.1 PU1201.3
+12V_FAN: CF6.1 CF7.1 JFAN1.1 JFAN2.1 PJP1202.2
+12V_FB: PC1204.2 PR1203.2 PR1204.1 PU1201.2
+12V_LX: PD1201.2 PL1201.2 PR1202.1 PU1201.6 PU1201.7
+12V_SNUB: PC1202.1 PR1202.2
+12V_SS: PC1206.1 PU1201.10
+12V_VIN: PC1201.1 PC1203.2 PJP1201.2 PL1201.1 PU1201.8 PU1201.9
+12VP: PC1204.1 PC1205.1 PC1208.1 PD1201.1 PJP1202.1 PR1203.1
+19V_ADPIN_1: PC1.1 PC2.1 PC19.1 PC20.1 PJPDC1.8 PJPDC1.9 PJPDC1.10 PJPDC1.11 PJPDC1.12 PJPDC1.13 PL1.1 PL2.1 PL3.1 PL4.1 PL5.1
+19V_ADPIN_2: PC5.1 PC6.1 PC21.1 PC22.1 PJPDC2.8 PJPDC2.9 PJPDC2.10 PJPDC2.11 PJPDC2.12 PJPDC2.13 PL7.1 PL8.1 PL9.1 PL10.1 PL11.1
+19V_VIN_1: PC3.1 PC4.1 PCS69.1 PL1.2 PL2.2 PL3.2 PL4.2 PL5.2 PQS10.1 PQS10.2 PQS10.3 PQS12.3 PR36.1 PRS57.1 PRS58.1 PRS59.1 PRS63.1
+19V_VIN_2: PC7.1 PC8.1 PCS70.1 PL7.2 PL8.2 PL9.2 PL10.2 PL11.2 PQS15.1 PQS15.2 PQS15.3 PQS16.3 PR38.1 PRS66.1 PRS67.1 PRS69.1 PRS70.1
+AVDD09: CL66.1 CL67.1 CL68.1 CL69.1 CL70.1 RL38.1 UL1.1 UL1.7 UL1.17 UL1.23 UL1.80
+AVDD18: CL54.1 CL55.1 CL56.1 CL57.1 CL58.1 RL47.1 UL1.3 UL1.5 UL1.19 UL1.21 UL1.81
+AVDD25: CL47.1 CL48.1 CL49.1 CL50.1 CL51.1 RL45.1 UL1.10 UL1.14 UL1.26 UL1.83 UL1.86
+AVDD33: CL40.1 CL41.1 CL42.1 CL43.1 CL44.1 RL30.1 UL1.4 UL1.12 UL1.20 UL1.28 UL1.84
+DVDD09: CL71.2 CL72.2 CL73.2 CL74.2 CL75.2 CL76.2 RL39.1 UL1.33 UL1.44 UL1.50 UL1.51 UL1.72 UL1.73
+DVDD18: CL59.1 CL60.1 CL61.1 RL48.1 UL1.35 UL1.52 UL1.70
+DVDD18_UPS: CL64.1 CL65.1 RL49.1 UL1.65
+DVDD25_UPS: CL52.1 CL53.1 RL46.1 UL1.66
+DVDD33: CL45.1 CL46.1 RL44.1 UL1.34 UL1.71
+DVDD3318: CL1.1 CL2.1 RL1.1 RL2.1 RL5.1 RL6.1 RL8.1 RL58.1 UL1.41 UL1.46
+V18R: RE24.1 UE5.124
+VCC_CORE: PCI86.1 PCI87.1 PCI88.1 PCI89.1 PCI90.1 PCI91.1 PCI92.1 PCI93.1 PCI94.1 PCI95.1 PCI96.1 PCI97.1 PCI98.1 PCI99.1 PCI100.1 PCI101.1 PCI102.1 PCI103.1 PCI104.1 PCI105.1 PCI106.1 PCI107.1 PCI108.1 PCI109.1 PCI110.1 PCI111.1 PCI112.1 PCI113.1 PCI114.1 PCI115.1 PCI116.1 PCI117.1 PCI118.1 PCI119.1 PCI120.1 PCI121.1 PCI122.1 PCI123.1 PCI124.1 PCI125.1 PCI126.1 PCI127.1 PCI128.1 PCI129.1 PCI130.1 PCI131.1 PCI132.1 PCI133.1 PCI134.1 PCI135.1 PCI136.1 PCI137.1 PCI138.1 PCI149.1 PCI150.1 PLI01.4 PLI02.4 PLI03.4 PLI04.4 PLI05.4 PLI06.4 RC197.1 UC1.A25 UC1.A26 UC1.A27 UC1.A28 UC1.A29 UC1.A30 UC1.AJ11 UC1.AJ12 UC1.AJ13 UC1.AJ14 UC1.AJ15 UC1.AJ16 UC1.AJ17 UC1.AJ18 UC1.AJ19 UC1.AJ20 UC1.AJ21 UC1.AJ25 UC1.AJ26 UC1.AJ27 UC1.AJ28 UC1.AJ29 UC1.AK21 UC1.B25 UC1.B27 UC1.B29 UC1.B31 UC1.B32 UC1.B33 UC1.B34 UC1.B35 UC1.B36 UC1.B37 UC1.C25 UC1.C26 UC1.C27 UC1.C28 UC1.C29 UC1.C30 UC1.C32 UC1.C34 UC1.C36 UC1.D25 UC1.D27 UC1.D29 UC1.D31 UC1.D32 UC1.D33 UC1.D34 UC1.D35 UC1.D36 UC1.E24 UC1.E25 UC1.E26 UC1.E27 UC1.E28 UC1.E29 UC1.E30 UC1.E32 UC1.E34 UC1.E36 UC1.F23 UC1.F24 UC1.F25 UC1.F27 UC1.F29 UC1.F31 UC1.F32 UC1.F33 UC1.F34 UC1.F35 UC1.F37 UC1.G23 UC1.G24 UC1.G25 UC1.G26 UC1.G27 UC1.G28 UC1.G29 UC1.G30 UC1.G32 UC1.G34 UC1.G35 UC1.H22 UC1.H23 UC1.H25 UC1.H27 UC1.H29 UC1.H31 UC1.H32 UC1.H33 UC1.H34 UC1.J21 UC1.J22 UC1.J23 UC1.J24 UC1.J25 UC1.J26 UC1.J27 UC1.J28 UC1.J29 UC1.J30 UC1.J31 UC1.J33 UC1.J35 UC1.K16 UC1.K18 UC1.K20 UC1.K21 UC1.K23 UC1.K25 UC1.K27 UC1.K29 UC1.K31 UC1.K32 UC1.K34 UC1.L14 UC1.L15 UC1.L16 UC1.L17 UC1.L18 UC1.L19 UC1.L20 UC1.L21 UC1.L22 UC1.L23 UC1.L24 UC1.L25 UC1.L26 UC1.L27 UC1.L28 UC1.L29 UC1.L30 UC1.L31 UC1.L33 UC1.M13 UC1.M14 UC1.M16 UC1.M18 UC1.M20 UC1.M22 UC1.M24 UC1.M26 UC1.M28 UC1.M30 UC1.M32
+VCCGT: PCG23.1 PCG24.1 PCG25.1 PCG26.1 PCG27.1 PCG28.1 PCG29.1 PCG30.1 PCG31.1 PCG32.1 PCG33.1 PCG34.1 PCG35.1 PCG36.1 PCG37.1 PLG01.4 PLG02.4 RC691.1 UC1.AA34 UC1.AA35 UC1.AA36 UC1.AA37 UC1.AA38 UC1.AB33 UC1.AB34 UC1.G36 UC1.G37 UC1.G38 UC1.G39 UC1.G40 UC1.H36 UC1.H38 UC1.H40 UC1.J36 UC1.J37 UC1.J38 UC1.J39 UC1.J40 UC1.K36 UC1.K38 UC1.K40 UC1.L34 UC1.L35 UC1.L36 UC1.L37 UC1.L38 UC1.L39 UC1.L40 UC1.M33 UC1.M34 UC1.M36 UC1.M38 UC1.M40 UC1.N34 UC1.N35 UC1.N36 UC1.N37 UC1.N38 UC1.N39 UC1.N40 UC1.P33 UC1.P34 UC1.P36 UC1.P38 UC1.P40 UC1.R34 UC1.R35 UC1.R36 UC1.R37 UC1.R38 UC1.R39 UC1.R40 UC1.T33 UC1.T34 UC1.T36 UC1.T38 UC1.T40 UC1.U34 UC1.U35 UC1.U36 UC1.U37 UC1.U38 UC1.U39 UC1.U40 UC1.V33 UC1.V34 UC1.V36 UC1.V38 UC1.V40 UC1.W34 UC1.W35 UC1.W36 UC1.W37 UC1.W38 UC1.Y33 UC1.Y34 UC1.Y36 UC1.Y38
+VCCIO: CC32.1 CC33.1 CC34.1 CC35.1 CC36.1 CC37.1 PJPF02.2 RC10.1 RC14.1 UC1.AJ23 UC1.AK11 UC1.AK14 UC1.AK24 UC1.M8 UC1.P8 UC1.T8 UC1.U8 UC1.W8
+VCCIOP: PCF07.1 PCF08.1 PCF09.1 PCF10.1 PCF11.1 PJPF02.1 PLF01.2 PRF05.1
+VCCRTCEXT: CH264.2 UH1.BF47 UH1.BG47
+VCCSA: CC26.1 CC27.1 CC28.1 CC29.1 CC47.1 CC48.1 CC49.1 CC50.1 CC51.1 CC52.1 PCA15.1 PCA16.1 PCA17.1 PCA18.1 PCA19.1 PCA20.1 PCA21.1 PCA22.1 PCA23.1 PCA24.1 PLA01.4 PRA17.2 UC1.AA6 UC1.AA7 UC1.AB6 UC1.AB7 UC1.AB8 UC1.AC7 UC1.AC8 UC1.N7 UC1.P7 UC1.R7 UC1.T7 UC1.U7 UC1.V7 UC1.W7 UC1.Y6 UC1.Y7 UC1.Y8
+VCCST_PECI: CE171.1 RH613.1 UE5.117
+VDD09: CL101.1 CL102.1 CL104.1 LL4.2 RL38.2 RL39.2 RL40.2 RL41.1
+VDD18: CL25.1 CL26.1 CL27.1 LL2.2 RL2.2 RL24.1 RL47.2 RL48.2 RL49.2 RL50.2
+VDD25: CL21.1 CL22.1 CL23.1 CL28.1 CL29.1 LL1.2 RL21.1 RL45.2 RL46.2 RL70.2
+VDDA: CE7.1 CE9.1 CE169.1 LE4.2 UE1.9

# Allegro board Alienware Area-51M LA-G881P.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PROC_DETECT#: length 157.5
  TOP w0.089: v2(272.67,58.27) 272.62,58.27 UH1.AP41
  TOP w0.112: RC356.1 v1(176.81,31.07) v2(176.81,30.57)
  IN3 w0.127: v2(260.28,58.94) 260.64,58.57 261.14,58.57 261.63,58.08 269,58.08 269.68,58.76 270.75,58.76 271.25,58.27 v2(272.67,58.27)
  IN4 w0.084: v2(180.22,10.19) 180.99,10.19 188.24,17.44 239.97,17.44 244.32,21.79 250.34,21.79 256,27.44 256,33.52 255.44,34.08 255.44,35.12 255.23,35.33 255.23,36.07 255.44,36.28 255.44,46.57 255.24,46.77 255.24,48.6 255.38,48.74 255.38,49.89 255.43,49.94 255.43,57.63 256.57,58.77 260.11,58.77 v2(260.28,58.94)
  BOTTOM w0.112: v2(180.22,10.19) 180.22,12.62 175.28,17.55 175.28,29.04 v2(176.81,30.57)
PROC_SELECT#: length 4.7
  TOP w0.102: TC2.1 153.32,49.68 152.9,49.27 150.58,49.27 v2(150.16,48.84)
  BOTTOM w0.254: v2(150.16,48.84) UC1.AB36
PROCHOT#_CHG: length 5.6
  TOP w0.112: PR777.2 v1(213.05,138.88)
  TOP w0.203: PU703.5 209.9,140.18 210.34,140.61 212.55,140.61 213.05,140.1 PR777.2
PROG_CHG: length 2.8
  TOP w0.203: PR753.2 209.41,143.15 v1(209.33,143.06) 208.72,143.06 208.43,142.77 PU703.9
PROG_ISL95338_1: length 3.1
  TOP w0.112: v1(129.76,146.52) 129.32,146.07 v2(129.08,146.07)
  TOP w0.254: v2(129.08,146.07) 128.9,145.9 128.11,145.9 127.98,145.77 PRS18.2
  BOTTOM w0.203: v2(129.08,146.07) 128.89,145.88 PUS1.27
PROG_ISL95338_2: length 3
  TOP w0.112: PRS38.2 v3(150.55,141.95)
  TOP w0.254: v2(151.37,143.51) 151.15,143.51 150.82,143.18 PRS38.2
  BOTTOM w0.203: v2(151.37,143.51) 151.23,143.37 PUS2.27
PS_ID_1: length 259.1
  TOP w0.112: PR4.2 152.83,164.87 PR3.2 v2(151.31,165.66) ; UE5.16 290.7,17.88 290.29,18.29 289.51,18.29 289.36,18.14 v2(289.36,17.87)
  IN2 w0.104: v2(151.31,165.66) 159.77,157.19 159.77,147.42 167.56,139.63 167.56,125.57 179.31,113.82 179.31,112.52 183.61,108.22 183.61,104.28 189.17,98.72 197.9,98.72 199.03,99.85 210.39,99.85 211.34,98.9 234.72,98.9 235.21,98.4 252.46,98.4 253.26,97.6 257.89,97.6 260.4,95.09 260.4,84.84 261.78,83.46 261.78,77.25 262.67,76.36 v2(262.67,75.39)
  BOTTOM w0.112: v2(289.36,17.87) 289.36,18.16 v1(288.01,19.51) 286.65,20.87 285.72,20.87 283.98,22.61 276.93,22.61 269.96,29.58 268.11,29.58 263.29,34.41 263.29,36.58 260.7,39.17 260.7,48.15 261.32,48.77 261.32,52.85 260.92,53.26 260.92,53.99 262.01,55.08 262.01,60.53 264.18,62.7 264.18,67.21 263.07,68.32 263.07,74.98 v2(262.67,75.39)
PS_ID_2: length 272.7
  TOP w0.112: UE5.19 290.71,16.68 290.62,16.77 290.6,16.77 290.55,16.81 290.18,16.81 v2(289.98,17.01)
  IN2 w0.104: v2(129.87,150.52) 129.87,148.71 130.15,148.43 141.26,148.43 142.32,147.38 145.87,147.38 146.25,147 149.84,147 150.42,147.58 155.91,147.58 156.38,147.11 159.42,147.11 167.1,139.43 167.1,125.38 178.85,113.63 178.85,112.32 183.14,108.03 183.14,104.09 189.16,98.07 197.91,98.07 199.22,99.38 210.2,99.38 211.15,98.43 234.52,98.43 235.02,97.94 237.95,97.94 238.67,97.22 239.99,97.22 240.6,97.83 243.91,97.83 244.6,97.14 257.7,97.14 259.85,94.99 259.85,84.69 261.31,83.23 261.31,76.81 v2(262.03,76.1)
  BOTTOM w0.112: v2(262.03,76.1) 262.71,76.1 263.31,75.49 263.31,68.42 264.42,67.31 264.42,62.61 262.25,60.43 262.25,54.98 261.16,53.89 261.16,53.36 261.56,52.95 261.56,48.67 260.94,48.05 260.94,39.27 263.53,36.68 263.53,34.5 268.21,29.82 270.06,29.82 277.03,22.85 284.21,22.85 v1(285.26,21.8) 285.96,21.11 286.91,21.11 289.64,18.37 290.08,18.37 290.48,17.97 290.48,17.51 v2(289.98,17.01)
  BOTTOM w0.254: PR8.2 131.75,151.05 131.47,150.77 131.47,150.26 PR9.2 130.13,150.26 v2(129.87,150.52)
PSID_1: length 20.8
  TOP w0.112: v3(153.95,155.85) 153.73,156.08 PL6.1
  TOP w0.254: v2(151.25,156.08) PL6.1
  BOTTOM w0.254: PJPDC1.1 137.22,156.33 137.47,156.08 139.95,156.08 140.75,155.28 150.45,155.28 v2(151.25,156.08)
PSID_1-1: length 14.8
  TOP w0.254: PR1.1 156.87,164.74 157.45,164.17 157.45,162.79 v1(157,162.35) PQ1.1 155.16,162.13 153.95,160.92 153.95,158.9 155.17,157.68 PD1.2 154.12,156.39 152.99,156.39 152.55,156.83 PL6.2
PSID_1-2: length 3.1
  TOP w0.112: PQ2.2 v1(156.94,165.73)
  TOP w0.254: 155.33,164.75 PR2.1 ; 155.33,164.75 PR1.2 ; 155.33,164.75 155.33,165.31 PQ2.2
PSID_1-3: length 6
  TOP w0.254: PR3.1 v2(151.35,164.74) ; PQ1.3 152.59,161.38 v2(152.09,161.88)
  IN1 w0.254: v2(152.09,161.88) 151.6,161.88 151.35,162.14 v2(151.35,164.74)
  BOTTOM w0.112: v2(151.35,164.74) v1(151.79,165.19)
PSID_1-4: length 9.8
  TOP w0.112: v1(156.75,163.85) 155.92,163.85 155.6,163.54 v2(154.2,163.54)
  TOP w0.254: PQ1.2 153.98,163.31 v2(154.2,163.54) ; PQ2.1 153.12,167.42 PR5.1 v2(153.04,166.69)
  IN1 w0.254: v2(154.2,163.54) 153.04,164.7 v2(153.04,166.69)
PSID_2: length 8.7
  TOP w0.112: v2(131.19,155.6) 130.52,155.6 129.63,156.49 v3(128.62,156.49)
  TOP w0.254: PJPDC2.1 v2(131.19,155.6)
  BOTTOM w0.254: v2(131.19,155.6) 132.25,154.54 PL12.1
PSID_2-1: length 12.2
  BOTTOM w0.254: PL12.2 135.27,154.33 PD2.2 136.35,153.64 136.99,152.99 136.99,150.42 v1(136.73,150.15) PQ3.1 135.2,146.38 PR6.1
PSID_2-2:
  vias: v1(137.06,145.18)
PSID_2-3: length 3
  BOTTOM w0.112: v1(132.05,152.11) 133.07,151.08 PR8.1
  BOTTOM w0.254: PR8.1 133.11,151.01 PQ3.3
PSID_2-4:
  vias: v1(132.52,145.25)
PSYS_CHG: length 6.4
  TOP w0.112: PR727.1 213.31,143.08 213.96,143.72 v1(214.21,143.72)
  TOP w0.203: PU703.8 209.45,141.38 209.7,141.63 209.7,142.14 210.21,142.64 212.06,142.64 PR792.2
  TOP w0.254: PR792.2 PR727.1
PTP_KBBL#: length 212
  TOP w0.112: v2(280.09,3.02) 279.77,3.34 279.77,5.73 278.86,6.65 278.86,11.47 279.42,12.02 284.83,12.02 285.4,11.45 RE703.1 ; v2(168.37,2.71) 165.57,5.5 133.22,5.5 129.87,8.85 v3(122.71,8.85) 122.3,8.44 118.58,8.44 v2(118.46,8.56)
  IN1 w0.084: v2(280.09,3.02) 280.09,2.66 279.02,1.6 253.26,1.6 252.88,1.21 240.44,1.21 240.23,1.42 240.23,1.8 239.89,2.14 239.89,2.71 239.81,2.79 239.3,2.79 238.16,3.93 223.53,3.93 222.01,2.4 219.17,2.4 218.36,3.21 196.01,3.21 194.04,1.23 190.16,1.23 189.51,1.89 173.16,1.89 172.34,2.71 v2(168.37,2.71)
  BOTTOM w0.112: RE663.2 103.96,17.16 103.76,16.96 103.27,16.96 102.45,16.15 JTP.8 102.45,14.18 103.53,13.1 106.82,13.1 108.5,14.79 108.5,15.47 108.82,15.79 109.84,15.79 112.87,12.75 115.39,12.75 118.46,9.68 v2(118.46,8.56)
PTP_LID_CLOSE#: length 169.4
  TOP w0.112: UE10.17 243.62,8.62 243.38,8.86 240.66,8.86 239.25,7.46 239.25,6.18 241.82,3.61 243.31,3.61 v3(243.42,3.51) 244.14,2.78 v2(244.14,2.75)
  IN3 w0.104: v2(244.14,2.75) 243.77,2.38 243.29,2.38 241.29,4.38 223,4.38 221.94,3.31 219.66,3.31 218.6,4.38 196.35,4.38 194.35,2.38 189.4,2.38 188.73,3.05 186.96,3.05 186.29,2.38 173.29,2.38 172.56,3.11 166.81,3.11 165.55,4.38 125.19,4.38 125.15,4.34 123.04,4.34 v2(122.63,4.75)
  IN4 w0.084: v2(102.02,11.19) 103.2,11.19 103.62,11.61 105.37,11.61 106.04,10.94 109.29,10.94 112.23,7.99 119.38,7.99 v2(122.63,4.75)
  BOTTOM w0.112: v2(102.02,11.19) 102.02,12.04 101.96,12.09 101.96,15.06 JTP.7 101.95,16.13 103.35,17.53 RE33.2
PWM1_GT: length 84.6
  TOP w0.203: PUZ01.12 67.16,28.39 67.46,28.09 67.51,28.09 v2(67.64,27.95)
  TOP w0.254: PRG01.1 v1(131.09,11.96) v2(132.04,12.91)
  IN3 w0.254: v2(68.19,21.04) 68.33,21.04 68.58,21.29 68.58,24.1 67.66,25.02 67.66,27.93 v2(67.64,27.95)
  IN4 w0.254: v2(132.04,12.91) 131.98,12.98 124.9,12.98 123.85,14.03 123.85,14.56 122.91,15.5 118.21,15.5 117.65,16.06 117.65,20.34 116.29,21.7 111.96,21.7 111.46,21.21 109.97,21.21 109.46,20.7 109.46,19.69 108.16,18.39 100.77,18.39 99.17,19.99 91.61,19.99 90.82,20.79 84.5,20.79 84.49,20.79 81.5,20.79 80.87,21.41 72.08,21.41 71.86,21.18 68.33,21.18 v2(68.19,21.04)
PWM1_IA: length 19.5
  TOP w0.112: v2(100.88,30.81) v1(100.23,30.81)
  IN1 w0.254: v2(100.88,30.81) 100.37,30.81 98.83,32.34 94.78,32.34 93.18,30.74 84.84,30.74 v2(84.73,30.64)
  BOTTOM w0.254: PRI209.2 84.3,30.21 v2(84.73,30.64) ; PRI13.1 v2(100.88,30.81)
PWM1_VCORE: length 29.7
  TOP w0.112: v1(69.12,34.74) 68.41,34.74 68.1,34.44 v2(67.78,34.44)
  TOP w0.203: v2(67.78,34.44) 67.36,34.44 PUZ01.25
  IN1 w0.254: v2(67.78,34.44) 67.84,34.5 70.76,34.5 72.15,35.9 76.32,35.9 81.48,30.74 83.73,30.74 84.43,30.05 87.85,30.05 88.35,29.54 88.35,28.15 88.8,27.71 v2(89.81,27.71)
  BOTTOM w0.254: PRI206.1 89.69,27.58 v2(89.81,27.71)
PWM2_GT: length 94.9
  TOP w0.112: v2(84.92,18.36) 84.92,18.37 84.31,18.98 v1(74.51,18.98) 73.12,18.98 70.31,21.79 70.31,27.17 68.65,28.83
  TOP w0.203: PUZ01.13 68.38,29.42 68.65,29.15 68.65,28.83
  IN3 w0.104: v2(84.92,18.36) 84.96,18.4 100.33,18.4 100.95,17.78 107.65,17.78 108.35,17.08 108.35,16.54 108.49,16.41 109.27,15.63 109.76,15.63 110.32,15.07 110.6,15.07 112.34,13.33 118.75,13.33 118.94,13.33 119.56,12.72 123.82,12.72 124.09,12.45 130.87,12.45 131.04,12.28 141.95,12.28 142.39,11.83 145.58,11.83 146.27,12.52 v2(150.86,12.52)
  BOTTOM w0.254: v2(150.86,12.52) 150.64,12.31 PRG14.1
PWM2_IA: length 19.4
  BOTTOM w0.254: PRI28.1 101.22,20.95 100.9,21.27 99.75,21.27 97.68,23.34 94.82,23.34 94.07,24.09 88.53,24.09 86.71,25.9 v1(85.5,25.9) 85.37,26.03 PRI205.2
PWM2_VCORE: length 27.6
  TOP w0.112: v1(68.61,35.96) 68.61,35.9 68.18,35.47 v2(68.15,35.47)
  TOP w0.203: PUZ01.26 66.76,35.08 67.14,35.46 67.93,35.46 67.94,35.47 v2(68.15,35.47)
  IN1 w0.254: v2(89.75,41.91) 89.6,41.91 87.08,39.39 82.98,39.39 82.35,39.39 81.44,38.48 81.06,38.48 80.06,37.48 75.3,37.48 75.29,37.47 70.65,37.47 69.27,36.09 69.09,36.09 68.46,35.47 v2(68.15,35.47)
  BOTTOM w0.254: PRI213.1 v2(89.75,41.91)
PWM3_IA: length 26.9
  IN1 w0.254: v2(104.44,57.33) 104.27,57.33 104.12,57.17 103.09,57.17 90.2,44.28 87.02,44.28 86.77,44.03 v2(86.77,43.91)
  BOTTOM w0.254: v2(104.44,57.33) 105.09,57.33 PRI53.1 ; v2(86.77,43.91) 86.2,44.49 v1(85.37,44.49) 84.31,44.49 PRI212.2
PWM3_VCORE: length 29.2
  TOP w0.203: v2(68.01,36.04) v1(67,36.04) 66.36,35.4 PUZ01.27
  IN1 w0.254: v2(68.01,36.04) 67.67,35.69 67.67,35.27 67.95,34.98 69.83,34.98 71.51,36.66 80.32,36.66 81.38,37.72 81.75,37.72 82.67,38.63 86.69,38.63 89.67,35.64 v2(89.67,35.53)
  BOTTOM w0.254: PRI225.1 v2(89.67,35.53)
PWM4_IA: length 42.3
  IN1 w0.254: v2(84.73,40.22) 84.72,40.23 84.72,41.76 85.94,42.98 85.94,43.93 86.67,44.66 90.04,44.66 100.4,55.02 v2(100.4,56.12)
  BOTTOM w0.254: v2(84.73,40.22) 84.69,40.18 PRI219.2 ; PRI68.1 103.83,69.57 102.36,68.1 102.36,66.58 100.33,64.54 v1(100.33,60.86) 100.33,56.18 v2(100.4,56.12)
PWM5_IA: length 29.4
  IN1 w0.254: v2(84.67,38) 84.04,37.36 84.04,33.49 84.86,32.66 92.35,32.66 93.31,33.61 93.31,37.59 95.81,40.09 99.28,40.09 v2(100.35,41.17)
  BOTTOM w0.254: PRI224.2 84.09,38 v2(84.67,38) ; v2(100.35,41.17) v1(100.7,40.83) 100.86,40.66 PRI93.1
PWM6_IA: length 32.8
  TOP w0.112: v2(102.34,49.37) v1(101.85,49.37)
  IN1 w0.254: v2(84.67,33.8) 87.4,33.8 88.16,33.04 89.45,33.04 90.22,33.8 90.22,39.29 90.89,39.96 92.48,39.96 93.62,41.11 93.62,46.38 96.62,49.37 v2(102.34,49.37)
  BOTTOM w0.254: PRI108.1 v2(102.34,49.37) ; PRI222.2 v2(84.67,33.8)
PWR_B#: length 45.5
  TOP w0.112: JPWR.8 170.5,180.33 170.34,180.49 170.34,181.76 170.5,181.92 JPWR.7 170.5,183.9 170.23,184.17 168.44,184.17 167.6,183.32 v2(165.69,183.32) ; v2(156.87,173.19) 157.8,173.19 158.56,172.43 159.22,172.43 v3(160.3,171.35) 159.87,170.91 RE160.1 158.94,170.89 RE154.2 159.56,169.94 QE13.3
  IN3 w0.104: v2(156.87,173.19) 151.85,173.19 150.96,174.08 150.96,178.46 156.11,183.6 165.41,183.6 v2(165.69,183.32)
PWR_B_7313#: length 6
  TOP w0.112: QE13.4 157.15,169.94 157.26,170.04 157.26,171.79 v1(157.51,172.04) 157.51,172.4 157.14,172.76 156.67,172.76 156.43,173 156.43,173.73 156.15,174.01 UE3.14
PWR_B_EC: length 290.2
  TOP w0.112: QE13.2 158.55,169.29 v2(158.09,169.75) ; v2(301.22,8.19) 301.22,8.55 300.74,9.04 UE5.52
  IN2 w0.104: v2(261.8,84.08) 260.63,85.25 260.63,89.26 261.29,89.92 261.29,90.32 261.11,90.5 261.11,95.03 258.08,98.07 253.45,98.07 252.66,98.86 235.4,98.86 234.91,99.36 211.53,99.36 210.58,100.31 198.84,100.31 197.9,99.38 192.66,99.38 192.13,99.91 188.96,99.91 184.3,104.57 184.3,108.51 180,112.8 180,114.11 168.26,125.86 168.26,139.91 160.46,147.7 160.46,157.48 158.12,159.83 158.12,166.71 158.09,166.74 v2(158.09,169.75)
  BOTTOM w0.112: v2(301.22,8.19) 301.22,9.2 v1(300.63,9.79) 300.46,9.95 294.13,9.95 292.83,8.66 292.83,4.78 291.87,3.83 283.99,3.83 281.84,5.97 281.84,7.7 280.27,9.26 280.27,11.2 277.42,14.05 276.72,15.74 276.72,20.79 269.36,28.15 267.52,28.15 261.86,33.81 261.86,35.99 259.27,38.58 259.27,48.75 259.89,49.37 259.89,52.26 257.95,54.2 257.95,56.64 259.16,57.85 259.16,60.09 258.49,60.76 258.49,63.31 259.47,64.28 259.47,67.19 260.26,67.99 260.26,70.86 260.82,71.42 260.82,73.73 260.91,73.82 260.91,81.56 261.84,82.49 261.84,84.04 v2(261.8,84.08)
PWR_G#: length 43.1
  TOP w0.112: JPWR.6 JPWR.5 171.5,184.01 171.11,184.4 168.34,184.4 167.72,183.78 162.67,183.78 v2(161.19,185.26) ; QE21.3 153.1,168.58 RE155.1 RE156.2 151.48,168.41 v2(151.41,168.48)
  IN3 w0.104: v2(151.41,168.48) 150.5,169.39 150.5,178.65 155.92,184.06 160.8,184.06 161.19,184.45 v2(161.19,185.26)
PWR_G_7313#: length 8.1
  TOP w0.112: v1(154.65,173.42) v2(154.65,173.9) UE3.11 ; QE21.4 v2(154.59,168.58)
  IN4 w0.084: v2(154.59,168.58) 154.29,168.88 154.29,173.54 v2(154.65,173.9)
PWR_LED#: length 74.5
  TOP w0.112: v2(349.76,35.96) 349.34,35.96 v1(349.03,36.28) ; v2(308.43,22.25) 308.4,22.28 UE5.92
  IN3 w0.104: v2(349.76,35.96) 349.76,35.11 349.44,34.8 349.44,33.8 351,32.25 354.01,32.25 354.8,31.46 354.8,24.31 352.48,21.99 350.96,21.99 350.59,21.63 350.59,19.28 344.72,13.4 329.77,13.4 326.54,16.63 315.4,16.63 310.61,21.42 309.26,21.42 v2(308.43,22.25)
  BOTTOM w0.127: QE4.2 v2(349.76,35.96)
PWR_R#: length 44.9
  TOP w0.112: JPWR.4 JPWR.3 172.5,184.14 172,184.64 168.24,184.64 167.73,184.14 163.24,184.14 v2(162.61,184.76) ; RE157.1 156.43,170.52 156.3,170.39 154.8,170.39 154.13,171.06 153.73,171.06 153.71,171.08 QE22.3 152.42,171.08 RE158.2 v2(152.16,170.19)
  IN3 w0.104: v2(162.61,184.76) 161.69,183.83 156.01,183.83 150.73,178.55 150.73,171.61 v2(152.16,170.19)
PWR_R_7313#: length 4.9
  TOP w0.112: UE3.10 154.15,174.33 v1(153.32,173.51) 153.32,173 154.46,171.85 154.46,171.22 154.6,171.08 QE22.4
PWR_R_EC: length 297.1
  TOP w0.112: v2(303.07,8.52) 303.07,8.7 302.74,9.03 UE5.57 ; QE22.2 153.64,171.73 v2(153.89,171.47)
  IN2 w0.104: v2(153.89,171.47) 153.89,170.03 157.66,166.27 157.66,159.63 160,157.29 160,147.51 167.79,139.72 167.79,125.67 179.54,113.92 179.54,112.61 183.84,108.31 183.84,104.38 189.2,99.02 197.87,99.02 198.93,100.08 210.48,100.08 211.44,99.13 234.81,99.13 235.31,98.63 252.56,98.63 253.36,97.83 257.98,97.83 260.88,94.93 v2(260.88,90.1)
  BOTTOM w0.112: v2(260.88,90.1) 260.35,90.1 259.39,89.14 259.39,85.01 255.97,81.59 255.97,53.48 257.96,51.49 257.96,50.17 257.36,49.57 257.36,37.74 259.83,35.28 259.83,33.14 265.05,27.91 265.05,23.98 267.43,21.6 272.15,21.6 274.81,18.94 274.81,15.35 275.85,12.85 275.85,10.58 277.64,8.79 277.64,8.7 279.79,6.56 279.79,5.67 283.49,1.96 292.38,1.96 296.66,6.24 v1(299.56,6.24) 302.54,6.24 303.48,7.18 303.48,8.11 v2(303.07,8.52)
PWRSHARE_EN_EC#: length 291.1
  TOP w0.112: v2(300.19,7.9) 300.19,8.72 299.94,8.97 UE5.50 ; UU1.5 36.18,17.95 36.29,18.06 38.56,18.06 38.7,18.2 39.45,18.2 40.23,17.42 40.81,17.42 41.05,17.18 41.05,15.59 v1(41.49,15.14) 41.49,11.77 v2(38.83,9.1)
  IN3 w0.104: v2(38.83,9.1) 39.59,8.34 45.77,8.34 45.83,8.28 58.52,8.28 61.68,5.12 94.07,5.12 97.07,8.12 97.89,8.12 97.9,8.11 97.98,8.12 108.12,8.12 110.71,5.53 111.12,5.12 118.44,5.12 120.57,2.99 125.43,2.99 125.66,3.22 165.07,3.22 167.07,1.22 186.77,1.22 187.44,1.89 188.25,1.89 188.92,1.22 194.83,1.22 196.83,3.22 218.12,3.22 219.18,2.16 222.42,2.16 223.48,3.22 240.81,3.22 242.81,1.22 243.38,1.22 243.39,1.22 275.94,1.22 277.09,2.38 292.58,2.38 297,6.8 299.92,6.8 300.19,7.07 v2(300.19,7.9)
QPCP_CHG: length 2
  TOP w0.203: PC750.1 205.76,136.72 206.43,137.39 PU703.27
REF_ISL95338_1: length 1.7
  BOTTOM w0.203: PUS1.29 128.72,145.08 129.1,144.71 PCS28.1
REF_ISL95338_2: length 3.2
  BOTTOM w0.112: PCS57.1 152.37,142.2 v1(153.26,141.3)
  BOTTOM w0.203: PUS2.29 151.05,142.57 151.42,142.2 PCS57.1
REFCLK_CNV: length 41.8
  TOP w0.112: v2(309.14,54.38) 309.66,54.38 v1(309.78,54.51) 325.82,54.51 326.79,53.53 333.34,53.53 333.63,53.24 335.24,53.24 336.07,52.41 336.07,51.43 336.76,50.74 338.07,50.74 338.98,51.65 339.45,51.65 339.91,51.18 RN113.2
  BOTTOM w0.112: RN117.2 302.26,52.83 303.42,53.99 308.75,53.99 v2(309.14,54.38)
REFCLK_CNV_H: length 15.3
  TOP w0.089: UH1.R6 289.83,48.03 v2(289.67,47.87)
  BOTTOM w0.112: RN117.1 301.83,52.25 301.48,51.9 300.36,51.9 300.18,52.08 RH628.2 299.63,51.97 297.52,51.97 296.71,51.15 295.88,51.15 295.43,50.7 295.18,50.7 293.85,49.36 290.89,49.36 v1(290.34,48.81) 289.67,48.14 v2(289.67,47.87)
REFCLK_CNV_R: length 6.6
  TOP w0.112: RN113.1 339.85,50.59 v2(339.29,51.15)
  BOTTOM w0.112: JWLAN.64 336.45,48.6 339.01,51.15 v2(339.29,51.15)
REMOTE1+: length 135.9
  IN4 w0.254: v2(117.79,86.1) 117.77,86.09 117.77,85.73 117.88,85.62 118.01,85.62 118.26,85.88 120.36,85.88 133.04,98.55 143.85,98.55 146.8,95.6 150.12,95.6 155.67,101.15 161.04,101.15 163.88,103.99 164.82,103.99 168.09,107.26 169.93,107.26 173.71,111.05 181.11,111.05 185.13,107.02 194.69,107.02 195.16,106.55 202.34,106.55 202.94,107.15 211.96,107.15 212.55,106.55 219.48,106.55 220.12,107.19 224.56,107.19 224.81,107.44 224.81,107.71 v2(224.71,107.81)
  BOTTOM w0.254: U2407.2 223.73,106.7 224.01,106.98 C2502.1 224.79,107.19 224.79,107.74 v2(224.71,107.81) ; Q2407.2 116.12,80.92 116.12,81.86 Q2407.1 116.45,82.19 116.87,82.19 117.51,81.54 C2500.1 118.18,81.54 118.58,81.95 118.58,82.95 v1(117.76,83.78) 117.69,83.85 117.69,86 v2(117.79,86.1)
REMOTE1-: length 135.5
  IN4 w0.254: v2(117.21,86.1) 117.25,86.07 117.25,85.72 117.72,85.24 118.17,85.24 118.42,85.49 120.52,85.49 133.2,98.17 143.69,98.17 146.64,95.22 150.28,95.22 155.83,100.77 161.19,100.77 164.04,103.61 164.98,103.61 168.25,106.88 170.08,106.88 173.87,110.67 180.95,110.67 184.98,106.64 194.53,106.64 195,106.17 202.5,106.17 203.1,106.77 211.8,106.77 212.39,106.17 219.64,106.17 220.27,106.8 224.72,106.8 225.2,107.28 225.2,107.71 v2(225.3,107.81)
  BOTTOM w0.254: Q2407.3 115.47,80.27 115.47,82.49 115.8,82.81 117.13,82.81 117.49,82.46 C2500.2 117.82,83.15 117.31,83.65 117.31,86 v2(117.21,86.1) ; R412.1 225.53,106.96 C2502.2 225.3,107.19 v2(225.3,107.81)
REMOTE2+: length 105.7
  IN1 w0.254: v2(176.65,134.84) 176.74,134.76 176.74,134.11 176.46,133.83 174.47,133.83 172.69,132.05 172.69,128.82 173.13,128.39 173.13,126.1 173.82,125.4 173.82,110.01 171.54,107.72 168.05,107.72 167.41,107.08 167.41,106.41 167.89,105.93 168.34,105.93 v2(168.45,105.81)
  IN4 w0.254: v2(224.87,104.1) 224.63,104.34 224.15,104.34 223.57,103.76 218.9,103.76 217.42,105.24 214.96,105.24 213.95,104.23 212.55,104.23 210.91,105.88 204.24,105.88 202.98,104.62 189.22,104.62 188.72,105.12 184.74,105.12 180.49,109.37 174.27,109.37 170.81,105.92 168.55,105.92 v2(168.45,105.81)
  BOTTOM w0.254: C2510.1 224.73,103.96 v2(224.87,104.1) 224.87,104.8 223.97,105.7 U2407.4 ; v2(176.65,134.84) 176.67,134.86 JDGFF1.G3
REMOTE2-: length 109.1
  IN1 w0.254: v2(177.25,134.85) 177.12,134.73 177.12,133.95 176.62,133.45 174.63,133.45 173.08,131.89 173.08,128.98 173.51,128.55 173.51,126.26 174.21,125.56 174.21,109.85 171.7,107.34 168.2,107.34 167.79,106.92 167.79,106.56 168.04,106.31 168.36,106.31 v2(168.45,106.4)
  IN4 w0.254: v2(225.45,104.1) 225.45,104.23 224.96,104.72 223.99,104.72 223.41,104.14 219.06,104.14 217.58,105.62 214.8,105.62 213.79,104.61 212.71,104.61 211.07,106.26 204.08,106.26 202.83,105 189.37,105 188.87,105.5 184.9,105.5 180.65,109.75 174.11,109.75 170.66,106.3 168.55,106.3 v2(168.45,106.4)
  BOTTOM w0.254: C2510.2 222.91,103.4 225.12,103.4 225.45,103.74 225.45,104.1 v2(225.45,104.1) 225.45,104.95 224.61,105.79 R412.2 224.48,106.2 U2407.3 ; v2(177.25,134.85) 177.27,134.88 JDGFF1.G2
REMOTE3+: length 232.5
  IN4 w0.254: v2(368.96,19.85) 368.9,19.91 367.35,19.91 366.75,19.31 354.04,19.31 353.51,19.84 349.79,19.84 349.03,20.6 337.47,20.6 337.23,20.36 334.76,20.36 333.35,21.77 329.42,21.77 326.74,19.09 324.85,19.09 322.37,16.62 320.07,16.62 319.53,16.08 310.66,16.08 309.18,17.55 307.06,17.55 306.32,16.81 303.63,16.81 300.72,19.72 300.72,21.94 299.05,23.61 299.05,25.51 297.59,26.97 297.59,27.25 297.23,27.6 297.23,31.54 298.52,32.83 298.52,42.14 303.92,47.54 303.92,56.22 301.39,58.75 301.39,68.32 296.59,73.12 296.59,75.63 267.86,104.35 249.33,104.35 248.16,105.52 226.7,105.52 226.36,105.87 224.41,105.87 223.27,104.72 221.54,104.72 v2(221.44,104.62)
  BOTTOM w0.254: Q2411.1 369.84,16.93 Q2411.2 370.08,18.12 C2511.1 369.84,18.97 v2(368.96,19.85) ; U2407.5 221.76,105.2 221.44,104.87 v2(221.44,104.62) 221.49,104.57 C5361.1
REMOTE3-: length 231.9
  IN4 w0.254: v2(369.6,20.15) 369.35,20.41 367.31,20.41 366.59,19.69 354.19,19.69 353.67,20.22 349.95,20.22 349.73,20.43 349.73,20.43 349.18,20.98 337.31,20.98 337.08,20.74 334.91,20.74 333.5,22.15 329.26,22.15 326.58,19.47 324.69,19.47 322.21,17 319.91,17 319.37,16.46 310.81,16.46 309.34,17.93 306.9,17.93 306.17,17.19 303.78,17.19 301.1,19.87 301.1,22.1 299.43,23.77 299.43,25.67 297.97,27.13 297.97,27.4 297.61,27.76 297.61,31.39 298.9,32.67 298.9,41.99 304.3,47.39 304.3,56.38 301.77,58.91 301.77,68.48 296.97,73.28 296.97,75.79 268.02,104.73 249.49,104.73 248.32,105.91 226.86,105.91 226.52,106.25 224.26,106.25 223.11,105.1 221.12,105.1 v2(220.64,104.62)
  BOTTOM w0.254: Q2411.3 370.99,18.02 C2511.2 370.99,19.08 369.92,20.15 v2(369.6,20.15) ; v2(220.64,104.62) 220.57,104.56 C5361.2 219.79,103.99 R185.2
REMOTE4+: length 104.5
  BOTTOM w0.112: C2532.1 17.97,12.08 Q2412.2 17.89,11.05 Q2412.1 18.54,10.69 18.81,10.96 18.95,11.02 19.1,10.97 21.86,8.21 60.26,8.21 63.12,5.36 64.46,5.36 64.69,5.12 94.28,5.12 97.28,8.12 110.89,8.12 111,8.24 v4(111.6,8.24) 113.3,8.24 C2533.1 113.97,8.23 114.16,8.23 114.46,7.93 U2408.2
REMOTE4-: length 102.6
  BOTTOM w0.112: C2532.2 18.89,12.3 Q2412.3 18.96,11.76 18.96,11.39 19.03,11.25 19.23,11.18 21.96,8.45 60.36,8.45 63.2,5.61 v4(64.16,5.61) 64.55,5.61 64.79,5.36 94.18,5.36 97.18,8.36 110.79,8.36 110.9,8.47 111.38,8.47 111.38,8.48 111.82,8.48 111.82,8.47 113.3,8.47 C2533.2 113.98,8.47 114.35,8.47 114.46,8.58 U2408.3
RESET_N: length 3
  BOTTOM w0.076: UT4.F11 47.37,47.07
  BOTTOM w0.127: 47.37,47.07 47.71,47.07 v1(47.97,47.33) 48.16,47.33 48.71,46.78 RT102.1
RF_+1VALWP: length 4.4
  TOP w0.112: v1(261.97,4.47) 261.32,5.12 PR106.1
  TOP w0.254: PU101.5 262.03,7.84 261.74,7.55 261.74,6.53 261.32,6.12 PR106.1
RJ45_CT: length 10
  TOP w0.508: CL10.2 v2(196.41,178.13)
  BOTTOM w0.508: v2(196.41,178.13) 196.36,178.08 v1(196.36,175.92) 196.36,174.65 196.87,174.14 RL15.2 197.22,174.14 197.81,173.56 RL16.2 199.31,173.56 199.48,173.38 RL17.2 200.14,173.38 200.19,173.33 RL18.2
RJ45_CT0: length 11.4
  TOP w0.508: UL2.15 v2(209.64,176.65)
  BOTTOM w0.508: v2(209.64,176.65) 206.05,173.06 v1(203.04,173.06) 202.29,173.06 RL18.1
RJ45_CT1: length 8.6
  TOP w0.508: 205.83,178.8 v2(205.83,176.98)
  BOTTOM w0.508: RL17.1 v1(201.08,174.29) 203.14,174.29 v2(205.83,176.98)
RJ45_CT2: length 6.3
  TOP w0.508: UL2.21 v2(202.02,177.09)
  BOTTOM w0.508: RL16.1 201.11,177.09 v2(202.02,177.09)
RJ45_CT3: length 4.2
  TOP w0.508: UL2.24 v2(198.21,176.78)
  BOTTOM w0.508: v2(198.21,176.78) 198.21,176.05 197.22,175.05 RL15.1
RJ45_MDIN0: length 9.4
  TOP w0.203: v2(199.39,180.62) 199.53,180.62 199.8,180.35 199.8,179.87 199.48,179.55 UL2.23
  IN1 w0.203: v2(199.39,180.62) 199.47,180.7 200.08,180.7 203.05,183.68 JLAN.2
RJ45_MDIN1: length 11.3
  TOP w0.203: UL2.20 203.29,179.75 203.85,180.31 203.85,181.09 203.65,181.29 202.87,181.29 v2(202.77,181.19)
  IN1 w0.203: v2(202.77,181.19) 202.9,181.32 204.7,181.32 206.65,183.27 206.65,183.77 207.13,184.25 JLAN.6
RJ45_MDIN2: length 10.2
  TOP w0.203: v2(206.43,180.84) 206.59,180.99 207.63,180.99 207.83,180.79 207.83,180.62 207.64,180.43 207.23,180.43 207.1,180.3 UL2.17
  IN4 w0.203: v2(206.43,180.84) 206.59,180.99 207,180.99 207.44,181.44 207.44,182.06 205.33,184.17 205.33,184.47 205.69,184.84 JLAN.5
RJ45_MDIN3: length 9.3
  TOP w0.203: v2(211.51,181.89) 211.51,181.7 211.2,181.38 211.2,180.27 210.91,179.98 210.91,178.8
  IN1 w0.203: JLAN.8 209.17,184.39 209.34,184.22 209.34,182.57 210.1,181.81 211.43,181.81 v2(211.51,181.89)
RJ45_MDIP0: length 9.4
  TOP w0.203: 200.75,178.8 200.75,179.58 200.21,180.12 200.21,180.52 199.41,181.32 v2(199.41,181.4)
  IN1 w0.203: JLAN.1 202.15,184.96 202.44,184.96 202.64,184.76 202.64,183.84 199.91,181.11 199.61,181.11 199.41,181.31 v2(199.41,181.4)
RJ45_MDIP1: length 11.3
  TOP w0.203: v2(202.77,181.77) 202.85,181.7 203.82,181.7 v1(204.26,181.26) 204.26,180.31 204.56,180.01 UL2.19
  IN1 w0.203: JLAN.3 205.11,183.79 206.04,183.79 206.24,183.59 206.24,183.43 204.53,181.72 202.82,181.72 v2(202.77,181.77)
RJ45_MDIP2: length 10.2
  TOP w0.203: UL2.16 208.37,180.22 208.24,180.35 208.24,180.96 207.8,181.4 206.46,181.4 v2(206.43,181.43)
  IN4 w0.203: JLAN.4 205.09,184.81 204.92,184.64 204.92,184 207.03,181.89 207.03,181.6 206.83,181.4 206.46,181.4 v2(206.43,181.43)
RJ45_MDIP3: length 9.3
  TOP w0.203: v2(211.93,181.48) 211.87,181.48 211.6,181.22 211.6,180.5 212.18,179.92 UL2.13
  IN1 w0.203: v2(211.93,181.48) 211.89,181.48 211.82,181.4 209.94,181.4 208.94,182.4 208.94,184.05 JLAN.7
RPD_G1: length 4.4
  BOTTOM w0.076: UT4.K9 45.29,49.2 45.54,49.46 45.54,49.83 45.54,49.83 45.54,49.88 45.57,49.9 45.57,49.91 45.75,50.09 45.75,50.09 45.8,50.14 45.8,50.19 46.06,50.44 46.32,50.44 v1(46.96,51.08) 47.39,51.51
  BOTTOM w0.112: 47.39,51.51 47.43,51.55 47.43,51.58 47.47,51.62 RT64.1
RPD_G2: length 4.8
  BOTTOM w0.076: UT4.K10 45.79,49.2 46.05,49.46 46.05,49.67 46.19,49.81 46.59,49.81 47.5,50.72
  BOTTOM w0.127: 47.5,50.72 47.58,50.72 v1(48.43,51.57) 48.86,52 RT65.1
RSVD8: length 12.1
  TOP w0.102: 167.04,85.38 164.71,83.05 v2(164.71,83.04)
  TOP w0.112: TC17.1 174.15,86.07 167.73,86.07 167.04,85.38
  BOTTOM w0.102: UC1.AV1 v2(164.71,83.04)
RSVD9: length 11.1
  TOP w0.102: 169.32,84.99 166.51,82.18 v2(165.6,82.18)
  TOP w0.112: TC18.1 169.57,85.24 169.32,84.99
  BOTTOM w0.102: UC1.AW2 165.6,82.1 v2(165.6,82.18)
RSVD20: length 4.2
  TOP w0.102: v2(138.2,73.89) 139.48,72.6 140.49,72.6 TC19.1
  BOTTOM w0.102: UC1.K10 138.69,74.38 v2(138.2,73.89)
RSVD24: length 1.2
  TOP w0.102: v2(139.21,73.96) 139.21,73.83 TC14.1
  BOTTOM w0.102: UC1.L10 139.61,74.36 v2(139.21,73.96)
RSVD_TP1: length 2.1
  TOP w0.102: TC15.1 138.7,76.22 v2(138.22,76.7)
  BOTTOM w0.102: UC1.J7 v2(138.22,76.7)
RSVD_TP2: length 5.5
  TOP w0.102: TC16.1 139.16,72.03 137.76,73.43 137.76,75.22 v2(137.26,75.71)
  BOTTOM w0.102: UC1.J8 v2(137.26,75.71)
RSVD_TP3: length 1.8
  TOP w0.102: TC12.1 139.89,75.08 v2(139.17,75.79)
  BOTTOM w0.102: v2(139.17,75.79) 138.74,76.23 UC1.K8
RTC_CELL: length 5.9
  TOP w0.112: UE10.22 246.22,6 RE662.1 245.8,5.41 v1(244.12,5.41) 242.41,5.41 QE58.2
RTD3_CIO_PWR_EN: length 359.4
  TOP w0.089: UH1.BF21 282.45,63.61 282.45,64.41 282.35,64.51 282.35,67.08 v2(282.81,67.54)
  TOP w0.112: RT16.2 20.48,51.01 v2(20.48,51.14)
  IN2 w0.104: v2(33.93,33.07) 33.88,33.07 33.65,33.3 25.73,33.3 24.63,32.2 19.34,32.2 17.27,34.26 17.27,36.21 17.14,36.34 v2(17.14,36.42) ; v2(15.73,48.93) 15.73,48.98 17.96,51.2 20.41,51.2 v2(20.48,51.14)
  IN3 w0.104: v2(282.81,67.54) 282.4,67.54 281.55,68.38 276.55,68.38 275.84,69.1 269.81,69.1 269.04,68.33 267.9,68.33 266.71,69.52 260.52,69.52 260.07,69.97 259.31,69.97 259.13,70.15 v2(259.1,70.15) ; v2(15.73,48.93) 15.75,48.92 17.15,48.92 17.4,48.67 17.4,40.48 18.01,39.88 18.01,37.41 17.14,36.55 v2(17.14,36.42)
  IN4 w0.084: v2(259.1,70.15) 255.58,66.63 254.28,66.63 253.72,66.06 253.72,26.65 249.91,22.84 243.89,22.84 239.54,18.49 187.8,18.49 180.74,11.43 168.95,11.43 168.75,11.23 144.27,11.23 143.43,12.07 141.48,12.07 141.04,12.52 130.94,12.52 130.77,12.68 124.78,12.68 123.55,13.9 123.55,14.44 122.79,15.2 118.2,15.2 117.82,14.82 113.23,14.82 109.92,18.13 109.8,18.25 108.44,18.25 108.29,18.1 100.65,18.1 99.14,19.6 98.97,19.6 91.59,19.6 91.49,19.69 91.28,19.91 87.66,19.91 87.36,19.6 62.88,19.6 59.39,23.1 58.79,23.1 56.9,24.99 56.9,27.24 54.74,29.4 54.74,31.25 54.45,31.55 54.45,32.51 54.23,32.72 54.11,32.72 52.61,32.72 52.19,32.3 49.8,32.3 48.44,30.94 44.33,30.94 43.78,30.39 41.32,30.39 40.36,31.35 34.21,31.35 33.93,31.63 33.93,33.05 33.93,33.06 v2(33.93,33.07)
RTD3_CIO_PWR_EN_R: length 4.7
  TOP w0.076: RT16.1 RT36.2 21.49,49.85 22.22,49.12 v2(22.22,48.99) v1(22.22,48.47)
  BOTTOM w0.076: UT1.F1 21.79,48.18 21.89,48.28 21.89,48.66 22.17,48.94
  BOTTOM w0.112: 22.17,48.94 v2(22.22,48.99) 22.22,49.35 21.94,49.64 RT726.1
RTD3_USB_PWR_EN: length 350.9
  TOP w0.089: UH1.BE21 282.44,63.22 282.65,63.42 282.65,64.48 282.54,64.59 282.54,66.62 v2(282.85,66.93)
  TOP w0.112: v2(15.67,46.61) 15.87,46.61 v1(16.22,46.96) 16.23,46.95 16.8,46.95 16.9,46.85 RT12.2
  IN2 w0.104: v2(16.53,36.22) 16.69,36.22 17.04,35.86 17.04,34.16 19.24,31.96 24.73,31.96 25.83,33.07 33.19,33.07 v2(33.38,32.88)
  IN3 w0.104: v2(16.53,36.22) 16.53,36.32 15.72,37.13 15.72,41.98 15.06,42.64 15.06,46 v2(15.67,46.61) ; v2(259.23,69.46) 259.52,69.74 259.97,69.74 260.42,69.29 266.61,69.29 267.8,68.1 269.14,68.1 269.91,68.87 275.74,68.87 276.45,68.15 281.42,68.15 282.64,66.93 v2(282.85,66.93)
  IN4 w0.084: v2(259.23,69.46) 258.71,69.46 255.67,66.42 254.37,66.42 253.93,65.97 253.93,26.56 250,22.63 243.97,22.63 239.63,18.28 187.89,18.28 180.83,11.22 169.04,11.22 168.84,11.02 144.18,11.02 143.34,11.86 141.39,11.86 140.95,12.31 130.85,12.31 130.68,12.47 124.69,12.47 123.49,13.67 123.41,13.75 118.63,13.75 117.77,14.61 113.14,14.61 109.71,18.04 108.53,18.04 108.46,17.98 108.38,17.89 100.56,17.89 99.06,19.39 91.5,19.39 91.4,19.48 91.19,19.69 87.75,19.69 87.44,19.39 62.97,19.39 62.8,19.39 59.3,22.88 58.7,22.88 56.69,24.9 56.69,27.16 54.53,29.31 54.53,31.16 54.23,31.46 54.23,32.3 54.02,32.51 52.7,32.51 52.28,32.09 49.89,32.09 48.53,30.73 44.41,30.73 43.86,30.18 41.23,30.18 40.28,31.14 34.13,31.14 33.72,31.54 33.72,32.54 33.38,32.88 v2(33.38,32.88)
RTD3_USB_PWR_EN_R: length 10.4
  TOP w0.112: v2(16.09,44.62) v1(17.17,44.62) 17.35,44.8 RT37.1 17.48,45.89 RT12.1
  IN2 w0.104: v2(20.97,46.47) 20.5,46.94 18.06,46.94 17.65,46.53 17.65,45.01 17.37,44.73 16.24,44.73 16.13,44.62 v2(16.09,44.62)
  BOTTOM w0.102: UT1.D4 v2(20.97,46.47)
RTN_VCCSA: length 4.7
  BOTTOM w0.112: PRA11.2 126.23,113.65 125.95,113.37 v1(124.43,113.37)
  BOTTOM w0.254: PRA11.2 126.23,114.87 PRA10.1 126.67,114.88 126.99,115.21 PUA01.1
SA0_DIM1: length 10
  TOP w0.112: v1(255.68,86.48) v2(256.2,86.48) RD1.1 RD4.2
  IN3 w0.104: v2(255.12,92.56) 255.74,91.93 255.74,86.61 255.87,86.48 v2(256.2,86.48)
  BOTTOM w0.127: v2(255.12,92.56) 255.09,92.53 253.8,92.53 JDIMM1.256
SA0_DIM2: length 4.4
  TOP w0.112: v2(241.34,93.33) v1(241.34,92.85)
  TOP w0.127: RD12.1 RD15.2 240.77,93.64 241.06,93.34 241.37,93.34 241.37,93.34 241.36,93.34 241.36,93.33 v2(241.34,93.33)
  BOTTOM w0.127: v2(241.34,93.33) 241.34,93.32 241.34,93.02 240.85,92.53 JDIMM3.256
SA0_DIM3: length 5.8
  TOP w0.112: v1(225.52,92.16) 224.97,92.71 RD26.1
  TOP w0.127: RD29.2 RD26.1 224.99,93.18 224.99,93.57 v2(224.71,93.84)
  BOTTOM w0.127: v2(224.71,93.84) 224.71,93.5 225.69,92.53 JDIMM2.256
SA0_DIM4: length 5.9
  TOP w0.112: RD38.1 v1(216.69,92.35)
  TOP w0.127: RD38.1 RD41.2 215.92,93.65 v2(215.57,94.01)
  BOTTOM w0.127: v2(215.57,94.01) 214.08,92.53 JDIMM4.256
SA1_DIM1: length 10.4
  TOP w0.112: RD5.2 RD2.1 v2(256.18,87.25)
  IN3 w0.104: v2(256.18,87.25) 256.18,92.53 255.93,92.78 v2(255.93,93.88)
  BOTTOM w0.127: JDIMM1.260 255.05,93.53 255.4,93.88 v2(255.93,93.88)
SA1_DIM2: length 7.4
  TOP w0.112: v1(240.77,97.93) v2(240.77,97.42)
  TOP w0.127: RD13.1 RD16.2 v2(240.77,97.42)
  BOTTOM w0.112: JDIMM3.260 240.79,93.53 241.01,93.75 241.01,97.17 v2(240.77,97.42)
SA1_DIM3: length 4.9
  TOP w0.112: RD27.1 224.17,94.59 223.42,95.34 223.42,95.53 v1(223.23,95.72)
  TOP w0.127: RD27.1 RD30.2 225.3,94.28 v2(225.3,93.85)
  BOTTOM w0.127: JDIMM2.260 225.62,93.53 v2(225.3,93.85)
SA1_DIM4: length 5
  TOP w0.112: v2(214.83,94.01) 214.09,93.27 v1(214.09,93.18)
  TOP w0.127: v2(214.83,94.01) 215.29,94.47 RD42.2 RD39.1
  BOTTOM w0.127: JDIMM4.260 214.35,93.53 v2(214.83,94.01)
SA2_DIM1: length 3.9
  TOP w0.112: RD6.2 v1(255.85,71.57)
  TOP w0.127: RD6.2 RD3.1 255.32,69.87 v2(255.04,70.15)
  BOTTOM w0.127: JDIMM1.166 254.91,70.03 v2(255.04,70.15)
SA2_DIM2: length 6.2
  TOP w0.112: RD17.2 v1(243.08,70.91)
  TOP w0.127: RD14.1 242.2,72.12 v2(242.2,71.58) 242.04,71.41 RD17.2
  BOTTOM w0.112: JDIMM3.166 241.02,70.03 242.16,71.17 242.16,71.54 v2(242.2,71.58)
SA2_DIM3: length 4
  TOP w0.112: RD28.1 RD31.2 225.99,69.3 v1(225.59,69.71) 225.32,69.98 v2(225.32,70.11)
  BOTTOM w0.112: JDIMM2.166 225.4,70.03 v2(225.32,70.11)
SA2_DIM4: length 4.1
  TOP w0.112: v1(215.29,71.91) 215.09,71.7 RD40.1
  TOP w0.127: RD40.1 214.27,70.81 RD43.2 214.25,70.11 v2(214.27,70.08)
  BOTTOM w0.127: v2(214.27,70.08) 214.22,70.03 JDIMM4.166
SA_DIMM_VREFDQ: length 25.3
  BOTTOM w0.102: UC1.AC40 151.49,44.53 151.02,44.05 151.02,38.79
  BOTTOM w0.127: TC7.1 161.01,28.8 151.02,38.79
SATA_GP0: length 70.7
  TOP w0.089: UH1.AH41 272.62,55.23 v2(272.44,55.41)
  TOP w0.112: v2(255.5,12.98) 255.5,12.98 256.51,13.98 v1(256.51,14.37) 256.51,15.11 RS2.1
  IN3 w0.104: v2(272.44,55.41) 272.29,55.25 267.75,55.25 267.36,55.65 265.71,55.65 264.38,54.32 261.02,54.32 259.16,52.46 256.93,52.46 256.18,51.71 256.18,49.15 v2(256.2,49.13)
  BOTTOM w0.112: v2(256.2,49.13) 256.39,48.94 256.39,36.92 257.28,36.03 257.28,27.45 254.88,25.05 254.88,13.84 255.5,13.22 v2(255.5,12.98) 255.09,12.57 255.09,9.42 258.05,6.46 JHDD.9
SATA_GP1: length 192.5
  TOP w0.089: UH1.AJ43 272.22,54.8 272.22,53.15 271.55,52.47 267.03,52.47 v2(266.77,52.73)
  IN3 w0.104: v2(256.81,13.47) 256.92,13.36 260.7,13.36 268.53,21.18 282.38,21.18 288.07,15.49 291.68,15.49 292.1,15.91 294.54,15.91 295.32,15.12 297.52,15.12 297.97,15.57 297.97,16.28 298.59,16.89 307.93,16.89 308.21,17.17 309.46,17.17 310.87,15.76 326.43,15.76 329.48,12.71 345,12.71 351.19,18.9 351.6,18.9 355.58,22.88 365.47,22.88 v2(366.23,23.64)
  IN4 w0.127: v2(258.42,31.27) 258.36,31.32 258.36,46.82 264.31,52.77 265.45,52.77 265.49,52.73 v2(266.77,52.73)
  BOTTOM w0.112: JSSD2.69 370.95,12.68 371.55,13.28 R365.1 370.17,14.69 368.18,16.69 368.18,20.74 v1(367.47,21.45) 366.23,22.69 v2(366.23,23.64) ; v2(258.42,31.27) 258.72,30.96 258.72,27.88 256.6,25.76 256.6,23.83 255.59,22.82 255.59,14.69 v2(256.81,13.47)
SATA_GP4: length 159
  TOP w0.089: v2(267.55,56.66) 267.93,56.28 268.28,56.28 268.39,56.39 269.7,56.39 270.07,56.77 UH1.AM46
  IN3 w0.104: v2(348.58,25.74) 348.51,25.68 348.51,24.63 349.12,24.03 349.12,21.1 347.82,19.81 338.93,19.81 337.65,21.08 337.65,22.34 336.79,23.21 334.01,23.21 331.34,20.54 329.25,20.54 328.16,19.45 324.08,19.45 322.41,17.79 315.88,17.79 311.09,22.57 310.48,22.57 309.56,23.49 309.56,23.54 308.91,24.19 306.87,24.19 304.5,26.55 303.47,26.55 302.09,27.94 301.05,27.94 300.21,28.77 298.32,28.77 297.52,29.57 296.1,29.57 295.2,30.47 295.2,30.75 292.77,33.18 291.2,33.18 287.71,36.66 287.71,38.24 287.63,38.32 287.63,40.1 285.05,42.68 285.05,43.99 284.39,44.65 284.39,45.27 285.05,45.93 285.05,49.14 285.88,49.98 285.88,50.56 286.34,51.02 286.34,52.81 286.97,53.44 286.97,54.41 286.13,55.25 286.13,55.74 286.45,56.05 286.45,59.23 285.52,60.16 285.52,60.44 285.08,60.88 284.75,60.88 284.01,60.14 282.86,60.14 282.14,59.42 282.14,59.23 281.83,58.92 281.24,58.92 281.14,58.82 281.14,57.17 279.87,55.9 273.13,55.9 272.45,56.58 269.81,56.58 269.22,55.99 268.22,55.99 v2(267.55,56.66)
  BOTTOM w0.112: v2(348.58,25.74) 349.34,26.51 v1(349.34,27.52) 349.34,29.23 349.82,29.71 363.47,29.71 366.44,26.74 R363.1 365.23,24.41 365.21,24.4 JSSD1.69
SATA_PRX_C_DTX_N0: length 44.2
  TOP w0.089: v2(266.42,36.17) 266.62,35.96 267.17,35.96 267.26,35.88 267.76,35.88 267.93,36.05 267.93,36.17 CH229.1
  IN4 w0.084: v2(262.36,6.63) 262.16,6.84 262.04,6.84 260.93,5.74 258.84,5.74 255.99,8.59 255.99,12.01 265.58,21.6 265.58,35.78 265.76,35.96 266.22,35.96 v2(266.42,36.17)
  BOTTOM w0.112: JHDD.1 262.05,6.29 261.81,6.53 261.81,6.7 261.95,6.85 262.15,6.85 v2(262.36,6.63)
SATA_PRX_C_DTX_P0: length 44.2
  TOP w0.089: CH230.1 268.11,36.14 268.11,35.98 267.83,35.7 267.19,35.7 267.1,35.79 266.62,35.79 v2(266.42,35.58)
  IN4 w0.084: v2(262.36,7.22) 262.16,7.01 261.97,7.01 260.86,5.91 258.91,5.91 256.16,8.66 256.16,11.94 265.75,21.53 265.75,35.71 265.83,35.8 266.21,35.8 v2(266.42,35.58)
  BOTTOM w0.112: JHDD.2 261.55,6.28 261.59,6.31 261.59,6.8 261.86,7.07 262.22,7.07 v2(262.36,7.22)
SATA_PRX_DTX_N0: length 9
  TOP w0.089: UH1.C45 270.75,42.72 v2(271.02,42.72) ; CH229.2 267.94,37.15 267.94,37.8 v2(267.74,38)
  IN4 w0.084: v2(271.02,42.72) 270.94,42.64 270.2,42.64 269.99,42.43 269.99,41.91 270.43,41.47 270.43,40.29 268.81,38.67 268.18,38.67 267.95,38.44 267.95,38.21 v2(267.74,38)
SATA_PRX_DTX_P0: length 9
  TOP w0.089: v2(270.64,42.06) 270.44,42.27 UH1.C46 ; v2(268.33,38) 268.12,37.8 268.12,37.15 CH230.2
  IN4 w0.084: v2(268.33,38) 268.12,38.21 268.12,38.37 268.25,38.5 268.88,38.5 270.6,40.22 270.6,41.54 270.15,41.98 270.15,42.36 270.27,42.48 270.7,42.48 270.83,42.34 270.83,42.19 270.71,42.06 v2(270.64,42.06)
SATA_PTX_C_DRX_N0: length 45.7
  TOP w0.089: CH227.1 273.1,37.32 273.1,35.94 273.45,35.58 273.45,34.06 272.77,33.37
  TOP w0.112: v2(267.51,34.48) 267.65,34.62 268.3,34.62 269.25,33.67 269.25,33.64 269.76,33.13 v4(271.62,33.13) 272.53,33.13 272.77,33.37
  IN4 w0.084: v2(260.58,6.63) 260.36,6.85 260.36,9.32 257.85,11.83 257.85,12.74 266.38,21.27 266.38,34.49 266.57,34.68 267.31,34.68 v2(267.51,34.48)
  BOTTOM w0.112: JHDD.4 260.55,6.14 260.4,6.29 260.4,6.45 v2(260.58,6.63)
SATA_PTX_C_DRX_P0: length 45.6
  TOP w0.089: CH228.1 272.92,37.32 272.92,35.87 273.28,35.51 273.28,34.13 272.69,33.54 272.62,33.54 272.6,33.52
  TOP w0.112: v2(267.51,35.06) 267.76,34.82 268.39,34.82 v4(269.59,33.61) 269.85,33.35 271.33,33.35 271.34,33.37 271.89,33.37 271.91,33.35 272.44,33.35 272.6,33.52 272.6,33.52
  IN4 w0.084: v2(260,6.63) 260.19,6.82 260.19,9.25 257.68,11.76 257.68,12.81 266.21,21.34 266.21,34.56 266.5,34.85 267.3,34.85 v2(267.51,35.06)
  BOTTOM w0.112: v2(260,6.63) 260.17,6.45 260.17,6.29 260.05,6.17 JHDD.5
SATA_PTX_DRX_N0: length 5.3
  TOP w0.089: CH227.2 273.5,38.31 273.5,38.45 273.4,38.55 273,38.55 272.91,38.64 272.91,39.16 273.28,39.53 273.71,39.53 274.32,40.14 274.32,40.75 274.22,40.85 274.22,41.87 274.21,41.88 274.21,41.88 UH1.B38
SATA_PTX_DRX_P0: length 5.3
  TOP w0.089: CH228.2 v4(272.72,38.95) 272.72,39.22 273.21,39.71 273.64,39.71 274.14,40.21 274.14,40.67 274.04,40.77 274.04,41.8 274.04,41.8 274.04,42.24 UH1.C38
SCL_CHG: length 1.6
  TOP w0.203: PR770.2 210.44,139.77 209.09,139.77 PU703.4
SCL_ISL95338_1: length 4.6
  TOP w0.112: PRS14.2 129.19,148.8 v1(129.57,149.18)
  TOP w0.254: v2(127.15,148.13) 127.3,148.28 128.35,148.28 128.6,148.54 PRS14.2
  BOTTOM w0.203: PRS12.2 127.28,148.26 v2(127.15,148.13) 126.79,147.77 PUS1.22
SCL_ISL95338_2: length 4.4
  TOP w0.112: PRS34.2 v3(151.85,146.33)
  TOP w0.254: PRS34.2 150.72,146.22 150.17,145.67 149.61,145.67 v2(149.57,145.63)
  BOTTOM w0.203: PUS2.22 149.17,145.23 v2(149.57,145.63) 149.57,146.2 PRS32.2
SD_RCOMP_1P8: length 7.6
  TOP w0.089: v2(289.91,62.58) 289.96,62.58 290.04,62.66 290.19,62.66 UH1.BE5
  BOTTOM w0.127: v2(289.91,62.58) 290.14,62.58 v1(290.47,62.9) 290.86,63.3 290.86,64.7 291.35,65.2 293.9,65.2 294.51,65.81 RH214.1
SD_RCOMP_3P3: length 5.5
  TOP w0.089: UH1.BE4 290.72,63.24 v2(290.44,63.52)
  BOTTOM w0.112: v2(290.44,63.52) 290.45,63.54 v1(290.45,64.6) 290.45,64.64 291.25,65.44 293.26,65.44 RH215.1
SDA_CHG: length 1.7
  TOP w0.203: PR769.2 210.35,139.38 PU703.3
SDA_ISL95338_1: length 4.6
  TOP w0.112: v1(126.39,146.64) 126.5,146.75 v2(126.5,148.12)
  TOP w0.254: v2(126.5,148.12) 126.72,148.35 126.72,148.38 127.13,148.79 PRS15.2
  BOTTOM w0.203: v2(126.5,148.12) 126.44,148.07 126.44,148.05 126.39,148.01 PUS1.21
  BOTTOM w0.254: v2(126.5,148.12) 126.52,148.14 PRS10.2
SDA_ISL95338_2: length 4.1
  TOP w0.203: v2(149,145.76) 149.59,146.35 PRS35.2
  BOTTOM w0.112: v1(147.67,146.64) 147.95,146.37 PRS30.2
  BOTTOM w0.203: PRS30.2 148.64,146.24 149,145.88 v2(149,145.76) 149,145.57 148.77,145.34 PUS2.21
SENSE_VCCIO: length 7.3
  TOP w0.112: v2(158.55,110.56) v1(161,110.56) 161.8,110.56 v2(162.66,109.7)
  BOTTOM w0.254: v2(162.66,109.7) 163.06,110.1 PRF05.2 163.09,110.51 PRF08.1 ; v2(158.55,110.56) 158.26,110.85 PRF07.1
SET0_VCCSA: length 2.7
  BOTTOM w0.254: PUA01.5 126.37,117.21 PRA05.1 125.18,117.62 PRA09.2
SET1_VCCSA: length 4.1
  BOTTOM w0.112: v1(124.04,118.13) 124.68,118.13 125.04,118.5 PRA09.1
  BOTTOM w0.254: PUA01.6 127.07,117.71 126.45,118.33 PRA12.2 125.31,118.33 PRA09.1
SET2_VCCSA: length 4.5
  BOTTOM w0.112: PRA15.2 v1(125.19,120.23)
  BOTTOM w0.254: PRA15.2 125.94,119.25 PRA12.1 127.16,119.24 127.9,118.51 PUA01.7
SLP_S3: length 6
  TOP w0.127: UE1.12 355.82,40.34 355.69,40.47 354.93,40.47 354.87,40.41 v1(353.91,40.41) 353.91,40.79 354.34,41.22 QE1.3 353.43,41.61 RE15.2
SLP_S5: length 19.3
  TOP w0.127: UE1.11 v2(356.32,40.03)
  BOTTOM w0.112: v2(356.32,40.03) 356.32,39.66 v1(356.87,39.11) 358.26,37.71 358.26,35.03 357.91,34.68 357.91,33.82 357.68,33.58 356.42,33.58 355.78,33.85 355.09,33.85 353.71,35.23 352.34,35.23 352.04,34.93 351.39,34.93 351.18,35.14 351.18,36.19 350.93,36.45
  BOTTOM w0.127: QE4.3 350.41,35.7 350.42,35.71 RE16.2 350.93,36.45
SM_PG_CTRL: length 116.2
  TOP w0.112: v2(197.26,107.53) 198.72,108.99 v1(205.9,108.99) 207.8,108.99 211.47,112.66 214.32,112.66 214.54,112.88 PR211.2 ; RC684.1 172.52,30.35 RC685.1 172.11,30.33 v2(171.88,30.55)
  BOTTOM w0.112: v2(171.88,30.55) 179.23,37.9 179.23,98.29 182.65,101.71 182.65,104.75 185.24,107.34 197.07,107.34 v2(197.26,107.53)
SMBALERT#: length 7.2
  TOP w0.089: RH95.2 281.9,69.15 281.9,66.99 281.55,66.63 v1(281.48,66.63) 281.46,66.61 281.46,66.61 280.78,65.93 280.78,63.3 UH1.BE25
SML0ALERT#: length 8.7
  TOP w0.089: RH1023.2 281.49,69.46 281.07,69.04 v1(281.07,68.35) 281.07,67.96 281.38,67.65 281.38,67.29 v2(281.53,67.14) ; v2(280.72,62.58) 280.9,62.76 280.9,63.07 281.07,63.24 UH1.BF24
  IN2 w0.104: v2(281.53,67.14) 281.68,66.99 281.68,66.78 280.72,65.83 v2(280.72,62.58)
SML0CLK: length 220.8
  TOP w0.089: v2(280.95,67.23) 280.95,67.37 280.86,67.46 280.56,67.46 280.26,67.17 280.26,63.91 280.54,63.64 UH1.BF25
  IN1 w0.084: v2(280.95,67.23) 281.05,67.23 281.36,67.54 281.67,67.54 281.85,67.72 281.85,69.31 281.69,69.48 281.69,71.71 282.04,72.06 282.04,73.04 282.94,73.93 282.94,86.4 263.7,105.64 251.54,105.64 251.13,106.05 235.33,106.05 234.88,106.51 215.93,106.51 215.28,107.16 206.61,107.16 190.72,123.05 182.69,123.05 181.51,124.23 181.51,125.2 181.31,125.39 181.31,126.53 182.95,128.17 182.95,133.73 182.32,134.36 182.32,139.08 182.92,139.68 182.92,142.21 181.15,143.98 181.15,145.67 180.64,146.17 180.64,153.41 177.85,156.2 177.85,157.34 176.07,159.13 174.27,159.13 171.13,162.27 165.45,162.27 164.92,161.74 162.48,161.74 159.67,164.55 159.67,165.32 v2(159.61,165.38)
  BOTTOM w0.112: UM4.11 158.82,173.43 158.71,173.32 158.28,173.32 156.62,171.66 156.62,167.85 158.7,165.77 159.54,165.77 159.65,165.66 159.65,165.42 v2(159.61,165.38)
  BOTTOM w0.127: v2(280.95,67.23) 281.28,67.56 281.75,67.56 282.4,68.21 283.74,68.21 285.44,69.92 285.44,70.33 RH501.2
SML0DATA: length 217.7
  TOP w0.089: v2(283.16,68.63) 283.08,68.55 282.57,68.55 v1(282.36,68.34) 282.14,68.12 282.14,66.87 281,65.73 281,63.82 281.3,63.52 281.3,63.17 281.23,63.1 UH1.BE24
  IN1 w0.084: v2(283.16,68.63) 283.16,68.66 282.76,69.06 282.15,69.67 282.15,71.51 282.51,71.87 282.51,72.85 283.4,73.74 283.4,86.6 263.89,106.1 251.73,106.1 251.32,106.52 235.52,106.52 235.07,106.97 216.12,106.97 215.47,107.62 206.8,107.62 190.91,123.51 182.88,123.51 181.97,124.42 181.97,125.39 181.78,125.59 181.78,126.34 183.41,127.98 183.41,133.92 182.78,134.55 182.78,138.89 183.38,139.49 183.38,142.4 181.62,144.17 181.62,145.86 181.11,146.37 181.11,153.6 178.32,156.39 178.32,157.54 176.26,159.59 174.47,159.59 171.33,162.73 165.25,162.73 164.73,162.2 162.67,162.2 160.13,164.74 160.13,165.32 v2(160.19,165.38)
  BOTTOM w0.112: UM4.10 158.82,172.72 158.71,172.83 158.48,172.83 157.11,171.46 157.11,168.06 158.9,166.27 159.74,166.27 160.14,165.87 160.14,165.42 v2(160.19,165.38)
  BOTTOM w0.127: RH502.2 284.66,70.33 284.66,69.85 283.53,68.72 283.25,68.72 v2(283.16,68.63)
SML1CLK: length 16.1
  TOP w0.089: 279.43,73 279.32,72.89 279.32,68.58 v1(279.43,68.48) 279.32,68.37 279.32,67.11 279.49,66.95 279.49,63.77 279.34,63.63 UH1.BF27
  TOP w0.112: 280.39,74.12 279.82,74.69 279.82,75.03 280,75.21 280.45,75.21 280.57,75.32 ; 279.43,73 279.45,73.01
  TOP w0.127: 279.45,73.01 279.74,73.3 280,73.3 280.39,73.7 280.39,74.12 ; RH460.2 280.4,76.06 281.04,76.06 281.38,75.72 281.38,75.45 281.25,75.32 QH5.6 280.57,75.32
SML1DATA: length 16.1
  TOP w0.089: UH1.BE27 279.34,63.02 279.09,63.27 279.09,63.65 279.28,63.84 279.28,66.88 279.11,67.06 279.11,72.04 279.02,72.13 278.98,72.13
  TOP w0.127: 278.98,72.13 278.09,72.13 277.97,72.25 277.97,72.6 278.1,72.73 v1(278.54,72.73) 278.89,72.73 279.02,72.86 279.02,73.28 278.77,73.53 278.77,73.9 278.9,74.02 QH5.3 279.08,74.05 279.55,74.52 279.55,76.12 RH461.2
SNB_1.2V: length 1.7
  TOP w0.112: PR202.2 v1(238.2,111.29)
SNB_3V: length 1.5
  TOP w0.112: v1(307.24,49.17) 307.78,49.17 PR310.2
SNB_5V:
  vias: v3(309.46,31.07)
SNB_+1VALWP: length 1.1
  BOTTOM w0.112: PC112.1 v1(270.84,15.52)
SNB_VCCIO: length 2.1
  BOTTOM w0.112: PRF04.2 151.16,106.63 v1(150.4,107.4)
SPI_CLK: length 3.4
  TOP w0.112: RE11.2 351.93,35.98 v1(352.14,35.77) 353.09,35.77 353.43,36.11 UE1.15
SPI_CLK_R: length 30.3
  TOP w0.112: CE173.1 350.95,35.3 351.06,35.19 RE11.1 351.06,35.01 350.61,34.57 v2(350.49,34.57)
  TOP w0.127: UE2.6 v2(369.7,41.43)
  BOTTOM w0.112: v2(350.49,34.57) 350.74,34.57 351,34.3 351,32.14 351.22,31.93 353.43,31.93 353.98,31.38 356.96,31.38 360.01,34.43 360.01,35.77 362.77,38.53 367.05,38.53 369.7,41.18 v2(369.7,41.43)
SPI_CS#: length 31
  TOP w0.112: v2(367.57,36.1) 367.57,34.19 367.16,33.78 UE2.1 367.16,31.43 367,31.27 RE12.2 ; v2(352.98,36.67) 353.03,36.61 UE1.14
  IN4 w0.084: v2(367.57,36.1) 366.9,35.43 357.96,35.43 357.88,35.35 357.88,34.71 357.79,34.63 357.63,34.63 357.54,34.71 357.54,35.35 357.46,35.43 357.29,35.43 357.21,35.35 357.21,34.71 357.12,34.63 356.96,34.63 356.87,34.71 356.87,35.35 356.79,35.43 356.62,35.43 356.54,35.35 356.54,34.71 356.45,34.63 356.29,34.63 356.2,34.71 356.2,35.35 356.12,35.43 355.95,35.43 355.87,35.35 355.87,34.71 355.78,34.63 355.3,34.63 355.21,34.71 355.21,35.35 355.13,35.43 354.96,35.43 354.88,35.35 354.88,34.71 354.79,34.63 354.63,34.63 354.54,34.71 354.54,35.35 354.46,35.43 354.29,35.43 354.21,35.35 354.21,34.71 354.12,34.63 353.96,34.63 353.87,34.71 353.87,35.77 v2(352.98,36.67)
SPI_MISO: length 25.7
  TOP w0.112: UE1.16 355.02,35.61 355.36,35.27 355.63,35.27 v2(356.68,34.22) ; RE10.2 368.9,29.74 369.15,29.49 369.15,28.47 v1(368.96,28.28) 368.46,28.28 368.35,28.39 v2(368.35,28.92)
  IN3 w0.104: v2(368.35,28.92) 368.35,34.99 367.73,35.61 356.88,35.61 356.68,35.41 v2(356.68,34.22)
SPI_MOSI: length 27.8
  TOP w0.112: v2(369.9,42.84) 370.32,42.42 RE9.2 ; UE1.17 353.25,35.11 v2(352.96,34.82)
  BOTTOM w0.112: v2(369.9,42.84) 369.48,42.42 369.43,42.42 366.87,39.86 362.46,39.86 359.52,36.91 359.52,34.64 357.91,33.03 352.85,33.03 352.26,33.61 352.26,34.71 352.38,34.82 v2(352.96,34.82)
SPK_SEL: length 285.3
  TOP w0.112: v2(279.49,2.88) 279.49,5.67 277.84,7.33 RE201.2 ; UE5.44 297.54,8.82 297.6,8.75 297.6,8.36 v2(297.21,7.96) 297.65,7.52 v3(297.65,7.46)
  IN3 w0.104: v2(39.06,13.03) 40.69,11.41 43.28,11.41 46.14,8.55 58.61,8.55 61.8,5.35 93.92,5.35 96.92,8.35 108.22,8.35 110.95,5.62 111.22,5.35 112.36,5.35 112.37,5.35 118.53,5.35 120.66,3.22 125.33,3.22 125.56,3.45 165.16,3.45 167.16,1.45 186.67,1.45 187.35,2.12 188.35,2.12 189.02,1.45 194.73,1.45 196.73,3.45 218.22,3.45 219.28,2.39 222.32,2.39 223.38,3.45 240.91,3.45 241.04,3.32 241.45,2.91 242.91,1.45 243.29,1.45 275.84,1.45 277.27,2.88 v2(279.49,2.88) 279.77,2.61 292.47,2.61 297.21,7.35 v2(297.21,7.96)
  BOTTOM w0.112: JAUDIO.11 37.56,14.21 37.36,14.01 37.36,13.67 37.36,13.67 37.36,13.54 37.47,13.43 38.66,13.43 39.06,13.03 v2(39.06,13.03)
SREF_VCCSA: length 4.2
  BOTTOM w0.112: PCA13.1 125.15,116.7 124.62,116.16 124.36,116.16 123.98,115.78 v1(123.98,115.72)
  BOTTOM w0.254: PCA13.1 125.22,116.7 PRA05.2 125.96,116.71 PUA01.4
STRAP3_PCH: length 175.5
  TOP w0.089: UH1.M45 270.47,46.76 270.41,46.82 270.41,46.95 270.22,47.14 270.22,47.2 270,47.43 269.2,47.43 v2(269.09,47.53)
  TOP w0.112: RG555.2 182.36,131.74 v2(182.41,131.69) v1(182.41,131.16)
  IN2 w0.104: v2(269.09,47.53) 268.62,48 268.62,48.38 268.91,48.66 269.31,48.66 269.63,48.98 269.63,50.17 269.9,50.45 269.9,54.32 270.42,54.85 270.42,56.78 271.23,57.59 271.23,58.44 270.98,58.7 270.98,59.05 271.33,59.4 271.46,59.54 271.46,60.93 271.57,61.04 271.57,61.23 272.09,61.74 272.09,63.09 271.71,63.46 271.71,64.84 272.95,66.08 272.95,66.89 273.49,67.42 273.49,72.13 272.84,72.77 272.84,75.59 272.38,76.05 272.38,77.42 270.72,79.08 270.72,83.61 271.86,84.75 271.86,98.96 267.84,102.99 238.45,102.99 237.98,103.46 219.28,103.46 218.32,104.42 216.06,104.42 216.02,104.46 211.47,104.46 211.36,104.35 211.22,104.21 197.05,104.21 191.84,109.42 191.84,115.56 187.62,119.78 187.62,125.06 183.54,129.13 183.54,130.72 182.58,131.69 v2(182.41,131.69)
  IN3 w0.104: v2(178.85,131.47) 179.39,130.92 181.95,130.92 182.41,131.38 v2(182.41,131.69)
  BOTTOM w0.112: JDGFF1.E1 178.64,131.47 v2(178.85,131.47)
STRAP5_PCH: length 180.1
  TOP w0.089: v2(267.95,47.39) 267.95,47.05 268.59,46.41 268.98,46.41 269.06,46.49 UH1.L48
  TOP w0.112: v1(182.72,133.88) 182.72,133.31 182.36,132.95 RG556.2 182.36,132.86 181.82,132.32 v2(181.82,131.98)
  IN2 w0.104: v2(267.95,47.39) 267.95,48.03 268.81,48.9 269.21,48.9 269.37,49.05 269.37,50.25 269.67,50.54 269.67,54.42 270.19,54.94 270.19,56.88 271,57.69 271,58.35 270.75,58.6 270.75,59.15 271.23,59.63 271.23,61.03 271.34,61.14 271.34,61.32 271.86,61.84 271.86,62.99 271.48,63.37 271.48,64.94 272.72,66.18 272.72,66.99 273.26,67.52 273.26,72.03 272.59,72.7 272.59,74.86 272.15,75.31 272.15,77.32 270.49,78.99 270.49,83.7 271.63,84.85 271.63,98.87 267.74,102.75 238.36,102.75 237.88,103.23 216.93,103.23 216.21,103.95 216.21,103.95 215.97,104.19 215.93,104.23 211.56,104.23 211.32,103.98 196.95,103.98 191.61,109.32 191.61,115.46 187.38,119.69 187.38,124.96 183.31,129.03 183.31,130.63 182.68,131.26 182.06,131.26 181.82,131.5 v2(181.82,131.98)
  IN3 w0.104: v2(175.47,134.85) 176.51,133.82 179.22,133.82 181.06,131.98 v2(181.82,131.98)
  BOTTOM w0.112: JDGFF1.G5 v2(175.47,134.85)

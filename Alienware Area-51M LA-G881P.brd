# Allegro board Alienware Area-51M LA-G881P.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PEG_CRX_C_GTX_P0: length 5.7
  TOP w0.112: v2(171.59,148.26) 171.38,148.47 170.85,148.47 CV1099.2
  IN4 w0.084: v2(171.59,148.26) 171.6,148.27 173.93,148.27 174.21,148.55 174.21,149.04 v2(174.27,149.1)
  BOTTOM w0.112: v2(174.27,149.1) 174.08,148.91 174.08,148.54 174.27,148.35 JDGFF2.F7
PEG_CRX_C_GTX_P1: length 2.1
  TOP w0.112: CV1095.2 173.7,150.51 173.44,150.25 173.44,149.94 v2(173.66,149.72)
  BOTTOM w0.112: v2(173.66,149.72) 173.48,149.9 173.48,150.16 173.67,150.35 JDGFF2.G8
PEG_CRX_C_GTX_P2: length 6.8
  TOP w0.112: v2(178.65,148.34) 178.83,148.16 179,148.16 179.23,148.4 179.51,148.4 CV1097.2
  IN4 w0.084: v2(176.05,149.13) 175.83,148.91 175.81,148.91 175.63,148.73 175.63,148.46 175.76,148.34 177.03,148.34 177.42,147.96 178.27,147.96 v2(178.65,148.34)
  BOTTOM w0.112: v2(176.05,149.13) 175.88,148.96 175.88,148.58 176.07,148.39 JDGFF2.F4
PEG_CRX_C_GTX_P3: length 2
  TOP w0.112: v2(175.46,149.78) 175.25,149.99 175.25,150.22 175.19,150.28 175.19,150.4 CV1093.2
  BOTTOM w0.112: JDGFF2.G5 175.47,150.38 175.28,150.19 175.28,149.96 v2(175.46,149.78)
PEG_CRX_C_GTX_P4: length 2.1
  TOP w0.112: v2(177.26,149.75) 177.06,149.95 177.06,150.3 CV1091.2
  BOTTOM w0.112: JDGFF2.G2 177.27,150.33 177.08,150.15 177.08,149.93 v2(177.26,149.75)
PEG_CRX_C_GTX_P5: length 3.8
  BOTTOM w0.112: CV1089.2 174.53,154.31 174.53,154.14 173.95,153.57 173.95,152.16 174.08,152.03 174.08,151.9 174.27,151.71 JDGFF2.H7
PEG_CRX_C_GTX_P6: length 3.6
  BOTTOM w0.112: CV1087.2 176.36,154.37 176.36,154.07 175.88,153.59 175.88,151.94 176.07,151.75 JDGFF2.H4
PEG_CRX_C_GTX_P7: length 3.7
  BOTTOM w0.112: CV64.2 178.14,154.37 178.14,153.63 177.6,153.09 177.6,152.19 177.7,152.1 177.7,151.84 177.87,151.67 JDGFF2.H1
PEG_CRX_C_RD_GTX_N8: length 2.2
  BOTTOM w0.112: CM69.2 173.89,176.19 173.89,176.3 173.7,176.49 v4(173.7,176.87) 173.7,177.29 173.56,177.43 UM8.4
PEG_CRX_C_RD_GTX_N9: length 2.2
  BOTTOM w0.112: CM66.2 171.58,176.19 171.58,176.39 171.7,176.52 v4(171.7,176.87) 171.7,177.29 171.56,177.43 UM8.8
PEG_CRX_C_RD_GTX_N10: length 2.2
  BOTTOM w0.112: CM62.2 172.72,176.16 172.72,176.64 172.7,176.66 172.7,177.29 172.56,177.43 UM8.6
PEG_CRX_C_RD_GTX_N11: length 2.2
  BOTTOM w0.112: UM8.2 174.56,177.43 174.77,177.22 174.77,176.51 175.01,176.26 175.01,176.14 CM65.2
PEG_CRX_C_RD_GTX_P8: length 2.2
  BOTTOM w0.112: UM8.3 174.06,177.43 173.92,177.29 173.92,177.19 173.94,177.17 173.94,176.57 173.94,176.57 174.11,176.4 174.11,176.19 CM67.2
PEG_CRX_C_RD_GTX_P9: length 2.2
  BOTTOM w0.112: CM63.2 171.8,176.14 171.8,176.3 171.92,176.43 171.92,176.58 171.94,176.6 171.94,177.13 171.93,177.14 171.93,177.3 172.06,177.43 UM8.7
PEG_CRX_C_RD_GTX_P10: length 2.2
  BOTTOM w0.112: CM68.2 172.94,176.16 172.94,176.73 172.92,176.75 172.92,177.29 173.06,177.43 UM8.5
PEG_CRX_C_RD_GTX_P11: length 2.2
  BOTTOM w0.112: CM64.2 175.24,176.23 175.24,176.35 175.01,176.58 v4(175.01,176.87) 175.01,177.29 175.06,177.34 UM8.1
PEG_CRX_GTX_N0: length 103.2
  TOP w0.112: v2(181.28,140.36) 179.41,140.36 178.68,141.09 170.41,141.09 167.94,143.56 167.94,148.41 168.25,148.71 169.29,148.71 CV1100.1
  IN1 w0.084: v2(181.28,140.36) 180.32,140.36 180.2,140.24 180.2,136.82 179.83,136.45 179.6,136.22 179.6,134.51 178.44,133.34 178.44,127.05 176.35,124.97 176.35,110.02 167.46,101.13 164.01,101.13 160.99,98.11 160.28,98.11 157.24,95.07 155.25,95.07 151.81,91.63 151.46,91.63 149.06,89.23 147.69,89.23 145.38,86.92 145.38,80.05 145.19,79.86 145.19,79.66 v2(145.41,79.43)
  BOTTOM w0.112: v2(145.41,79.43) 145.09,79.76 UC1.U4
PEG_CRX_GTX_N1: length 99.8
  TOP w0.112: v2(172.68,152.36) 172.84,152.52 173.09,152.52 173.21,152.41 173.21,152 CV1096.1
  IN1 w0.084: v2(144.6,78.41) 144.57,78.43 144.33,78.45 144.24,78.37 144.22,78.07 144.04,77.9 143.34,77.9 143.31,77.93 141.76,77.93 141.44,78.24 141.44,78.66 140.48,79.63 140.48,81.28 141.34,82.13 141.34,84.04 141.71,84.41 141.71,89.15 146.88,94.33 150.69,94.33 154.4,98.03 156.39,98.03 159.16,100.81 159.69,100.81 162.06,103.17 162.06,116.96 163.24,118.14 163.24,120.54 168.43,125.74 168.43,148.84 170.59,151 172.55,151 173.28,151.73 173.28,152.48 173.18,152.57 172.89,152.57 v2(172.68,152.36)
  BOTTOM w0.112: UC1.T5 144.18,78.89 144.6,78.47 v2(144.6,78.41)
PEG_CRX_GTX_N2: length 94.4
  TOP w0.112: v2(179.15,141.9) 179.45,142.2 179.45,142.7 181.7,144.95 181.7,148.06 181.59,148.17 181.09,148.17 CV1098.1
  IN1 w0.084: v2(179.15,141.9) 179.39,141.66 179.39,141.5 179.3,141.42 171.92,141.42 169.69,139.19 169.69,128.76 170.24,128.21 170.24,117.23 165.89,112.88 165.89,105.04 160.39,99.54 159.69,99.54 156.65,96.5 154.66,96.5 151.22,93.06 149.5,93.06 143.94,87.5 143.94,86.98 143.03,86.07 143.03,81.58 143.43,81.18 143.43,79.67 143.35,79.59 143.35,79.57 143.27,79.49 v2(142.89,79.49)
  BOTTOM w0.112: v2(142.89,79.49) 142.89,79.49 143.26,79.86 UC1.R4
PEG_CRX_GTX_N3: length 99.4
  TOP w0.112: v2(174.46,152.79) 174.62,152.95 174.81,152.95 174.92,152.84 174.92,151.94 CV1094.1
  IN1 w0.084: v2(174.46,152.79) 174.67,153 174.97,153 175.05,152.92 175.05,151.35 174.01,150.31 170.79,150.31 169.89,149.41 169.89,140.28 169.06,139.45 169.06,128.5 169.61,127.95 169.61,117.49 165.26,113.14 165.26,105.3 160.13,100.17 159.42,100.17 156.49,97.24 154.5,97.24 150.96,93.7 147.14,93.7 142.34,88.89 142.34,83.97 141.88,83.52 141.88,81.6 141.14,80.86 141.14,79.47 141.63,78.98 142.08,78.98 142.36,78.7 142.36,78.63 142.39,78.6 142.39,78.37 142.3,78.28 142.07,78.28 141.98,78.37 v2(141.98,78.47)
  BOTTOM w0.112: v2(141.98,78.47) 141.98,78.61 UC1.P5
PEG_CRX_GTX_N4: length 102.3
  TOP w0.112: CV1092.1 176.97,152.02 176.97,152.68 176.66,152.99 176.51,152.99 v2(176.29,152.77)
  IN1 w0.084: v2(141.88,80.41) 141.72,80.41 141.54,80.23 141.54,79.99 141.62,79.91 142.25,79.91 142.46,79.7 142.46,79.34 142.71,79.08 143.2,79.08 143.22,79.06 143.91,79.06 144.13,79.28 144.13,79.66 144.13,79.66 144.13,80.65 143.93,80.85 143.93,81.97 143.74,82.16 143.74,85.03 143.8,85.09 143.8,85.94 144.57,86.71 144.57,87.24 149.76,92.43 151.48,92.43 154.92,95.87 156.91,95.87 159.95,98.91 160.65,98.91 163.67,101.93 167.12,101.93 175.49,110.29 175.49,128.28 177.3,130.1 177.3,133.36 178.8,134.85 178.8,136.55 179.4,137.15 179.4,140.62 180.17,141.39 180.17,142.03 177.7,144.5 177.7,150.02 176.84,150.89 176.84,152.87 176.69,153.02 176.53,153.02 v2(176.29,152.77)
  BOTTOM w0.112: v2(141.88,80.41) 141.88,80.33 141.43,79.89 UC1.N4
PEG_CRX_GTX_N5: length 100.4
  IN1 w0.084: v2(140.11,78.45) 140.24,78.45 140.36,78.57 140.36,78.74 140.24,78.86 138.95,78.86 138.58,79.23 138.58,81.29 139.62,82.33 139.62,83.91 140.44,84.73 140.44,89.68 146.35,95.59 150.17,95.59 153.87,99.3 155.86,99.3 158.64,102.07 159.17,102.07 160.8,103.7 160.8,117.49 161.97,118.66 161.97,121.07 167.16,126.26 167.16,149.36 172.57,154.76 173.9,154.76 174.37,155.24 174.37,156.04 v2(174.17,156.25)
  BOTTOM w0.112: CV1090.1 174.33,155.92 174.33,156.08 v2(174.17,156.25) ; UC1.M5 140.52,78.93 140.11,78.52 v2(140.11,78.45)
PEG_CRX_GTX_N6: length 99.3
  IN1 w0.084: v2(139.17,79.45) 139.44,79.45 139.53,79.53 139.53,81.41 140.23,82.11 140.23,83.61 141.07,84.45 141.07,89.42 146.62,94.96 150.43,94.96 154.13,98.66 156.12,98.66 158.9,101.44 159.43,101.44 161.43,103.43 161.43,117.23 162.6,118.4 162.6,120.81 167.8,126 167.8,149.1 172.83,154.13 174.16,154.13 174.67,154.65 175.56,154.65 175.82,154.91 175.82,156.31 v2(175.61,156.52)
  BOTTOM w0.112: v2(175.61,156.52) 175.78,156.35 175.78,156.12 175.97,155.94 175.97,155.78 CV1088.1 ; v2(139.17,79.45) UC1.L4
PEG_CRX_GTX_N7: length 106.5
  IN1 w0.084: v2(175.09,156.79) 174.68,157.2 174.27,157.2 166.7,149.63 166.7,135.05 163.71,132.06 163.71,123.59 161.51,121.38 161.51,120.37 160.33,119.19 160.33,103.89 158.98,102.54 158.44,102.54 158.08,102.18 147.42,102.18 145.04,99.79 145.04,94.93 139.96,89.85 139.96,84.79 139.28,84.11 139.28,82.51 138.33,81.56 138.33,79.22 138.63,78.92 138.63,78.61 138.64,78.6 138.64,78.52 138.71,78.45 v2(139.09,78.45)
  BOTTOM w0.112: v2(139.09,78.45) 139.09,78.51 138.69,78.91 UC1.K5 ; CV1086.1 177.9,155.93 177.9,156.4 177.27,157.03 175.34,157.03 v2(175.09,156.79)
PEG_CRX_GTX_N8: length 129.3
  IN1 w0.084: v2(137.39,79.45) 137.39,79.04 137.52,78.91 137.64,78.91 137.8,79.08 137.8,83.68 139.16,85.04 139.16,90.19 143.73,94.75 143.73,95.38 144.24,95.89 144.24,100.13 147.09,102.98 149.46,102.98 151.18,104.7 151.18,106.93 153.84,109.6 156.03,109.6 156.64,110.2 156.64,118.91 162.86,125.13 162.86,132.35 165.76,135.25 165.76,150.88 156.75,159.89 156.75,166.95 160.32,170.53 163.78,170.53 166.18,172.93 173.02,172.93 173.92,173.82 173.92,174.06 v2(173.71,174.27)
  BOTTOM w0.112: v2(173.71,174.27) 173.89,174.45 173.89,174.93 173.89,174.93 173.89,175.25 CM69.1 ; v2(137.39,79.45) 137.39,79.5 UC1.J4
PEG_CRX_GTX_N9: length 127.6
  IN1 w0.084: v2(136.39,78.56) 136.36,78.54 136.36,78.11 136.45,78.02 136.59,78.02 136.78,78.21 136.78,79.69 136.2,80.28 136.2,80.87 137.27,81.94 137.27,83.99 138.48,85.2 138.48,90.4 143.06,94.99 143.06,99.85 146.82,103.61 148.32,103.61 150.45,105.74 150.45,107.64 152.34,109.53 152.34,114.3 155.88,117.84 155.88,120.28 162.23,126.63 162.23,132.67 165.13,135.57 165.13,147.15 156.12,156.16 156.12,167.21 160.06,171.16 163.42,171.16 165.82,173.56 171.47,173.56 171.56,173.65 171.56,173.77 v2(171.36,173.96)
  BOTTOM w0.112: v2(136.39,78.56) 136.45,78.56 UC1.H5 ; CM66.1 171.55,175.22 171.55,174.14 v2(171.36,173.96)
PEG_CRX_GTX_N10: length 130.7
  IN1 w0.084: v2(172.54,174.8) 172.72,174.98 172.72,175.03 172.53,175.22 171.92,175.22 170.8,174.1 167.58,174.1 167.16,174.52 162.76,174.52 159.81,171.56 159.32,171.56 155.65,167.89 155.65,153.46 164.66,144.45 164.66,135.76 161.77,132.87 161.77,126.82 154.85,119.9 152.07,119.9 151.84,119.67 151.84,109.86 149.35,107.38 149.35,105.3 148.13,104.07 146.63,104.07 142.6,100.04 142.6,95.18 137.82,90.4 137.82,85.58 136.37,84.12 136.37,81.96 135.21,80.8 135.21,80.11 135.41,79.91 135.79,79.91 136.05,79.65 136.05,79.21 135.92,79.08 135.72,79.08 135.58,79.23 v2(135.58,79.49)
  BOTTOM w0.112: v2(172.54,174.8) 172.72,174.98 172.72,175.21 172.54,175.39 CM62.1 ; UC1.G4 135.95,79.86 135.58,79.49 v2(135.58,79.49)
PEG_CRX_GTX_N11: length 135.7
  IN1 w0.084: v2(134.59,79.39) 134.84,79.14 134.84,78.91 134.76,78.83 134.25,78.83 134.01,79.06 134.01,80.86 135.53,82.38 135.53,84.29 137.19,85.94 137.19,90.66 141.31,94.79 141.31,99.65 143.92,102.26 143.92,106.06 145.1,107.23 148.31,107.23 151.2,110.12 151.2,119.93 151.81,120.53 154.58,120.53 161.13,127.09 161.13,133.13 163.87,135.86 163.87,144.28 155.02,153.14 155.02,167.28 155.02,168.16 159.06,172.19 159.54,172.19 163.39,176.05 174.1,176.05 175.07,175.07 175.07,174.97 v2(174.88,174.79)
  BOTTOM w0.112: v2(134.59,79.39) 134.66,79.39 135.03,79.02 UC1.F5 ; CM65.1 174.88,175.41 175.06,175.23 175.06,174.97 v2(174.88,174.79)
PEG_CRX_GTX_P0: length 103.1
  TOP w0.112: v2(181.28,140.95) 180.92,140.58 179.51,140.58 178.77,141.32 170.5,141.32 168.17,143.65 168.17,148.32 168.34,148.49 169.29,148.49 CV1099.1
  IN1 w0.084: v2(144.67,79.43) 145.02,79.79 145.02,79.93 145.21,80.12 145.21,86.99 147.62,89.4 148.99,89.4 151.39,91.8 151.74,91.8 155.18,95.24 157.17,95.24 160.21,98.28 160.92,98.28 163.94,101.3 167.39,101.3 176.18,110.09 176.18,125.04 178.27,127.12 178.27,133.41 179.43,134.58 179.43,136.29 179.67,136.52 179.67,136.52 180.04,136.89 180.04,140.31 180.25,140.53 180.86,140.53 v2(181.28,140.95)
  BOTTOM w0.112: v2(144.67,79.43) 145.09,79.01 UC1.U5
PEG_CRX_GTX_P1: length 99.8
  TOP w0.112: CV1095.1 173.43,151.87 173.43,152.5 173.19,152.74 172.88,152.74 v2(172.68,152.94)
  IN1 w0.084: v2(172.68,152.94) 172.88,152.74 173.25,152.74 173.44,152.55 173.44,151.66 172.62,150.84 170.66,150.84 168.6,148.77 168.6,125.67 163.4,120.48 163.4,118.07 162.23,116.89 162.23,103.1 159.76,100.64 159.23,100.64 156.46,97.86 154.47,97.86 150.76,94.16 146.95,94.16 141.87,89.09 141.87,84.34 141.5,83.97 141.5,82.07 140.65,81.21 140.65,79.7 141.61,78.73 141.61,78.31 141.83,78.1 143.38,78.1 143.41,78.06 143.97,78.06 144.06,78.15 144.07,78.42 143.99,78.51 143.79,78.52 v2(143.73,78.46)
  BOTTOM w0.112: UC1.T6 144.18,78.07 143.79,78.46 v2(143.73,78.46)
PEG_CRX_GTX_P2: length 94.5
  TOP w0.112: v2(179.74,141.9) 179.67,141.96 179.67,142.61 181.92,144.86 181.92,148.15 181.68,148.4 181.09,148.4 CV1097.1
  IN1 w0.084: v2(179.74,141.9) 179.55,141.72 179.55,141.43 179.37,141.25 171.99,141.25 169.86,139.12 169.86,128.83 170.41,128.28 170.41,117.16 166.06,112.81 166.06,104.97 160.46,99.37 159.76,99.37 156.72,96.34 154.73,96.34 151.29,92.9 149.57,92.9 144.1,87.43 144.1,86.91 143.19,86 143.19,81.65 143.6,81.25 143.6,79.56 v2(143.73,79.44)
  BOTTOM w0.112: UC1.R5 v2(143.73,79.44)
PEG_CRX_GTX_P3: length 99.4
  TOP w0.112: CV1093.1 175.15,151.93 175.15,152.93 174.9,153.17 174.66,153.17 v2(174.46,153.38)
  IN1 w0.084: v2(174.46,153.38) 174.67,153.17 175.04,153.17 175.22,152.99 175.22,151.28 174.08,150.14 170.86,150.14 170.06,149.34 170.06,140.21 169.23,139.38 169.23,128.56 169.78,128.01 169.78,117.42 165.43,113.07 165.43,105.23 160.2,100.01 159.49,100.01 156.56,97.07 154.57,97.07 151.03,93.53 147.21,93.53 142.51,88.82 142.51,83.9 142.05,83.45 142.05,81.53 141.31,80.79 141.31,79.54 141.7,79.14 142.15,79.14 142.52,78.77 142.52,78.7 v2(142.76,78.47)
  BOTTOM w0.112: v2(142.76,78.47) UC1.P6
PEG_CRX_GTX_P4: length 102.3
  TOP w0.112: v2(176.29,153.36) 176.44,153.21 176.76,153.21 177.19,152.77 177.19,151.85 CV1091.1
  IN1 w0.084: v2(141.84,79.53) 141.84,79.63 141.95,79.74 142.18,79.74 142.29,79.63 142.29,79.27 142.64,78.91 143.13,78.91 143.15,78.89 143.98,78.89 144.3,79.21 144.3,79.28 144.29,79.28 144.29,79.59 144.3,79.59 144.3,80.72 144.09,80.92 144.09,82.04 143.91,82.23 143.91,84.96 143.97,85.02 143.97,85.88 144.74,86.64 144.74,87.17 149.83,92.26 151.55,92.26 154.99,95.7 156.98,95.7 160.02,98.74 160.72,98.74 163.74,101.76 167.19,101.76 175.65,110.22 175.65,128.21 177.47,130.03 177.47,133.29 178.97,134.78 178.97,136.48 179.57,137.08 179.57,140.55 180.34,141.32 180.34,142.1 177.87,144.57 177.87,150.09 177,150.96 177,152.94 176.76,153.19 176.47,153.19 v2(176.29,153.36)
  BOTTOM w0.112: UC1.N5 141.43,79.04 141.84,79.45 v2(141.84,79.53)
PEG_CRX_GTX_P5: length 100.4
  IN1 w0.084: v2(140.92,78.46) 140.67,78.46 140.53,78.6 140.53,78.81 140.31,79.03 139.02,79.03 138.75,79.3 138.75,81.22 139.79,82.26 139.79,83.84 140.61,84.66 140.61,89.61 146.42,95.43 150.24,95.43 153.94,99.13 155.93,99.13 158.71,101.9 159.24,101.9 160.96,103.63 160.96,117.42 162.14,118.59 162.14,121 167.33,126.19 167.33,149.29 172.63,154.6 173.97,154.6 174.54,155.17 174.54,156.04 v2(174.75,156.25)
  BOTTOM w0.112: v2(140.92,78.46) UC1.M6 ; CV1089.1 174.55,155.95 174.55,156.05 v2(174.75,156.25)
PEG_CRX_GTX_P6: length 99.3
  IN1 w0.084: v2(140.04,79.4) 139.98,79.4 139.69,79.69 139.69,81.34 140.4,82.04 140.4,83.54 141.24,84.38 141.24,89.35 146.69,94.79 150.5,94.79 154.2,98.5 156.19,98.5 158.97,101.27 159.5,101.27 161.6,103.36 161.6,117.16 162.77,118.33 162.77,120.74 167.96,125.93 167.96,149.03 172.9,153.96 174.23,153.96 174.74,154.48 175.63,154.48 175.99,154.84 175.99,156.31 v2(176.2,156.52)
  BOTTOM w0.112: v2(176.2,156.52) 176,156.32 176,156.21 176.2,156.01 176.62,155.6 CV1087.1 ; UC1.L5 v2(140.04,79.4)
PEG_CRX_GTX_P7: length 106.6
  IN1 w0.084: v2(175.09,157.37) 174.2,157.37 166.53,149.7 166.53,135.12 163.54,132.13 163.54,123.66 161.34,121.45 161.34,120.44 160.16,119.26 160.16,103.96 158.91,102.7 158.37,102.7 158.01,102.34 147.35,102.34 144.87,99.86 144.87,95 139.79,89.92 139.79,84.86 139.11,84.18 139.11,82.58 138.16,81.63 138.16,79.15 138.46,78.85 138.46,78.57 138.33,78.45 v2(138.26,78.45)
  BOTTOM w0.112: CV64.1 178.13,155.93 178.13,156.49 177.37,157.25 175.22,157.25 v2(175.09,157.37) ; UC1.K6 138.65,78.06 v2(138.26,78.45)
PEG_CRX_GTX_P8: length 129.3
  IN1 w0.084: v2(174.29,174.27) 174.09,174.06 174.09,173.75 173.09,172.76 166.25,172.76 163.85,170.36 160.39,170.36 156.92,166.88 156.92,159.96 165.93,150.95 165.93,135.18 163.03,132.28 163.03,125.06 156.81,118.84 156.81,110.13 156.1,109.43 153.91,109.43 151.35,106.86 151.35,104.63 149.53,102.81 147.15,102.81 144.4,100.06 144.4,95.82 143.89,95.31 143.89,94.69 139.32,90.12 139.32,84.97 137.97,83.61 137.97,79.01 137.71,78.74 137.49,78.74 137.36,78.62 v2(137.36,78.51)
  BOTTOM w0.112: UC1.J5 137.36,78.56 v2(137.36,78.51) ; CM67.1 174.12,175.25 174.12,174.93 174.11,174.93 174.11,174.45 v2(174.29,174.27)
PEG_CRX_GTX_P9: length 127.5
  IN1 w0.084: v2(171.95,173.96) 171.72,173.73 171.72,173.58 171.54,173.39 165.89,173.39 163.49,170.99 160.13,170.99 156.28,167.14 156.28,156.23 165.3,147.21 165.3,135.5 162.4,132.6 162.4,126.56 156.04,120.21 156.04,117.77 152.51,114.23 152.51,109.46 150.62,107.57 150.62,105.67 148.39,103.44 146.89,103.44 143.23,99.78 143.23,94.92 138.65,90.33 138.65,85.13 137.44,83.92 137.44,81.87 136.37,80.8 136.37,80.35 136.95,79.76 136.95,78.14 136.66,77.85 136.48,77.85 136.39,77.75 v2(136.39,77.61)
  BOTTOM w0.112: CM63.1 171.77,175.21 171.77,174.14 v2(171.95,173.96) ; UC1.H6 136.84,78.06 v2(136.39,77.61)
PEG_CRX_GTX_P10: length 130.7
  IN1 w0.084: v2(173.13,174.8) 173.09,174.8 172.88,175 172.88,175.1 172.6,175.39 171.85,175.39 170.73,174.27 167.65,174.27 167.23,174.69 162.69,174.69 159.74,171.73 159.25,171.73 155.48,167.96 155.48,153.39 164.49,144.38 164.49,135.83 161.6,132.94 161.6,126.89 154.78,120.07 152,120.07 151.67,119.74 151.67,109.93 149.19,107.45 149.19,105.37 148.06,104.24 146.56,104.24 142.43,100.11 142.43,95.25 137.65,90.47 137.65,85.65 136.2,84.19 136.2,82.03 135.04,80.87 135.04,80.04 135.2,79.88 135.2,79.33 135.41,79.13 135.55,78.99 v2(135.55,78.57)
  BOTTOM w0.112: v2(135.55,78.57) 135.55,78.58 UC1.G5 ; CM68.1 173.13,175.39 172.94,175.21 172.94,174.98 v2(173.13,174.8)
PEG_CRX_GTX_P11: length 135.7
  IN1 w0.084: v2(134.56,78.45) 134.36,78.66 134.18,78.66 133.85,78.99 133.85,80.93 135.37,82.45 135.37,84.36 137.02,86.01 137.02,90.73 141.14,94.86 141.14,99.72 143.76,102.33 143.76,106.13 145.03,107.4 148.24,107.4 151.04,110.19 151.04,120 151.74,120.7 154.51,120.7 160.97,127.16 160.97,133.2 163.7,135.93 163.7,144.22 154.85,153.07 154.85,167.21 154.85,167.74 154.85,168.23 158.99,172.36 159.47,172.36 163.32,176.21 174.17,176.21 175.23,175.14 175.23,175.01 v2(175.46,174.79)
  BOTTOM w0.112: v2(175.46,174.79) 175.28,174.97 175.28,175.23 175.46,175.41 CM64.1 ; UC1.F6 134.64,78.45 v2(134.56,78.45)
PEG_CRX_RD_GTX_N8: length 9.4
  TOP w0.112: v2(173.67,190.97) 173.85,191.15 173.85,191.35 173.75,191.45 JCDRA.16
  BOTTOM w0.112: v2(173.67,190.97) 173.84,190.79 173.84,188.42 174.24,188.02 174.24,187.7 174.22,187.68 174.22,187.14 174.24,187.12 174.24,184.96 173.77,184.49 173.77,184.37 173.56,184.16 UM8.42
PEG_CRX_RD_GTX_N9: length 9.8
  TOP w0.112: JCDRA.19 172.55,191.48 172.64,191.39 172.64,190.81 172.46,190.63 172.37,190.63 v2(172.2,190.79)
  BOTTOM w0.112: v2(172.2,190.79) 171.94,190.53 171.85,190.53 171.6,190.27 171.6,189.53 171.3,189.24 171.3,184.82 171.13,184.65 171.13,184.2 171.06,184.13 UM8.37
PEG_CRX_RD_GTX_N10: length 12.3
  TOP w0.112: JCDRA.25 170.15,191.49 170.24,191.4 170.24,190.99 170.48,190.75 170.65,190.75 v2(170.94,190.46)
  BOTTOM w0.112: UM8.39 v4(172.06,187.73) 172.06,188.53 172.71,189.18 172.71,191.04 172.41,191.35 171.92,191.35 171.25,190.69 171.17,190.69 v2(170.94,190.46)
PEG_CRX_RD_GTX_N11: length 16.5
  TOP w0.112: JCDRA.31 167.75,191.5 167.84,191.42 167.84,191.08 167.84,191.08 167.84,189.88 168.82,188.91 172.52,188.91 173.16,189.55 174.3,189.55 v2(174.48,189.36)
  BOTTOM w0.112: v2(174.48,189.36) 174.62,189.51 174.93,189.51 175.04,189.4 175.04,184.74 174.74,184.45 174.74,184.26 174.56,184.08 UM8.44
PEG_CRX_RD_GTX_P8: length 9.3
  TOP w0.112: JCDRA.15 174.15,191.5 174.07,191.42 174.07,191.15 v2(174.25,190.97)
  BOTTOM w0.112: v2(174.25,190.97) 174.07,190.78 174.07,188.51 174.46,188.11 v4(174.46,187.41) 174.46,184.87 173.99,184.4 173.99,184.24 174.06,184.16 UM8.43
PEG_CRX_RD_GTX_P9: length 9.8
  TOP w0.112: JCDRA.18 172.95,191.49 172.86,191.4 172.86,190.71 172.55,190.41 172.4,190.41 v2(172.2,190.21)
  BOTTOM w0.112: UM8.38 171.56,184.02 171.35,184.24 171.35,184.56 171.52,184.73 171.52,189.15 171.82,189.44 171.82,190.18 171.95,190.31 172.1,190.31 v2(172.2,190.21)
PEG_CRX_RD_GTX_P10: length 12.3
  TOP w0.112: v2(170.94,191.04) 170.87,190.97 170.57,190.97 170.46,191.08 170.46,191.39 170.55,191.48 JCDRA.24
  BOTTOM w0.112: UM8.40 172.56,184.04 172.29,184.32 172.29,187.44 172.3,187.46 172.3,188 172.29,188.02 172.29,188.44 172.93,189.09 172.93,191.14 172.5,191.57 171.82,191.57 171.16,190.91 171.08,190.91 v2(170.94,191.04)
PEG_CRX_RD_GTX_P11: length 16.5
  TOP w0.112: JCDRA.30 168.15,191.52 168.07,191.44 168.07,191.08 168.07,191.08 168.07,189.97 168.91,189.13 172.42,189.13 173.06,189.77 174.3,189.77 v2(174.48,189.95)
  BOTTOM w0.112: UM8.45 175.06,184.08 174.97,184.18 174.97,184.36 175.26,184.65 175.26,189.49 175.02,189.73 174.7,189.73 v2(174.48,189.95)
PEG_CTX_C_GRX_N0: length 80.6
  IN4 w0.084: v2(173.38,139.85) 173.38,140.53 174.2,141.35 175.01,141.35 175.12,141.24 177.65,141.24 177.68,141.27 179.25,141.27 180.2,140.32 180.2,135.85 178.44,134.08 178.44,130.17 178.44,130.03 176.78,128.37 175.89,128.37 175.65,128.14 175.65,127.77 173.63,125.75 173.63,115.3 167.8,109.47 165.73,109.47 164.71,108.44 161.51,108.44 160.78,107.72 158.37,107.72 156.71,109.38 151.73,109.38 149.15,106.8 140.87,106.8 138.9,104.82 138.25,104.82 138.07,105.01 138.07,105.58 v2(138.06,105.59)
  BOTTOM w0.112: v2(173.38,139.85) 173.59,139.85 173.78,140.04 173.78,140.38 173.67,140.5 JDGFF2.A8 ; CC7.2 138.24,105.2 138.24,105.41 v2(138.06,105.59)
PEG_CTX_C_GRX_N1: length 78.1
  IN4 w0.084: v2(136.82,105.59) 136.74,105.66 136.74,106.15 136.82,106.22 136.82,107.1 137.15,107.43 148.89,107.43 151.47,110.01 156.97,110.01 158.63,108.35 160.52,108.35 161.25,109.07 164.45,109.07 165.47,110.1 167.54,110.1 173,115.56 173,123.79 172.49,124.3 172.49,125.82 173.7,127.02 173.7,127.46 175.24,129.01 176.51,129.01 177.32,129.81 177.32,133.86 179.57,136.12 179.57,140.06 178.99,140.64 177.95,140.64 177.91,140.61 175.75,140.61 175.57,140.43 175.57,139.68 v2(175.54,139.66)
  BOTTOM w0.112: CC9.2 136.96,104.9 136.63,105.22 136.63,105.41 v2(136.82,105.59) ; v2(175.54,139.66) 175.54,140.23 175.47,140.31 JDGFF2.A5
PEG_CTX_C_GRX_N2: length 84
  IN4 w0.084: v2(134.38,105.65) 134.59,105.86 134.59,106.06 134.77,106.24 135.28,106.24 135.64,105.88 135.64,104.83 136.11,104.36 151.77,104.36 152.37,103.76 157.49,103.76 161.68,107.95 164.88,107.95 165.93,109 168,109 175.2,116.21 175.2,125.02 179.51,129.32 179.51,134.5 180.67,135.66 180.67,140.53 180.17,141.03 180.17,142.03 179.9,142.3 178.99,142.3 178.43,141.74 177.49,141.74 177.46,141.7 175.31,141.7 175.13,141.89 175.13,142.01 v2(174.89,142.25)
  BOTTOM w0.112: v2(174.89,142.25) 175.06,142.08 175.06,141.9 174.87,141.71 JDGFF2.B6 ; CC11.2 134.56,105.22 134.56,105.47 v2(134.38,105.65)
PEG_CTX_C_GRX_N3: length 76.9
  IN4 w0.084: v2(132.54,105.62) 132.74,105.83 132.74,107.37 133.6,108.23 148.55,108.23 151.59,111.27 153.58,111.27 154.04,110.81 156.63,110.81 157.35,111.54 159.01,111.54 159.39,111.15 163.98,111.15 164.62,111.79 166.84,111.79 171.31,116.26 171.31,122.99 170.8,123.51 170.8,126.9 170.64,127.06 170.64,131.82 170.85,132.03 170.85,135.59 170.64,135.79 170.64,137.81 171.41,138.57 177,138.57 177.09,138.65 177.09,139.12 v2(176.88,139.32)
  BOTTOM w0.112: JDGFF2.A2 177.27,140.46 177.46,140.27 177.46,140.11 177.06,139.7 177.06,139.51 v2(176.88,139.32) ; v2(132.54,105.62) 132.73,105.43 132.73,105.22 CC13.2
PEG_CTX_C_GRX_N4: length 74.8
  IN4 w0.084: v2(173.08,142.28) 173.29,142.07 173.29,141.64 169.82,138.18 169.82,126.98 170.17,126.64 170.17,123.19 170.65,122.71 170.65,116.61 166.46,112.42 164.35,112.42 164.11,112.17 157.09,112.17 156.36,111.44 154.33,111.44 153.87,111.9 151.33,111.9 148.29,108.86 132.99,108.86 130.93,106.8 130.93,105.86 v2(130.72,105.65)
  BOTTOM w0.112: v2(173.08,142.28) 173.26,142.1 173.26,141.88 173.07,141.69 JDGFF2.B9 ; v2(130.72,105.65) 130.9,105.47 130.9,105.22 CC15.2
PEG_CTX_C_GRX_N5: length 90.8
  IN4 w0.084: v2(128.89,105.65) 128.89,104.24 129.62,103.51 151.45,103.51 152.02,102.94 157.8,102.94 162.01,107.15 165.21,107.15 166.26,108.2 168.33,108.2 176.09,115.96 176.09,124.77 180.31,128.99 180.31,133.82 181.47,134.98 181.47,138.29 181.85,138.66 181.85,141.61 180.36,143.1 177.04,143.1 176.75,142.81 176.75,142.38 v2(176.68,142.31)
  BOTTOM w0.112: v2(128.89,105.65) 129.07,105.47 129.07,105.22 CC17.2 ; JDGFF2.B3 176.67,141.67 176.86,141.86 176.86,142.06 176.68,142.25 v2(176.68,142.31)
PEG_CTX_C_GRX_N6: length 82.4
  IN4 w0.084: v2(125.5,106.39) 125.64,106.26 125.75,106.26 125.95,106.45 125.95,106.73 126.03,106.81 126.44,106.81 127.62,107.99 130.57,107.99 132.54,109.96 147.83,109.96 150.88,113 156.31,113 156.58,113.27 159.39,113.27 162.38,116.26 162.38,118.5 168.73,124.84 168.73,140.74 172.11,144.12 175.4,144.12 175.89,143.63 175.89,143.32 v2(175.48,142.9)
  BOTTOM w0.112: v2(175.48,142.9) 175.66,143.09 175.66,143.53 175.47,143.72 JDGFF2.C5 ; v2(125.5,106.39) 125.68,106.58 126.37,106.58 v4(126.89,106.05) 127.05,105.9 127.05,105.8 127.25,105.6 127.25,105.23 CC19.2
PEG_CTX_C_GRX_N7: length 85.6
  IN4 w0.084: v2(173.68,142.94) 174.06,143.33 174.06,143.37 173.94,143.49 172.37,143.49 169.36,140.48 169.36,126.79 169.7,126.44 169.7,122.82 170.18,122.34 170.18,116.84 166.23,112.88 164.16,112.88 163.91,112.64 156.85,112.64 156.13,111.91 154.63,111.91 154.17,112.37 151.14,112.37 148.1,109.33 132.8,109.33 130.83,107.36 130.63,107.36 130.63,107.36 127.89,107.36 126.11,105.59 124.52,105.59 124.43,105.5 124.43,105.15 124.34,105.07 124.14,105.07 124.01,105.2 v2(124.01,105.28)
  BOTTOM w0.112: v2(173.68,142.94) 173.86,143.12 173.86,143.61 173.67,143.8 JDGFF2.C8 ; CC21.2 125.38,105.19 125.38,105.35 125.27,105.46 124.19,105.46 v2(124.01,105.28)
PEG_CTX_C_GRX_N8: length 163.8
  TOP w0.112: v2(178.46,191.04) 178.64,191.22 178.64,191.44 178.55,191.53 JCDRA.4
  IN1 w0.084: v2(121.49,97.69) 121.47,97.7 117.46,97.7 107.28,107.88 107.28,129.6 113.03,135.34 113.03,139.4 107.26,145.18 107.26,153.18 108.81,160.47 112.88,164.54 145.14,164.54 151.54,170.94 155.85,170.94 158.91,174 158.91,174.82 163.47,179.39 164.15,179.39 164.37,179.6 165.02,179.6 165.53,180.12 165.53,182.46 166.71,183.64 169.76,183.64 172.17,186.06 173.52,186.06 175.69,188.22 178.14,188.22 178.6,188.68 178.6,190.89 v2(178.46,191.04)
  BOTTOM w0.112: CC60.2 121.88,97.87 121.67,97.87 v2(121.49,97.69)
PEG_CTX_C_GRX_N9: length 162.8
  TOP w0.112: v2(177.26,191.01) 177.44,191.2 177.44,191.39 177.35,191.48 JCDRA.7
  IN1 w0.084: v2(177.26,191.01) 177.33,190.94 177.33,189.08 177.11,188.85 175.42,188.85 174.07,187.5 168.4,187.5 159.68,178.78 157.91,178.78 151.85,172.72 151.85,172.15 144.87,165.17 112.62,165.17 108.17,160.73 106.62,153.46 106.62,144.91 112.39,139.14 112.39,135.61 106.65,129.86 106.65,129.34 106.65,129.34 106.65,107.6 117.63,96.62 120.24,96.62 v2(120.35,96.52)
  BOTTOM w0.112: CC56.2 121.91,96.67 120.5,96.67 v2(120.35,96.52)
PEG_CTX_C_GRX_N10: length 164.3
  TOP w0.112: v2(176.06,191.08) 176.24,191.26 176.24,191.45 176.15,191.54 JCDRA.10
  IN1 w0.084: v2(121.49,95.35) 121.42,95.42 117.74,95.42 105.99,107.16 105.99,130.1 111.76,135.87 111.76,138.88 105.99,144.65 105.99,153.55 107.62,161.21 112.21,165.81 112.35,165.81 144.61,165.81 151.15,172.35 151.15,174.16 153.21,176.21 153.21,176.45 156.28,179.51 159.52,179.51 168.13,188.13 173.8,188.13 175.16,189.48 175.83,189.48 176.13,189.78 176.13,191.01 v2(176.06,191.08)
  BOTTOM w0.112: v2(121.49,95.35) 121.67,95.53 121.88,95.53 CC62.2
PEG_CTX_C_GRX_N11: length 165.1
  TOP w0.112: v2(174.84,191.08) 175.02,191.26 175.02,191.44 174.95,191.52 JCDRA.13
  IN1 w0.084: v2(120.41,94.25) 117.81,94.25 105.36,106.7 105.36,130.36 111.13,136.13 111.13,138.62 105.36,144.39 105.36,153.62 107.07,161.69 111.82,166.44 112.09,166.44 144.34,166.44 150.52,172.62 150.52,174.42 152.57,176.47 152.57,176.75 156.3,180.48 159.59,180.48 160.81,181.7 160.81,182.22 162.88,184.29 163.4,184.29 168,188.89 172.47,188.89 174.11,190.52 174.76,190.52 174.95,190.71 174.95,190.97 v2(174.84,191.08)
  BOTTOM w0.112: CC63.2 121.88,94.36 120.53,94.36 v2(120.41,94.25)
PEG_CTX_C_GRX_P0: length 80.6
  IN4 w0.084: v2(138.65,105.59) 138.44,105.38 138.42,105.38 138.23,105.2 138.23,105.08 138.32,104.99 138.83,104.99 140.8,106.96 149.08,106.96 151.66,109.55 156.77,109.55 158.44,107.88 160.71,107.88 161.44,108.61 164.64,108.61 165.66,109.63 167.73,109.63 173.47,115.37 173.47,125.82 175.49,127.84 175.49,128.21 175.82,128.54 176.71,128.54 178.27,130.1 178.27,134.15 180.04,135.92 180.04,140.25 179.18,141.11 177.75,141.11 177.72,141.07 175.05,141.07 174.94,141.18 174.27,141.18 173.55,140.46 173.55,140.24 173.78,140.01 173.78,139.71 173.89,139.6 174.18,139.6 174.26,139.68 v2(174.26,139.88)
  BOTTOM w0.112: CC6.2 138.46,105.22 138.46,105.41 v2(138.65,105.59) ; JDGFF2.A7 174.27,140.48 174,140.22 174,139.99 174.12,139.88 v2(174.26,139.88)
PEG_CTX_C_GRX_P1: length 78.1
  IN4 w0.084: v2(136.23,105.59) 136.58,105.93 136.58,106.22 136.65,106.29 136.65,107.17 137.08,107.6 148.82,107.6 151.4,110.18 157.04,110.18 158.7,108.52 160.45,108.52 161.18,109.24 164.38,109.24 165.4,110.27 167.47,110.27 172.83,115.63 172.83,123.72 172.32,124.23 172.32,125.89 173.53,127.09 173.53,127.53 175.17,129.17 176.44,129.17 177.15,129.88 177.15,133.93 179.4,136.18 179.4,139.99 178.92,140.47 178.02,140.47 177.98,140.44 175.82,140.44 175.73,140.36 175.73,140.05 v2(176.13,139.66)
  BOTTOM w0.112: v2(136.23,105.59) 136.41,105.41 136.41,105.22 136.07,104.87 CC8.2 ; v2(176.13,139.66) 175.76,140.02 175.76,140.24 176.07,140.54 JDGFF2.A4
PEG_CTX_C_GRX_P2: length 84.1
  IN4 w0.084: v2(175.47,142.25) 175.41,142.25 175.3,142.14 175.3,141.96 175.38,141.87 177.39,141.87 177.42,141.91 178.36,141.91 178.92,142.46 179.97,142.46 180.34,142.1 180.34,141.09 180.84,140.6 180.84,135.59 179.68,134.43 179.68,129.25 175.37,124.95 175.37,116.14 168.07,108.83 166,108.83 164.95,107.78 161.75,107.78 157.56,103.59 152.3,103.59 151.7,104.19 136.04,104.19 135.47,104.76 135.47,105.81 135.21,106.07 134.84,106.07 134.75,105.99 134.75,105.86 v2(134.96,105.65)
  BOTTOM w0.112: v2(134.96,105.65) 134.78,105.47 134.78,105.22 CC10.2 ; JDGFF2.B5 175.47,141.69 175.28,141.88 175.28,142.06 v2(175.47,142.25)
PEG_CTX_C_GRX_P3: length 76.9
  IN4 w0.084: v2(177.46,139.32) 177.25,139.12 177.25,138.58 177.07,138.4 171.47,138.4 170.81,137.74 170.81,135.86 171.01,135.66 171.01,131.96 170.81,131.75 170.81,127.13 170.97,126.97 170.97,123.58 171.48,123.06 171.48,116.19 166.91,111.62 164.69,111.62 164.05,110.99 159.32,110.99 158.94,111.37 157.42,111.37 156.7,110.64 153.97,110.64 153.51,111.1 151.66,111.1 148.62,108.06 133.67,108.06 132.91,107.3 132.91,105.83 v2(133.12,105.62)
  BOTTOM w0.112: v2(133.12,105.62) 132.95,105.45 132.95,105.22 CC12.2 ; JDGFF2.A1 177.87,140.46 177.68,140.27 177.68,140.02 177.28,139.61 177.28,139.51 v2(177.46,139.32)
PEG_CTX_C_GRX_P4: length 74.8
  IN4 w0.084: v2(131.3,105.65) 131.1,105.86 131.1,106.73 133.06,108.69 148.36,108.69 151.4,111.73 153.8,111.73 154.26,111.28 156.43,111.28 157.16,112 164.18,112 164.42,112.25 166.53,112.25 170.82,116.54 170.82,122.77 170.34,123.26 170.34,126.71 169.99,127.05 169.99,138.11 173.45,141.58 173.45,142.07 v2(173.66,142.28)
  BOTTOM w0.112: JDGFF2.B8 173.67,141.71 173.48,141.9 173.48,142.1 v2(173.66,142.28) ; CC14.2 131.12,105.22 131.12,105.47 v2(131.3,105.65)
PEG_CTX_C_GRX_P5: length 90.8
  IN4 w0.084: v2(177.26,142.31) 177.09,142.48 177.07,142.48 176.92,142.63 176.92,142.74 177.11,142.93 180.29,142.93 181.68,141.54 181.68,138.73 181.3,138.36 181.3,135.05 180.14,133.89 180.14,129.06 175.92,124.84 175.92,116.03 168.26,108.37 166.19,108.37 165.14,107.32 161.94,107.32 157.73,103.11 152.09,103.11 151.52,103.68 129.69,103.68 129.06,104.31 129.06,105.26 129.29,105.49 129.29,105.6 129.38,105.69 129.76,105.69 v2(129.82,105.62)
  BOTTOM w0.112: CC16.2 129.29,105.22 129.29,105.47 129.45,105.62 v2(129.82,105.62) ; v2(177.26,142.31) 177.26,142.25 177.08,142.06 177.08,141.85 177.27,141.66 JDGFF2.B2
PEG_CTX_C_GRX_P6: length 82.4
  IN4 w0.084: v2(176.06,142.9) 176.06,143.7 175.47,144.29 172.04,144.29 168.56,140.81 168.56,124.91 162.21,118.56 162.21,116.33 159.32,113.44 156.51,113.44 156.24,113.17 150.81,113.17 147.77,110.13 132.47,110.13 130.5,108.16 127.55,108.16 126.37,106.98 v2(125.5,106.98)
  BOTTOM w0.112: JDGFF2.C4 176.07,143.67 175.88,143.48 175.88,143.09 v2(176.06,142.9) ; v2(125.5,106.98) 125.68,106.8 126.46,106.8 126.82,106.43 126.85,106.43 127.27,106.02 127.27,105.89 127.47,105.69 127.47,105.22 CC18.2
PEG_CTX_C_GRX_P7: length 85.6
  IN4 w0.084: v2(174.26,142.94) 174.26,143.41 174.01,143.66 172.3,143.66 169.19,140.55 169.19,126.72 169.54,126.38 169.54,122.76 170.02,122.28 170.02,116.91 166.16,113.05 164.09,113.05 163.84,112.8 156.78,112.8 156.06,112.08 154.7,112.08 154.24,112.53 151.07,112.53 148.03,109.49 132.73,109.49 130.77,107.53 130.7,107.53 127.82,107.53 126.04,105.76 124.12,105.76 v2(124.01,105.86)
  BOTTOM w0.112: v2(124.01,105.86) 124.19,105.68 125.36,105.68 125.6,105.44 125.6,105.25 CC20.2 ; JDGFF2.C7 174.27,143.72 174.08,143.53 174.08,143.12 v2(174.26,142.94)
PEG_CTX_C_GRX_P8: length 163.8
  TOP w0.112: v2(179.04,191.04) 178.86,191.22 178.86,191.41 178.95,191.5 JCDRA.3
  IN1 w0.084: v2(121.49,98.27) 121.35,98.27 121.19,98.11 121.19,98 121.05,97.87 117.53,97.87 107.45,107.95 107.45,129.53 113.19,135.27 113.19,139.47 107.42,145.25 107.42,153.16 108.96,160.39 112.95,164.37 145.21,164.37 151.61,170.77 155.92,170.77 159.07,173.93 159.07,174.75 163.54,179.22 164.22,179.22 164.44,179.43 165.09,179.43 165.7,180.05 165.7,182.4 166.78,183.47 169.83,183.47 172.24,185.89 173.59,185.89 175.76,188.05 178.21,188.05 178.77,188.61 178.77,190.77 v2(179.04,191.04)
  BOTTOM w0.112: CC57.2 121.93,98.09 121.67,98.09 v2(121.49,98.27)
PEG_CTX_C_GRX_P9: length 162.9
  TOP w0.112: v2(177.84,191.01) 177.66,191.2 177.66,191.4 177.75,191.49 JCDRA.6
  IN1 w0.084: v2(177.84,191.01) 177.84,190.75 177.74,190.65 177.58,190.65 177.5,190.58 177.5,189.01 177.18,188.68 175.49,188.68 174.14,187.33 168.47,187.33 159.75,178.61 157.98,178.61 152.02,172.65 152.02,172.09 144.94,165.01 112.68,165.01 108.32,160.65 106.79,153.44 106.79,144.98 112.56,139.21 112.56,135.54 106.82,129.79 106.82,129.41 106.82,129.4 106.82,107.67 117.7,96.79 120.04,96.79 v2(120.35,97.1)
  BOTTOM w0.112: CC59.2 121.89,96.89 120.56,96.89 v2(120.35,97.1)
PEG_CTX_C_GRX_P10: length 164.3
  TOP w0.112: JCDRA.9 176.55,191.53 176.46,191.45 176.46,191.26 v2(176.64,191.08)
  IN1 w0.084: v2(121.49,95.93) 121.14,95.58 117.81,95.58 106.16,107.23 106.16,130.03 111.93,135.8 111.93,138.95 106.16,144.72 106.16,153.54 107.77,161.13 112.28,165.64 112.42,165.64 144.68,165.64 151.32,172.28 151.32,174.09 153.38,176.14 153.38,176.38 156.34,179.35 159.59,179.35 168.2,187.96 173.87,187.96 175.23,189.32 175.9,189.32 176.29,189.71 176.29,190.63 176.39,190.73 176.5,190.73 176.64,190.87 v2(176.64,191.08)
  BOTTOM w0.112: CC61.2 121.93,95.75 121.67,95.75 v2(121.49,95.93)
PEG_CTX_C_GRX_P11: length 165.2
  TOP w0.112: JCDRA.12 175.35,191.53 175.24,191.42 175.24,191.26 v2(175.43,191.08)
  IN1 w0.084: v2(120.41,94.83) 119.99,94.42 117.88,94.42 105.53,106.77 105.53,130.29 111.3,136.06 111.3,138.69 105.53,144.46 105.53,153.6 107.23,161.61 111.89,166.27 112.16,166.27 144.41,166.27 150.69,172.55 150.69,174.35 152.74,176.4 152.74,176.68 156.37,180.31 159.66,180.31 160.98,181.63 160.98,182.15 162.95,184.12 163.47,184.12 168.07,188.72 172.54,188.72 174.18,190.36 174.83,190.36 175.11,190.64 175.11,190.76 v2(175.43,191.08)
  BOTTOM w0.112: CC58.2 121.93,94.58 120.66,94.58 v2(120.41,94.83)
PEG_CTX_GRX_N0: length 26.8
  BOTTOM w0.112: UC1.T3 144.18,80.98 144.09,81.06 143.87,81.06 143.63,81.3 143.63,83.04 143.53,83.14 143.53,84.01 144.69,85.17 144.69,89.36 138.23,95.81 138.23,103.6 CC7.1
PEG_CTX_GRX_N1: length 26.4
  BOTTOM w0.112: UC1.R1 143.35,82.54 143.35,82.26 143.26,82.16 143.1,82.16 143.09,82.17 143.09,82.17 142.9,82.37 142.9,82.85 143.03,82.98 143.03,84.33 144.19,85.49 144.19,89.15 136.61,96.73 136.61,103.62 CC9.1
PEG_CTX_GRX_N2: length 26.9
  BOTTOM w0.112: UC1.P3 142.35,80.99 142.25,81.09 142.06,81.09 141.79,81.36 141.79,83.78 142.15,84.14 142.15,89.42 134.61,96.96 134.61,103.56 CC11.1
PEG_CTX_GRX_N3: length 26.4
  BOTTOM w0.112: UC1.N2 141.43,82.04 141.35,82.13 141.16,82.13 140.88,82.41 140.88,82.94 141.19,83.25 141.19,83.83 141.2,83.83 141.2,84.98 141.19,84.99 141.19,89.05 132.77,97.46 132.77,102.04 132.38,102.43 CC13.1
PEG_CTX_GRX_N4: length 27.4
  BOTTOM w0.112: UC1.M3 140.52,80.96 140.4,81.08 140.38,81.08 140.36,81.1 140.18,81.1 139.96,81.32 139.96,81.33 139.96,84.99 139.96,85.09 139.96,88.95 131.44,97.46 131.44,102.48 130.93,103 130.93,103.58 CC15.1
PEG_CTX_GRX_N5: length 26.9
  BOTTOM w0.112: CC17.1 129.03,103.66 129.03,98.67 139.12,88.57 139.12,83.02 139.05,82.95 139.05,82.28 139.35,81.98 139.52,81.98 139.61,81.89 UC1.L2
PEG_CTX_GRX_N6: length 28.2
  BOTTOM w0.112: UC1.K3 138.69,80.99 138.59,81.09 138.42,81.09 138.14,81.37 138.14,82.87 138.06,82.95 138.06,82.96 138.02,83 138.02,83.17 138.03,83.18 138.03,84.99 138.02,84.99 138.02,88.47 127.25,99.24 127.25,103.61 CC19.1
PEG_CTX_GRX_N7: length 27.5
  BOTTOM w0.112: UC1.J2 137.78,81.72 137.2,82.3 137.2,87.97 125.41,99.76 125.41,103.62 CC21.1
PEG_CTX_GRX_N8: length 25
  BOTTOM w0.112: UC1.H3 136.28,81.38 136.28,82.97 135.98,83.28 135.98,84.79 136.32,85.13 136.32,87.23 125.75,97.8 122.8,97.8 CC60.1
PEG_CTX_GRX_N9: length 22.2
  BOTTOM w0.112: UC1.G2 135.95,81.81 135.38,82.38 135.38,86.89 125.59,96.67 124.12,96.67 124.12,96.67 122.85,96.67 CC56.1
PEG_CTX_GRX_N10: length 21.5
  BOTTOM w0.112: UC1.F3 135.03,80.85 134.45,81.43 134.45,82.9 134.23,83.12 134.23,86.67 125.38,95.53 122.87,95.53 CC62.1
PEG_CTX_GRX_N11: length 18.9
  BOTTOM w0.112: CC63.1 125.6,94.16 133.37,86.38 133.37,85.01 133.62,84.77 133.62,82.6 134.12,82.1 UC1.E2
PEG_CTX_GRX_P0: length 26.8
  BOTTOM w0.112: CC6.1 138.45,103.6 138.45,95.9 144.91,89.45 144.91,85.08 143.74,83.91 143.74,83.23 143.84,83.13 143.84,81.39 143.96,81.28 144.13,81.28 144.26,81.4 144.26,81.63 UC1.T2
PEG_CTX_GRX_P1: length 26.4
  BOTTOM w0.112: CC8.1 136.39,103.61 136.39,96.64 143.97,89.06 143.97,85.58 142.81,84.42 142.81,83.06 142.68,82.93 142.68,82.84 142.68,82.83 142.68,82.82 142.68,82.44 142.68,82.43 142.68,82.29 142.88,82.08 142.88,82.07 143.01,81.94 143.2,81.94 143.26,81.88 UC1.R2
PEG_CTX_GRX_P2: length 26.9
  BOTTOM w0.112: UC1.P2 142.5,81.57 142.5,81.41 142.39,81.3 142.16,81.3 142.01,81.46 142.01,83.69 142.37,84.05 142.37,89.52 134.84,97.05 134.84,103.67 CC10.1
PEG_CTX_GRX_P3: length 26.4
  BOTTOM w0.112: CC12.1 133.32,103.94 133.32,103.58 133.2,103.46 132.72,103.46 132.61,103.35 132.61,102.52 132.99,102.14 132.99,97.55 141.41,89.14 141.41,83.17 141.1,82.85 141.1,82.5 141.19,82.4 141.33,82.4 141.43,82.5 UC1.N1
PEG_CTX_GRX_P4: length 27.3
  BOTTOM w0.112: CC14.1 131.15,103.64 131.15,103.09 131.66,102.58 131.66,97.55 140.18,89.04 140.18,85.09 140.18,84.99 140.18,83.25 140.18,81.4 140.27,81.31 140.54,81.31 140.65,81.42 140.65,81.43 140.65,81.58 UC1.M2
PEG_CTX_GRX_P5: length 26.8
  BOTTOM w0.112: CC16.1 129.25,103.57 129.25,98.76 139.34,88.66 139.34,82.94 139.27,82.86 139.27,82.38 139.45,82.19 139.56,82.19 139.67,82.3 139.67,82.56 UC1.L1
PEG_CTX_GRX_P6: length 28.1
  BOTTOM w0.112: CC18.1 127.47,103.62 127.47,99.33 138.24,88.56 138.24,85.2 138.23,85.19 138.23,83.09 138.35,82.96 138.35,81.45 138.5,81.3 138.69,81.3 138.81,81.43 138.81,81.6 UC1.K2
PEG_CTX_GRX_P7: length 27.5
  BOTTOM w0.112: CC20.1 125.63,103.6 125.63,99.85 137.42,88.06 137.42,82.39 137.6,82.22 137.77,82.22 137.87,82.32 137.87,82.54 UC1.J1
PEG_CTX_GRX_P8: length 25
  BOTTOM w0.112: UC1.H2 136.86,81.55 136.76,81.44 136.64,81.44 136.5,81.57 136.5,83.06 136.2,83.37 136.2,84.7 136.54,85.04 136.54,87.32 125.84,98.02 122.9,98.02 CC57.1
PEG_CTX_GRX_P9: length 22.2
  BOTTOM w0.112: UC1.G1 135.95,82.47 135.83,82.35 135.72,82.35 135.6,82.47 135.6,86.98 125.68,96.9 124.12,96.9 124.12,96.9 122.85,96.9 CC59.1
PEG_CTX_GRX_P10: length 21.5
  BOTTOM w0.112: UC1.F2 135.03,81.54 134.92,81.43 134.76,81.43 134.67,81.53 134.67,82.99 134.45,83.21 134.45,86.76 125.47,95.75 122.83,95.75 CC61.1
PEG_CTX_GRX_P11: length 18.9
  BOTTOM w0.112: UC1.E1 133.95,82.63 133.84,82.74 133.84,84.86 133.6,85.1 133.6,86.48 125.69,94.38 123.45,94.38 123.33,94.49 123.33,94.83 123.18,94.98 123.02,94.98 122.78,94.74 CC58.1
PEG_RCOMP: length 3
  TOP w0.127: v2(139.11,76.65) 139.62,76.65 140.33,75.94 RC14.2
  BOTTOM w0.102: UC1.L7 v2(139.11,76.65)
PEX_RST#: length 165.2
  TOP w0.089: UH1.BB16 284.21,61.55 284.04,61.38 v2(283.91,61.38)
  IN2 w0.104: v2(176.75,124.17) 176.75,122.88 188.31,111.32 188.31,108.78 191.12,105.96 191.12,105.59 194.06,102.65 211.73,102.65 212.71,101.67 237.23,101.67 237.73,101.17 254.08,101.17 254.66,100.59 258.99,100.59 260.11,99.46 v2(262.28,99.46)
  BOTTOM w0.112: v2(262.28,99.46) 262.47,99.28 278.03,99.28 284.64,92.67 v1(284.64,84.29) 285.21,83.72 286.73,83.72 290.29,80.16 290.29,70.74 289.1,69.56 285.82,69.56 284.95,68.68 284.95,66.69 284.02,65.76 284.02,61.5 v2(283.91,61.38) ; v2(176.75,124.17) 176.07,124.84 JDGFF1.A4
PGOOD_1.2V: length 4.4
  TOP w0.112: v1(220.59,111.56) 220.59,113.6 220.25,113.94 PR210.2
  TOP w0.254: PR210.2 220.12,114.42 PU201.10
PGOOD_VCCSA: length 1.4
  BOTTOM w0.254: PUA01.12 131.1,117.21 131.62,117.73 PRA20.2
PM_DOWN_R: length 22.9
  TOP w0.102: 129.82,77.27 131,76.1 132.23,76.1 132.71,76.57 v2(132.71,76.61)
  TOP w0.112: RC5.1 120.88,85.11 122.26,85.11 124.12,86.97 127.92,86.97 128.97,85.92 v1(128.97,80.29) 128.97,78.12 129.82,77.27
  BOTTOM w0.102: UC1.D8 132.83,76.61 v2(132.71,76.61)
PM_SLP_S3#: length 438
  TOP w0.089: v2(272.62,64.55) 272.62,63.76 272.42,63.57 UH1.BF42
  TOP w0.112: v2(283.43,24.01) 285.44,21.99 RE679.1 ; v2(170.52,30.5) 170.52,30.25 v1(170.91,29.87) 171.36,29.41 RC685.2
  TOP w0.127: QE1.5 v2(355.37,42.26)
  TOP w0.254: v2(203.92,130.12) 203.92,130.36 PQ710.2
  IN1 w0.084: v2(355.37,42.26) 355.65,41.99 355.65,34.88 355.3,34.53 355.3,32.92 354.91,32.54 354.91,22.27 351.36,18.72 v2(351.36,18.49)
  IN3 w0.104: v2(351.36,18.49) 345.35,12.48 329.39,12.48 326.33,15.53 307.27,15.53 306.14,16.66 298.93,16.66 v2(298.6,16.33) ; v2(298.7,20.01) 298.54,19.85 295.09,19.85 295.05,19.89 291.45,19.89 290.76,20.58 289.85,20.58 289.67,20.41 288.1,20.41 286.95,21.56 286.52,21.56 284.82,23.26 284.17,23.26 v2(283.43,24.01) 283.43,24.16 282.69,24.9 271.76,24.9 270.4,23.54 268.16,23.54 260.32,15.7 239.59,15.7 235.83,11.94 228.98,11.94 228.43,11.38 223.99,11.38 223.52,10.91 197.47,10.91 196.13,12.25 189.72,12.25 186.7,9.23 181.35,9.23 180.02,7.9 176.29,7.9 v2(176.11,7.71)
  IN3 w0.254: v2(200.57,112.62) 200.57,116.15 201.4,116.98 201.4,127.6 v2(203.92,130.12)
  BOTTOM w0.112: v2(272.62,64.55) 272.93,64.55 273.87,63.62 273.87,61.42 274.29,61 274.29,60.26 274.35,60.2 274.35,59.52 274.11,59.27 273.6,59.27 273.25,59.62 272.93,59.62 272.04,58.73 272.04,58.62 271.39,57.97 271.39,57.57 268.95,55.12 268.95,52.95 268.48,52.48 268.48,52.39 267.98,51.89 267.98,51.52 266.8,50.34 266.8,49.16 266.52,48.88 266.52,48.29 264.69,46.45 264.69,45.89 265.26,45.32 265.26,44.9 267.33,42.84 267.33,37.28 268.53,36.07 268.53,34.24 269.75,33.02 272.16,33.02 275.67,29.5 278.7,29.5 283.54,24.66 283.54,24.12 v2(283.43,24.01) ; v2(200.57,112.62) 199.86,111.91 199.86,108.86 197.96,106.96 185.2,106.96 182.89,104.65 182.89,101.61 179.47,98.19 179.47,37.35 172.24,30.12 170.91,30.12 v2(170.52,30.5) 170.15,30.13 170.15,18.12 176.11,12.15 v2(176.11,7.71) ; v2(298.6,16.33) 298.6,19.91 v2(298.7,20.01) 298.7,20.65 297.1,22.26 Q8.2
  BOTTOM w0.254: v2(203.92,130.12) 204.69,130.12 PRS98.1
PM_SLP_S3_H: length 10.3
  BOTTOM w0.112: Q7.2 294.28,21.81 293.24,20.77 293.24,20.26 293.47,20.02 293.59,20.02 294.06,19.56 R307.2 Q7.5 294.28,20.85 294.95,21.52 296.02,21.52 296.45,21.09 Q8.6 Q8.5 v1(297.1,19.33)
PM_SLP_S3_R#: length 8.3
  TOP w0.112: UE5.6 290.63,21.88 290.17,22.34 287.22,22.34 286.87,21.99 RE679.2 286.26,22.47 285.89,22.84 CE41.1 v1(284.89,23.58)
PM_SLP_S4#: length 262
  TOP w0.089: UH1.BE42 272,63.07 271.38,63.68 271.38,65.01 v2(271.02,65.38)
  TOP w0.112: Q9.2 209.65,103.6 210.4,104.35 v1(211.74,104.35) 213.05,104.35 v2(213.65,103.75) ; RE680.1 311.09,14.29 v2(311.15,14.22)
  IN2 w0.104: v2(271.02,65.38) 272.26,66.62 272.26,67.18 272.79,67.71 272.79,68.37 272.13,69.03 272.13,75 271.92,75.21 271.92,77.23 270.25,78.89 270.25,83.8 271.4,84.94 271.4,98.77 267.64,102.52 258.44,102.52 257.83,101.91 255.22,101.91 254.63,102.5 238.28,102.5 237.79,103 214.4,103 v2(213.65,103.75)
  IN3 w0.104: v2(245.64,12.9) 245.82,12.73 248.82,12.73 249.9,11.64 252.7,11.64 253.57,12.52 256.9,12.52 257.97,11.45 260.68,11.45 263.05,13.82 263.05,14.72 268.82,20.49 282.09,20.49 287.78,14.8 291.97,14.8 292.39,15.21 294.25,15.21 295.03,14.43 310.35,14.43 310.56,14.22 v2(311.15,14.22)
  IN4 w0.084: v2(271.02,65.38) 268.01,65.38 265.14,62.51 263.08,62.51 262.51,63.08 261.79,63.08 260.97,62.27 260.97,58.77 259.95,57.74 257.97,57.74 255.86,55.64 255.86,49.77 255.8,49.71 255.8,48.46 v2(255.89,48.37)
  BOTTOM w0.112: PR2501.2 247.08,18.06 248.09,17.05 248.09,14.43 246.55,12.9 v2(245.64,12.9) 245.63,12.9 245.32,12.59 245.32,11.91 245.58,11.64 246.27,11.64 247.68,13.05 248.88,13.05 249.43,12.5 250.11,12.5 250.64,13.03 251.12,13.03 253.62,15.53 253.62,25.57 255.96,27.91 255.96,35.04 255.52,35.49 255.52,46.57 255.38,46.71 255.38,47.91 255.84,48.37 v2(255.89,48.37)
PM_SLP_S4_H: length 2.9
  TOP w0.112: v1(210.64,99.34) R325.2 210.64,101.1 Q9.6 Q9.5
PM_SLP_S4_R#: length 6.1
  TOP w0.112: UE5.73 308.13,14.68 308.14,14.66 309.27,14.66 309.64,14.29 RE680.2 309.87,14.14 310.1,13.91 310.53,13.91 310.76,13.68 312,13.68 v1(312.51,14.18)
PM_SLP_S5#: length 171.4
  TOP w0.089: v2(272.94,62.49) 272.9,62.44 272.43,62.44 272.34,62.35 UH1.BC42
  TOP w0.112: RE678.1 286.39,18.29 282.16,22.52 281.38,22.52 v1(280.95,22.95) 280.73,23.17 v2(280.73,24.4)
  IN3 w0.104: v2(349.9,34.01) 350.71,33.2 353.39,33.2 355.03,31.55 355.03,22.66 351.5,19.13 351.1,19.13 344.91,12.94 329.58,12.94 326.37,16.14 314.41,16.14 311.92,18.63 307.18,18.63 306.07,19.74 305.59,19.74 304.83,18.98 302.75,18.98 302.48,19.26 296.34,19.26 295.48,18.4 291.42,18.4 290.61,19.2 287.94,19.2 287.29,19.85 286.06,19.85 283.3,22.62 281.28,22.62 280.73,23.17 v2(280.73,24.4)
  BOTTOM w0.112: v2(272.94,62.49) 270.26,65.17 268.06,65.17 267.49,64.6 267.49,58.42 265.63,56.57 265.63,55.53 264.26,54.15 264.26,51.23 263.23,50.21 263.23,47.92 262.61,47.3 262.61,40.11 265.29,37.43 265.29,35.1 268.81,31.59 271.56,31.59 275.08,28.07 277.83,28.07 280.73,25.17 v2(280.73,24.4)
  BOTTOM w0.127: v2(349.9,34.01) 349.76,33.86 QE4.5
PM_SLP_S5_R#: length 22.4
  TOP w0.112: v1(287.49,17.3) 287.94,17.74 v2(287.94,17.78) 287.92,17.8 RE678.2 288.62,18.29 CE45.1 ; UE5.108 301.14,23.34 300.68,22.88 298.74,22.88 297.61,21.75 297.61,18.62 v2(296.24,17.24)
  IN3 w0.104: v2(296.24,17.24) 296.01,17.47 291.04,17.47 290.23,18.27 288.44,18.27 v2(287.94,17.78)
POK: length 96.1
  TOP w0.112: v2(320.04,18.74) 320.04,17.92 318.02,15.9 318.02,7.83 v1(317.87,7.68) v2(313.69,3.5) ; DE2.1 308.13,27.04 v2(307.79,26.69) ; DE3.1 288.21,7.8 v2(287.6,7.19)
  TOP w0.203: PU301.7 329.43,40.3 329.89,40.76 v2(330.17,40.76)
  IN1 w0.084: v2(313.69,3.5) 311.42,5.77 291.77,5.77 290.74,6.8 287.99,6.8 v2(287.6,7.19)
  IN4 w0.084: v2(320.04,18.74) 320.04,18.7 319.56,18.22 314.41,18.22 312.34,20.29 312.34,23.75 309.39,26.69 v2(307.79,26.69)
  BOTTOM w0.254: v2(330.17,40.76) 330.17,39.16 330.75,38.58 330.75,36.74 330.11,36.1 330.11,35.44 327.38,32.71 327.38,22.64 323.75,19.01 320.32,19.01 v2(320.04,18.74)
POW_EXT_SWR: length 18.8
  TOP w0.112: v2(178.52,164.36) 178.34,164.18 v1(178.34,163.15) 178.79,163.15 179.59,163.96 UL1.67 ; UL13.7 v2(164.67,163.34)
  IN3 w0.104: v2(178.52,164.36) 174.09,164.36 173.45,165 168.5,165 166.84,163.34 v2(164.67,163.34)
POW_MODE1: length 7
  TOP w0.112: v1(179.73,159.09) 178.9,159.93 178.72,159.93 RL3.2
  TOP w0.203: 179.29,163.22 179.35,163.22 179.7,163.57 179.74,163.57 179.95,163.77 179.95,163.81 179.99,163.86 UL1.68
  TOP w0.254: RL3.2 178.52,160 178.52,160.04 177.99,160.58 177.99,161.62 RL4.2 178.52,162.45 179.29,163.22
POWER_LED: length 305.7
  TOP w0.112: QE8.2 176.76,188.54 RE28.2 176.53,189.23 177.35,190.05 v1(180.18,190.05) 180.46,190.05 v2(181.28,189.23)
  IN1 w0.084: v2(349.87,34.62) 349.87,35.2 350.48,35.81 350.48,37.19 350.48,39.22 349.19,40.51 349.19,49.26 349.25,49.31 349.25,50.71 347.97,51.99 347.79,51.99 339.09,51.99 338,50.89 336.64,50.89 336.33,51.2 336.33,52.16 335.37,53.11 332.72,53.11 324.39,55.64 322.07,56.6 307.54,56.6 303.24,60.9 303.24,62.3 303.11,62.42 302.39,63.14 302.39,63.34 300.73,65 300.73,65.77 293.31,73.2 293.31,76.5 292.54,77.26 292.54,80.2 291.61,81.13 291.61,87.21 291.49,87.33 282.18,96.64 282.18,99.48 282.18,99.66 282.05,99.78 279.69,102.15 276.71,102.15 268.19,110.66 268.19,110.93 267.96,111.16 267.48,111.16 v2(267.36,111.28)
  IN2 w0.104: v2(181.28,189.23) 181.17,189.12 181.17,181.76 181.4,181.53 181.4,179.8 180.65,179.05 180.65,175.32 178.86,173.53 176.85,173.53 175.8,172.48 175.8,167.36 176.39,166.77 176.39,161.47 176.94,160.91 179.64,160.91 181.05,159.51 181.05,155.71 185.1,151.65 185.1,138.79 185.85,138.04 185.85,130.09 189.24,126.7 189.24,120.47 191.96,117.75 196.67,117.75 200.85,113.57 246.89,113.57 247.65,112.82 265.82,112.82 v2(267.36,111.28)
  BOTTOM w0.127: v2(349.87,34.62) 349.11,33.86 QE4.6
PQ6A_GATE: length 9.8
  BOTTOM w0.254: PQ11.2 154.16,161.15 152.3,159.29 152.3,158.05 151.87,157.62 151.17,157.62 v1(151.03,157.76) 150.78,158.01 PR21.1 150.78,159.85 PQ6.2 150.79,159.97 150.33,160.42 149.94,160.42 149.93,160.41 PC15.2
PQ10A_GATE: length 1.2
  BOTTOM w0.112: PQ12.2 v1(146.36,169.86)
PQS32_2: length 115.3
  IN3 w0.254: v2(128.13,132.22) 128.63,132.22 128.75,132.1 132.87,132.1 133.51,132.74 133.51,142.52 134.96,143.98 134.96,145.01 136.03,146.07 143.22,146.07 143.73,146.58 150.54,146.58 151.06,146.06 154.28,146.06 155.02,146.8 158.62,146.8 159.51,145.91 168.39,145.91 170.84,143.47 170.84,142.87 172.46,141.25 179.98,141.25 180.43,141.7 180.43,142.76 180.99,143.32 183.89,143.32 185.17,144.61 189.98,144.61 196.1,138.49 199.44,138.49 201.3,136.63 201.3,135.77 202.18,134.88 202.66,134.88 204.05,133.5 204.05,132.53 203.76,132.24 203.76,130.64 v2(203.21,130.09)
  BOTTOM w0.254: v2(203.21,130.09) 203.21,130.43 203.81,131.04 PRS98.2 v1(206.21,131.04) 211.43,136.26 PRS99.2 ; PQS32.2 v2(128.13,132.22)
